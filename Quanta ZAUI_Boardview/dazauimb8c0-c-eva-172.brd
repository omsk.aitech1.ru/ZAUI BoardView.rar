# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD7: length 25.3
  IN3 w0.14: v2(117.94,97.37) 118.35,96.96 119.24,96.96 120.33,95.87 124.27,95.87 125.66,94.47 125.66,91.3 128.2,88.76 130.23,88.76 130.59,88.4 131.04,88.4 132.21,87.23 v2(132.21,87.01)
  BOTTOM w0.127: 116.93,96.46 116.85,96.38 115.38,96.38 114.93,96.83 U22.F26 ; v2(132.21,87.01) 132.61,86.61 VRAM2.K5
  BOTTOM w0.165: v2(117.94,97.37) 117.94,96.91 117.49,96.46 116.93,96.46
FBA_CMD8: length 32.5
  IN3 w0.14: v2(133.01,86.21) 133.18,86.21 133.41,86.44 133.41,87.97 131.58,89.81 130.21,89.81 129.22,90.79 129.22,91.3 129.42,91.5 129.42,95.54 127.19,97.78 120.92,97.78 120.46,98.23 117.36,98.23 117.16,98.04 115.89,98.04 115.3,97.45 115.3,96.7 114.88,96.28 113.32,96.28 112.94,96.66 v2(112.94,96.73)
  BOTTOM w0.127: U22.F23 112.54,97.13 v2(112.94,96.73) ; v2(133.01,86.21) 133.41,85.81 VRAM2.J4
FBA_CMD9: length 33.3
  IN3 w0.14: v2(111.32,97.55) 111.72,97.15 111.72,96.48 111.95,96.25 112.33,96.25 112.56,96.02 112.56,95.64 112.76,95.44 114.69,95.44 115.76,96.51 115.76,97.52 116.03,97.8 120.08,97.8 120.71,97.17 125.77,97.17 127.8,95.13 127.8,92.79 128.62,91.97 128.62,90 129.04,89.58 131.16,89.58 133.01,87.73 v2(133.01,87.01)
  BOTTOM w0.127: v2(133.01,87.01) 133.41,86.61 VRAM2.J5 ; v2(111.32,97.55) 111.69,97.92 U22.G22
FBA_CMD10: length 33
  IN3 w0.14: v2(112.11,97.55) 112.17,97.55 112.58,97.14 114.62,97.14 115.77,98.29 117.04,98.29 117.44,98.69 120.81,98.69 121.17,98.33 127.52,98.33 131.01,94.84 131.01,91.54 131.15,91.41 131.91,91.41 132.01,91.3 132.01,90.02 134.21,87.82 134.21,86.61 v2(133.81,86.21)
  BOTTOM w0.127: v2(112.11,97.55) 112.49,97.93 U22.G23 ; v2(133.81,86.21) 134.21,85.81 VRAM2.H4
FBA_CMD11: length 30.9
  IN3 w0.14: v2(134.61,87.01) 134.61,87.01 134.61,88.02 132.61,90.02 132.61,94.4 128.1,98.92 121.4,98.92 121.17,99.15 117.38,99.15 116.77,98.54 115.63,98.54 114.64,97.55 v2(113.73,97.55)
  BOTTOM w0.102: U22.G24 113.35,97.93 v2(113.73,97.55)
  BOTTOM w0.127: VRAM2.H5 134.21,86.61 134.61,87.01 v2(134.61,87.01)
FBA_CMD12: length 26.9
  IN3 w0.14: v2(116.77,97.37) 116.77,97.27 118.24,95.81 118.49,95.81 120.97,93.33 122.01,93.33 127.21,88.12 129.35,88.12 129.86,87.62 130.36,87.62 130.74,87.24 130.74,86.09 131.03,85.81 132.4,85.81 132.61,85.6 132.61,85.14 132.75,85 135,85 v2(135.41,85.41)
  BOTTOM w0.127: U22.F27 115.94,96.92 116.43,96.92 116.77,97.27 v2(116.77,97.37) ; VRAM2.G3 135.01,85.01 v2(135.41,85.41)
FBA_CMD13: length 35.4
  IN3 w0.14: v1(119.95,100.09) 120.4,100.54 128.23,100.54 134.05,94.73 134.05,91.43 134.21,91.26 134.21,89.74 135.01,88.94 135.01,86.04 134.78,85.81 134.21,85.81 v2(133.81,85.41)
  BOTTOM w0.127: VRAM2.J2 133.81,84.6 v2(133.81,85.41)
  BOTTOM w0.165: v1(119.95,100.09) 119.95,99.94 R526.2 118.93,98.92 116.78,98.92 116.24,98.39 114.59,98.39 114.14,97.93 U22.G25
FBA_CMD14: length 28.3
  IN3 w0.14: v2(119.7,97.37) 120.53,96.53 124.88,96.53 126.55,94.86 126.55,94.22 126.93,93.84 126.93,92.32 127.82,91.43 127.82,89.98 128.66,89.14 130.5,89.14 130.78,88.86 131.23,88.86 132.61,87.48 132.61,86 133.01,85.6 v2(133.01,85.41)
  BOTTOM w0.127: v2(133.01,85.41) 133.41,85.01 VRAM2.J3 ; U22.G27 115.83,98.03 116.65,98.03
  BOTTOM w0.165: 116.65,98.03 118.3,98.03 118.43,97.9 119.21,97.9 119.7,97.42 v2(119.7,97.37) 119.85,97.52 119.85,97.94 R527.2
FBA_CMD15: length 24.4
  IN3 w0.14: v2(116.19,97.37) 116.19,97.37 116.22,97.34 116.22,97.19 120.64,92.77 121.75,92.77 126.96,87.57 129.27,87.57 129.6,87.24 129.6,86.22 130.21,85.61 130.21,85.13 130.39,84.95 131.76,84.95 v2(132.21,85.41)
  BOTTOM w0.102: 115.65,97.52 115.24,97.93 U22.G26
  BOTTOM w0.127: v2(132.21,85.41) 131.81,85 VRAM2.L3 ; v2(116.19,97.37) 116.19,97.37 116.04,97.52 115.65,97.52
FBA_CMD16: length 26.9
  TOP w0.114: 132.62,109.71 132.62,108.22 v2(132.21,107.81)
  TOP w0.165: 132.62,109.71 132.62,109.76 131.94,110.45 126.48,110.45 121.09,105.06 121.09,103.82 120,102.73 v1(119.82,102.73) 119.52,102.42 118.25,102.42 117.87,102.05 114.17,102.05 v2(113.73,102.49)
  BOTTOM w0.127: VRAM1.G12 131.81,107.4 v2(132.21,107.81) ; U22.M24 113.33,102.12 113.7,102.49 v2(113.73,102.49)
FBA_CMD17: length 25.1
  TOP w0.165: v2(112.92,102.49) 113.62,101.78 118.15,101.78 118.31,101.94 119.98,101.94 121.98,103.95 121.98,105.19 126.71,109.92 131.66,109.92 132.12,109.46 v2(132.21,109.46)
  BOTTOM w0.127: v2(112.92,102.49) 112.53,102.1 U22.M23 ; v2(132.21,109.46) 132.21,109.41 132.61,109.01 VRAM1.H10
FBA_CMD18: length 26.1
  IN3 w0.14: v2(132.21,108.62) 132.61,108.22 132.61,105.11 131.89,104.38 122.26,104.38 119.67,101.79 119.52,101.79 118.2,100.47 116.77,100.47 116.47,100.16 115.21,100.16 v2(114.53,100.85)
  BOTTOM w0.102: U22.K24 113.64,100.41 114.06,100.82 114.5,100.82 v2(114.53,100.85)
  BOTTOM w0.127: v2(132.21,108.62) 132.21,108.61 132.61,108.21 VRAM1.H11
FBA_CMD19: length 29.6
  IN3 w0.14: v2(112.93,100.01) 112.93,99.84 113.35,99.43 113.35,99.02 113.57,98.79 113.98,98.79 114.15,98.96 114.15,99.59 114.46,99.91 116.69,99.91 116.9,100.13 118.36,100.13 119.57,101.33 119.82,101.33 121.78,103.29 132.45,103.29 133.28,104.13 133.28,106.92 133.67,107.3 133.67,108.47 v2(133.81,108.62)
  BOTTOM w0.102: U22.K23 v2(112.93,100.01)
  BOTTOM w0.127: VRAM1.K11 134.21,108.21 133.81,108.61 v2(133.81,108.62)
FBA_CMD20: length 23.9
  TOP w0.165: v2(116.25,102.61) 116.25,102.69 116.67,103.11 117.56,103.11 117.79,102.88 119.04,102.88 119.7,103.54 119.7,104.43 126.25,110.98 132.52,110.98 133.81,109.69 v2(133.81,109.46)
  BOTTOM w0.127: VRAM1.K10 134.21,109.01 133.81,109.41 v2(133.81,109.46) ; v2(116.25,102.61) U22.M27
FBA_CMD21: length 29
  TOP w0.127: v2(135.41,107.81) 135.81,108.21 135.81,109.71
  TOP w0.165: v2(115.34,102.55) 116.53,103.75 117.79,103.75 118.12,103.41 118.73,103.41 119.06,103.75 119.06,104.56 126.02,111.52 133.64,111.52 v1(133.69,111.47) 134.06,111.47 135.81,109.71
  BOTTOM w0.127: v2(115.34,102.55) 114.93,102.14 U22.M26 ; v2(135.41,107.81) 135.01,107.41 VRAM1.L12
FBA_CMD22: length 29.1
  IN3 w0.14: v2(134.61,113.4) 134.61,113.41 134.21,113.8 132.68,113.8 132.01,113.14 132.01,112.25 131.65,111.89 129.87,111.89 129.6,112.15 124.42,112.15 117.79,105.52 117.79,103.49 117.99,103.29 117.99,102.58 117.56,102.14 114.82,102.14 v2(114.5,102.46)
  BOTTOM w0.127: v2(114.5,102.46) U22.M25 ; v2(134.61,113.4) 134.61,113.41 134.22,113.8 VRAM1.K4
FBA_CMD23: length 26.8
  IN3 w0.14: v2(115.5,100.88) 115.97,100.42 116.37,100.42 116.77,100.82 118.06,100.82 121.09,103.86 121.09,104.68 122.62,106.21 123.66,106.21 126.96,109.51 128.36,109.51 128.73,109.89 132.95,109.89 134.43,111.37 134.43,111.87 134.61,112.06 v2(134.61,112.61)
  BOTTOM w0.127: v2(134.61,112.61) 134.61,112.61 134.22,113 VRAM1.K5 ; v2(115.5,100.88) 115.46,100.88 114.99,100.41 U22.K26
FBA_CMD24: length 30.8
  IN3 w0.14: v2(112.11,100.01) 112.11,100.01 111.69,100.43 111.69,101 111.95,101.26 112.36,101.26 113.33,102.23 113.33,102.71 113.54,102.93 114.3,102.93 115.31,103.94 115.31,104.82 123.76,113.27 126.12,113.27 126.4,112.99 130.08,112.99 130.21,113.12 130.21,113.75 131.05,114.59 132.63,114.59 v2(133.01,114.21)
  BOTTOM w0.127: VRAM1.J4 133.41,113.81 133.01,114.21 v2(133.01,114.21) ; v2(112.11,100.01) 112.11,100.01 111.71,100.41 U22.K22
FBA_CMD25: length 31.6
  IN3 w0.14: v2(133.8,112.61) 133.8,112.62 133.42,113 132.76,113 132.59,112.83 132.59,111.94 132.24,111.59 127.79,111.59 127.5,111.3 126.21,111.3 123.1,108.19 121.35,108.19 118.83,105.67 118.83,103.05 117.61,101.84 113.32,101.84 112.51,101.03 112.51,99.61 v2(112.93,99.19)
  BOTTOM w0.127: U22.J23 112.53,99.59 v2(112.93,99.19) ; v2(133.8,112.61) 133.8,112.62 133.42,113 VRAM1.J5
FBA_CMD26: length 30.3
  IN3 w0.14: v2(133.01,113.4) 133.02,113.41 133.66,113.41 134.2,112.86 134.2,112.32 133.81,111.93 133.81,111.61 132.66,110.46 128.48,110.46 128.15,110.12 126.76,110.12 123.56,106.92 122.01,106.92 119.73,104.64 119.73,103.1 117.97,101.33 114.11,101.33 113.73,100.95 v2(113.73,100.01)
  BOTTOM w0.102: U22.J25 v2(113.73,100.01)
  BOTTOM w0.127: VRAM1.H4 132.62,113.8 133.01,113.41 v2(133.01,113.4)
FBA_CMD27: length 29.6
  IN3 w0.14: v2(113.75,99.19) 113.75,99.41 113.33,99.82 113.33,101.32 113.6,101.59 117.71,101.59 119.17,103.04 119.17,105.12 121.6,107.56 123.35,107.56 126.48,110.68 127.83,110.68 128.18,111.03 132.42,111.03 133.01,111.62 v2(133.01,112.6)
  BOTTOM w0.127: VRAM1.H5 132.62,113 133.01,112.61 v2(133.01,112.6) ; U22.J24 v2(113.75,99.19)
FBA_CMD28: length 26.2
  IN3 w0.14: v2(131.41,114.19) 131.41,114 131.01,113.6 131.01,112.39 130.82,112.2 130.11,112.2 129.6,112.71 124.09,112.71 116.96,105.58 116.96,103.3 117.44,102.83 v2(117.44,102.6)
  BOTTOM w0.127: 117.44,102.5 v2(117.44,102.6) ; VRAM1.G3 131.81,114.6 131.41,114.21 v2(131.41,114.19) ; 116.65,100.82 116.23,100.41 U22.K27
  BOTTOM w0.165: 116.65,100.82 117.44,101.61 117.44,102.5
FBA_CMD29: length 29.1
  TOP w0.165: v2(133.01,114.99) 133.01,114.88 132.57,114.44 132.57,112.31 132.32,112.05 125.79,112.05 121.42,107.68 120.97,107.68 R29.1 118.43,105.13 v2(118.43,103.87)
  BOTTOM w0.127: VRAM1.J2 133.41,115.4 133.01,115.01 v2(133.01,114.99) ; U22.K25 114.5,100.04 116.37,100.04 116.6,100.27 116.65,100.27
  BOTTOM w0.165: 116.65,100.27 116.85,100.27 118.04,101.46 118.04,103.49 v2(118.43,103.87)
FBA_CMD30: length 34.6
  IN3 w0.14: v2(133.81,114.21) 133.97,114.21 134.38,114.62 135.62,114.62 135.81,114.43 135.81,107.29 134.81,106.29 134.81,103.97 133.01,102.17 122.57,102.17 121.75,101.36 v2(121.42,101.36)
  BOTTOM w0.127: U22.J27 115.8,99.68 116.52,99.68 ; VRAM1.J3 133.8,114.21 v2(133.81,114.21)
  BOTTOM w0.165: 116.52,99.68 117.92,99.68 118.67,100.43 R525.1 119.61,100.43 119.89,100.71 120.6,100.71 121.25,101.36 v2(121.42,101.36)
FBA_CMD31: length 32.5
  IN3 w0.14: v2(134.61,114.21) 134.61,114.21 135.01,113.81 135.01,107.46 134.24,106.69 134.24,104.27 132.7,102.73 122.01,102.73 120.28,101 119.92,101 118.86,99.94 118.55,99.94 118.42,99.8 117.03,99.8 116.88,99.66 115.71,99.66 v2(115.32,99.26)
  BOTTOM w0.127: VRAM1.L3 135,114.6 134.61,114.21 v2(134.61,114.21) ; v2(115.32,99.26) 115.28,99.26 U22.J26
FBA_DBI0: length 36.8
  TOP w0.127: v2(109.5,95.82) 109.7,95.61 109.7,94.31 110.01,94 110.01,93.51 110.86,92.65 110.86,91.75 112.05,90.56 122.32,90.56 v1(124.26,88.62) 126.3,86.58 126.3,85.16 127,84.46 136.14,84.46 136.8,83.81 v2(137.81,83.81)
  BOTTOM w0.165: v2(137.81,83.81) 137.42,84.2 VRAM2.D2 ; v2(109.5,95.82) 109.47,95.82 109.15,95.5 U22.D19
FBA_DBI1: length 38.7
  IN1 w0.114: v2(105.45,95.87) 105.81,96.24 106.47,96.24 106.67,96.43 106.67,97.01 106.77,97.12 109.15,97.12 109.21,97.06 109.86,97.06 109.92,97.12 111.91,97.12 111.93,97.14 115.03,97.14 115.66,97.78 121.47,97.78 122.16,98.46 132.49,98.46 132.92,98.03 135.82,98.03 137.42,96.44 137.42,93.81 v2(137.01,93.41)
  BOTTOM w0.165: VRAM2.D13 137.41,93.01 v2(137.01,93.41) ; U22.D14 105.03,95.45 v2(105.45,95.87)
FBA_DBI2: length 28.1
  IN1 w0.114: v2(129.01,92.61) 128.7,92.29 127.8,92.29 127.06,91.55 126.3,91.55 124.5,89.75 110.2,89.75 109.26,90.69 107.4,90.69 107,91.1 v2(107,91.55)
  BOTTOM w0.102: v2(107,91.55) 107.22,91.77 107.22,93.64 107.17,93.69 107.17,93.97 107.51,94.32 U22.C17
  BOTTOM w0.165: VRAM2.P13 129.41,93 v2(129.01,92.61)
FBA_DBI3: length 25.3
  BOTTOM w0.089: VRAM2.P2 129.04,84.57 128.46,84.57 128.34,84.69 126.69,84.69 126.3,85.08
  BOTTOM w0.127: 126.3,85.08 126.2,85.18 126.2,87.19 122.27,91.12 v1(119.78,91.12) 117.06,91.12 116.52,90.59 113.32,90.59 112.01,91.91 112.01,92.5 112.27,92.76 112.27,93.47 112.08,93.66 112.08,94.09 111.63,94.54 U22.C22
FBA_DBI4: length 28
  IN1 w0.114: v2(113.73,104.07) 114.05,103.74 114.36,103.74 114.96,103.15 117.67,103.15 117.92,103.39 119.39,103.39 120.06,104.06 126.61,104.06 126.81,104.25 137.35,104.25 138.22,105.12 138.22,105.77 137.81,106.18 v2(137.81,106.21)
  BOTTOM w0.165: U22.P24 113.39,103.73 v2(113.73,104.07) ; v2(137.81,106.21) 137.42,106.6 VRAM1.P13
FBA_DBI5: length 28
  IN1 w0.114: v2(137.81,115.01) 137.41,114.6 136.65,114.6 135.85,113.8 128.56,113.8 128.54,113.83 125.59,113.83 121.17,109.41 115.96,109.41 114.84,108.29 v2(114.51,108.29)
  BOTTOM w0.165: v2(137.81,115.01) 137.8,115.01 VRAM1.P2 ; v2(114.51,108.29) 113.77,108.29 U22.W24
FBA_DBI6: length 17.7
  TOP w0.127: v2(129.01,114.99) 128.86,114.99 128.28,114.41 124.43,114.41 v1(121.87,111.86) 121.15,111.14 116.7,111.14 116.44,110.88 116.04,110.88 115.08,109.93 v2(114.53,109.93)
  BOTTOM w0.165: VRAM1.D2 129.41,115.4 129.01,115.01 v2(129.01,114.99) ; U22.AA25 v2(114.53,109.93)
FBA_DBI7: length 16.3
  BOTTOM w0.089: VRAM1.D13 129.34,106.6 128.97,106.97 128.46,106.97 128.34,107.09 126.79,107.09 126.65,107.22
  BOTTOM w0.127: 126.65,107.22 126.47,107.4 v1(121.22,107.4) 119.95,107.4 119.59,107.05 118.88,107.05 118.35,106.52 116.13,106.52 116.01,106.4 115.39,106.4 115.15,106.64 114.56,106.64 U22.U25
FBA_EDC0: length 37.1
  TOP w0.127: v2(109.54,96.65) 109.97,96.23 109.97,94.42 110.27,94.11 110.27,93.62 111.13,92.77 111.13,92.22 112.29,91.06 122.74,91.06 v1(123.72,90.08) 126.81,86.99 126.81,85.37 127.22,84.96 136.68,84.96 136.74,85.01 137.4,85.01 v2(137.81,84.61)
  BOTTOM w0.165: U22.E19 109.15,96.26 v2(109.54,96.65) ; v2(137.81,84.61) 138.21,84.21 VRAM2.C2
FBA_EDC1: length 37.2
  IN1 w0.114: v2(137.81,93.41) 137.41,93 136.03,93 135.82,93.21 135.82,94.45 134.97,95.3 133.95,95.3 131.9,97.34 122.69,97.34 121.77,96.42 119.86,96.42 119.57,96.13 115.54,96.13 114.86,95.45 110.84,95.45 110.78,95.39 110.17,95.39 110.15,95.41 107.68,95.41 107.67,95.42 106.82,95.42 106.66,95.26 105.65,95.26 105.65,95.26 v2(105.46,95.07)
  BOTTOM w0.165: v2(105.46,95.07) 105.87,94.66 U22.C15 ; v2(137.81,93.41) 138.21,93.01 VRAM2.C13
FBA_EDC2: length 27.9
  IN1 w0.114: v2(106.39,91.81) 106.64,92.06 107.25,92.06 107.5,91.81 107.5,91.47 107.75,91.22 109.49,91.22 110.41,90.3 124.08,90.3 126.2,92.42 126.68,92.42 127.26,93 128.61,93 v2(129.01,93.41)
  BOTTOM w0.102: U22.B16 106.67,93.53 107.01,93.19 107.01,92.43 v2(106.39,91.81)
  BOTTOM w0.165: VRAM2.R13 128.61,93 v2(129.01,93.41)
FBA_EDC3: length 24
  BOTTOM w0.089: VRAM2.R2 128.45,84.2 128.13,84.51 126.36,84.51 126.17,84.7
  BOTTOM w0.127: U22.B22 111.63,93.65 112,93.28 112,92.87 111.72,92.59 111.72,91.48 113.12,90.08 116.72,90.08 117.25,90.61 122.07,90.61 v1(123.36,89.32) 125.84,86.84 125.84,85.03 126.17,84.7
FBA_EDC4: length 26.9
  IN1 w0.114: v2(137.81,107.01) 137.42,106.61 137.42,105.21 137.04,104.83 126.28,104.83 126.03,104.59 119.84,104.59 119.51,104.26 117.87,104.26 117.28,103.67 115.87,103.67 115.39,104.15 v2(114.57,104.15)
  BOTTOM w0.165: U22.R25 114.13,104.52 114.5,104.15 v2(114.57,104.15) ; v2(137.81,107.01) 138.21,106.61 VRAM1.R13
FBA_EDC5: length 29.6
  IN1 w0.114: v2(112.93,108.27) 113.15,108.27 113.58,108.7 114.88,108.7 116.04,109.87 116.04,110.3 116.37,110.63 121.42,110.63 126.19,115.39 133.41,115.39 133.61,115.2 136.51,115.2 136.71,115.4 137.41,115.4 v2(137.81,115.81)
  BOTTOM w0.165: U22.W23 112.93,108.25 v2(112.93,108.27) ; v2(137.81,115.81) 138.21,115.41 VRAM1.R2
FBA_EDC6: length 16.3
  TOP w0.127: v2(118.25,111.64) 119.98,111.64 120.58,112.25 121.48,112.25 v1(123.83,114.6) 124.65,115.43 127.84,115.43 v2(128.21,115.81)
  BOTTOM w0.127: U22.AB26 115.18,110.33 115.58,110.73 117.11,110.73 117.33,110.96 117.92,110.96 118.25,111.29 v2(118.25,111.64)
  BOTTOM w0.165: v2(128.21,115.81) 128.21,115.8 VRAM1.C2
FBA_EDC7: length 14.6
  BOTTOM w0.089: 126.55,106.91 128.13,106.91 128.45,106.6 VRAM1.C13
  BOTTOM w0.127: U22.T26 114.93,105.68 115.38,106.13 116.12,106.13 116.24,106.25 118.51,106.25 118.8,106.54 v1(123.51,106.54) 125.69,106.54 126.06,106.91 126.55,106.91
FBA_VREFC_1: length 1.3
  TOP w0.508: v1(132.65,100.19) 132.65,100.2 R43.2
  vias: v1(133.92,98.49)
FBA_VREFC_2: length 3.3
  TOP w0.508: C92.1 v1(133.04,102.12) ; C92.1 R40.2 ; C92.1 133.04,103.86
  BOTTOM w0.33: VRAM1.J14 133.42,105.8 v2(133.81,105.41)
FBVDD_EN: length 6.9
  BOTTOM w0.102: U20.4 100.38,121.79 100.52,121.65 102.04,121.65 102.12,121.73 103.01,121.73 103.57,122.29 103.57,122.41 103.77,122.62 v1(104.23,122.62) 104.23,122.85 103.94,123.13 R505.1 103.44,123.43 103.43,123.42 103.34,123.42 103.01,123.75 R504.2
FBVDDQ_EN: length 108.9
  IN3 w0.089: v1(104.66,124.22) 104.66,124.19 104.63,124.17 104.63,124.1 104.22,123.68 101.33,123.68 100.8,123.15 96.05,123.15 95.25,122.36 95.25,119.03 96.63,117.65 96.63,112.97 96.19,112.52 96.19,102.31 97.15,101.35 97.15,98.92 98.49,97.59 98.49,96.27 98.68,96.08 98.68,95.12 99.47,94.33 100,94.33 102.07,92.26 103.01,92.26 103.51,92.76 104.29,92.76 104.58,92.47 104.58,91.31 105.86,90.03 108.78,90.03 111,87.81 121.79,87.81 124.69,84.91 124.69,83.05 125.95,81.79 128.77,81.79 129.52,81.05 138.5,81.05 142.71,76.84 142.71,65.83 142.82,65.72 142.82,65.02 142.76,64.96 v1(142.76,64.65)
  BOTTOM w0.102: v1(104.66,124.22) 104.66,124.17 104.72,124.11 R505.2
  BOTTOM w0.254: PR163.2 142.25,66.99 142.84,66.41 142.84,65.65 142.91,65.57 142.91,65.11 142.76,64.96 v1(142.76,64.65)
G5335-AGND-2: length 5.7
  TOP w0.254: v1(142.28,68.6) 142.07,68.39 PR44.2 ; PR45.2 140.56,66.29 v1(140.81,66.54)
  BOTTOM w0.254: v1(142.28,68.6) 142.26,68.58 PC178.2 ; PC175.2 141.21,69.25 140.9,68.95 140.5,68.95 140.42,68.87 v1(140.3,68.87) ; PR169.2 141.88,62.88 v1(142.37,63.37) ; PU9.4 140.71,66.44 v1(140.81,66.54)
  vias: v1(142.25,67.09)
G5335-BST-2: length 3.5
  BOTTOM w0.254: PU9.20 137.56,69.38 137.89,69.72 138.96,69.72 139.18,69.94
  BOTTOM w0.508: PR154.2 139.56,70.32 139.18,69.94
G5335-EN-2: length 25.6
  TOP w0.254: v1(131.71,77.13) 131.41,76.83 PQ6.2
  IN2 w0.203: v1(131.71,77.13) 131.63,77.13 130.31,75.81 130.31,71.72 132.08,69.95 135.76,69.95 136.87,68.85 139.28,68.85 140.22,67.91 140.22,66.42 v1(140.99,65.65)
  BOTTOM w0.254: v1(140.99,65.65) 141.18,65.65 PR166.2 141.56,66.53 141.65,66.61 PR163.1 141.65,67.47 141.48,67.64 PC178.1 140.78,67.96 140.26,67.44 PU9.2
G5335-FB-2: length 4.8
  BOTTOM w0.102: v1(141.51,62.13) 141.26,62.38 PR169.1
  BOTTOM w0.254: PU9.5 140.25,65.94 140.45,65.74 140.45,65.41 140.98,64.88 PC183.1 PR167.2 141.07,63.07 PR169.1
G5335-PFM-2: length 2.5
  TOP w0.254: v1(140.9,67.35) 141.08,67.52 PR43.1 141.41,67.93 141.46,67.88 PR44.1
  BOTTOM w0.254: v1(140.9,67.35) 140.49,66.94 PU9.3
G5335-PWRGD-2: length 2.6
  BOTTOM w0.254: PR157.1 141.81,69.05 141.53,68.77 141.27,68.77 140.84,68.34 140.48,68.34 140.07,67.94 PU9.1
G5335-SS-2: length 2
  BOTTOM w0.254: PC175.1 140.09,69.46 139.32,68.69 PU9.23
G5335-TON-2: length 1.7
  BOTTOM w0.254: PR168.1 139.81,64.14 PU9.6
G5335-VCC-2: length 5.5
  BOTTOM w0.254: PR155.2 140.99,70.62 140.4,70.04 140.09,70.04 139.39,69.33 138.26,69.33 138.06,69.13 PU9.21
  BOTTOM w0.508: PC170.1 140.97,72.05 140.97,70.65 PR155.2
G_MBCLK_R: length 5.6
  TOP w0.102: R484.2 R483.2 65.06,12.78 64.83,12.56 C467.1 65.21,13.56 v1(65.21,14.06) U16.4
G_MBDATA_R: length 5.1
  TOP w0.102: C464.1 68.92,13.55 R475.2 R468.2 68.51,14.97 v1(68.2,15.29) 66.98,16.5 U16.6
GC6_FB_EN: length 3.3
  TOP w0.102: Q9.2 89.17,93.49 R86.1 R81.1
GC6_FB_EN_N17: length 7.6
  TOP w0.102: R81.2 91.04,95.4 92.14,94.3 92.95,94.3 v2(93.46,93.79)
  BOTTOM w0.102: U22.B2 94.85,93.83 94.48,93.46 94.24,93.46 93.96,93.17 93.96,93.04 93.71,92.78 93.17,92.78 93.08,92.87 93.08,93.41 v2(93.46,93.79)
GC6_FB_EN_Q: length 123.2
  TOP w0.102: v1(85.15,93.46) 85.15,93.69 v1(84.62,94.22) 84.31,94.52 84.31,95.53 84.45,95.67 86.75,95.67 Q8.3 87.03,95.39 89.47,95.39 90.03,95.95 90.84,95.95 93.66,98.77 v2(93.79,98.77) ; v1(69.02,43.19) 69.02,42.66 68.51,42.15 66.7,42.15 R262.1 64.8,41.81 64.68,41.92 63.24,41.92 63.16,41.84 R261.2
  IN1 w0.089: v1(82.87,87.87) 82.99,88 82.99,91.3 v1(85.15,93.46)
  IN3 w0.089: v1(93.41,113.63) 93.8,113.24 93.8,112.04 93.45,111.69 93.45,110.56 93.91,110.1 93.91,101.71 94.55,101.08 94.55,99.53 v2(93.79,98.77) ; v1(69.02,43.19) 69.02,44.31 71.97,47.26 71.97,47.89 76.36,52.28 76.36,53.05 76.77,53.45 78.42,53.45 78.67,53.71 78.67,54.09 78.93,54.34 79.94,54.34 80.45,54.85 80.45,72.82 81.61,73.97 81.61,74.31 82.07,74.76 82.5,74.76 82.89,75.16 82.89,75.33 83.69,76.13 83.69,82.27 84.52,83.1 84.52,84.85 83.69,85.68 83.69,87.55 83.37,87.87 v1(82.87,87.87)
  BOTTOM w0.079: v1(69.02,43.19) 69.56,43.19 70.24,43.88 70.24,44.51 71.33,45.6 71.64,45.6 72.38,46.34 73.89,46.34 74.18,46.36 74.53,46.44 74.66,46.5 74.96,46.53 U24.CL47
  BOTTOM w0.102: v1(93.41,113.63) 94.02,114.24 94.02,119.29 94.4,119.67 98,119.67 100.06,117.61 101.56,117.61 101.68,117.73 U20.1
GC6FBEN_Q_EC: length 1.4
  TOP w0.102: TP39.1 182.08,27.72 182.14,27.78 U13.2
GPD7: length 26.6
  TOP w0.102: v2(72.85,40.27) 73.13,39.99 73.52,39.99 73.77,39.74 74.05,39.74 74.46,39.33 74.46,36.16 73.85,35.55 73.4,35.55 70.07,32.22 69.58,32.22 67.44,30.08 67.44,29.69 67.04,29.29 67.04,25.51 67.52,25.02 v1(67.52,24.32) 67.47,24.26 R405.1 67.47,23.23 R413.2
  BOTTOM w0.079: v2(72.85,40.27) 72.85,41.12 73.16,41.43 73.93,41.43 74.47,40.89 75.33,40.89 U24.DC47
GPIO10_VREF: length 92.1
  TOP w0.102: v1(97.88,96.02) 98.14,96.02 98.36,96.24 R64.2
  TOP w0.381: v1(137.58,101.13) 137.03,100.58 Q5.2 ; R64.2 98.74,95.73 98.05,95.05 v2(98,95.05)
  IN1 w0.508: v1(115.38,86.22) 115.14,86.45 111.62,86.45 110.57,85.41 104.79,85.41 103.42,84.04 98.29,84.04 97.43,84.9 97.43,86.71 96.99,87.15 96.99,90.19 98.41,91.61 98.41,94.63 v2(98,95.05)
  IN2 w0.508: v1(137.58,101.13) 138.95,101.13 142.3,97.78 142.3,88.38 143.22,87.46 143.22,80.66 142.91,80.35 139.15,80.35 137.73,81.77 125.79,81.77 124.73,82.84 123.53,82.84 121.27,80.58 118.22,80.58 116.01,82.79 116.01,85.76 115.56,86.22 v1(115.38,86.22)
  BOTTOM w0.381: v2(98,95.05) U22.C5
GPP_B18: length 17.4
  BOTTOM w0.079: U24.CF48 74.7,49.35 74.47,49.12 73.86,49.12 73.68,48.94 73.26,48.94 73.01,48.68 72.25,48.68 71.72,48.15 71.72,47.45
  BOTTOM w0.102: R655.2 R656.1 61.28,45.58 61.38,45.68 61.66,45.68 61.71,45.73 62.14,45.73 62.52,45.35 R657.1 62.57,45.33 63.05,45.33 63.51,44.87 65.29,44.87 66.13,45.71 69.28,45.71 70.52,46.95 71.22,46.95 71.72,47.45
GPP_B23: length 10.3
  BOTTOM w0.079: 68.64,43.67 69.02,43.67 71.13,45.78 71.57,45.78 72.32,46.53 74.16,46.53 74.48,46.6 74.92,46.79 U24.CL48
  BOTTOM w0.102: 68.64,43.67 66.99,43.67 66.89,43.57 R666.1 66.56,43.22 66.48,43.29 R663.2
GPP_C2: length 8.5
  TOP w0.102: v2(85.93,36.39) 86.47,35.85 86.47,35.49 87.31,34.65 87.36,34.65 88.05,33.96 88.05,33.41 88.25,33.21 R303.1 88.43,33.1 88.96,32.57 88.96,31.74 v1(88.89,31.66) 88.96,31.59 88.96,30.85 89.47,30.34 R346.2
  BOTTOM w0.102: U24.DL24 85.96,36.39 v2(85.93,36.39)
GPP_C5: length 6.9
  TOP w0.079: 88.86,34.17 88.55,34.48 88.06,34.48 87.53,35.01 v2(87.53,35.06)
  TOP w0.102: R347.2 90.18,30.31 90,30.49 R334.1 90,31 89.8,31.2 89.8,32.5 89.34,32.95 89.34,32.96 v1(89.34,32.96) 89.33,32.96 88.86,33.44 88.86,34.17
  BOTTOM w0.102: U24.DP22 87.2,35.33 87.48,35.06 v2(87.53,35.06)
GPP_E6: length 9.5
  BOTTOM w0.079: U24.DT12 92.5,34 92.5,33.37 92.57,33.3 92.66,33.09 92.66,32.81 92.64,32.75 92.64,32.49 92.81,32.32 92.81,31.81 93.58,31.04 93.58,30.62 94.38,29.83 94.8,29.83
  BOTTOM w0.102: R760.1 96.43,27.14 96.33,27.24 96.33,27.98 95.85,28.46 95.46,28.46 95.38,28.54 R736.1 95.38,28.95 95.15,29.17 95.15,29.52 94.84,29.83 94.8,29.83
GPP_E10: length 4.7
  BOTTOM w0.102: U24.DW16 90.27,30.63 89.95,30.31 R725.1 R735.2 R747.2
GPP_E11: length 6.8
  BOTTOM w0.079: U24.DV16 90.27,33.09 90.08,32.9 90.02,32.72 90.02,32.24
  BOTTOM w0.102: 90.02,32.24 90.02,31.07 89.67,30.72 88.86,30.72 88.23,30.09 88.23,29.81 88.1,29.68 R728.2 R739.2 88.1,28.63 88.45,28.28 R750.2
GPP_E19: length 11.1
  TOP w0.079: 90.64,37.32 90.54,37.32 90.51,37.35 90.21,37.35 89.85,37.71 v2(89.6,37.71)
  TOP w0.102: R304.2 R301.1 96.71,34.02 96.4,33.72 95.06,33.72 94.24,34.53 93.91,34.53 93.79,34.66 92.25,34.66 91.88,35.03 91.88,36.18 v1(91.69,36.37) 91.5,36.56 91.12,36.56 90.87,36.82 90.87,37.1 90.64,37.32
  BOTTOM w0.079: U24.DK17 89.93,37.37 v2(89.6,37.71)
GPP_H2: length 18.2
  TOP w0.102: R415.2 77.05,22.44 76.93,22.56 R408.1 76.93,23.71 v1(77.2,23.99) 77.46,24.24 77.79,24.24 77.86,24.32 77.86,26 78.29,26.43 78.29,29.96 78.47,30.14 78.47,34.41 79.06,35 79.06,35.83 79.87,36.64 79.87,37.96 v2(79.49,38.34)
  BOTTOM w0.102: v2(79.49,38.34) 79.81,38.02 U24.DJ38
GPPC_D19: length 7.1
  TOP w0.102: v2(82.18,35.92) 82.18,35.87 82.64,35.41 82.64,34.78 82.23,34.37 82.23,33.62 82.41,33.44 82.41,30.92 TP37.1
  BOTTOM w0.102: v2(82.18,35.92) 82.2,35.92 82.63,35.49 U24.DP33
GPU_CHOKE_THERMAL: length 182.6
  TOP w0.102: v2(177.17,32.93) 177.17,32.98 177.7,33.51 178.37,33.51 178.8,33.08 178.8,32.93 180,31.74 180.78,31.74 181.21,31.31 R325.1 181.68,31.05 182.56,31.05 182.89,30.72 183.96,30.72 184.47,30.21 184.47,29.09 184.64,28.92 185.46,28.92 185.65,29.11 U13.126 ; v1(70.83,106.54) 70.7,106.66 PR30.1
  IN1 w0.089: v2(74.41,102.96) 74.43,102.98 74.43,103.8 73.34,104.89 73.34,105.22 72.66,105.9 71.16,105.9 70.83,106.23 v1(70.83,106.54)
  IN2 w0.089: v2(177.17,32.93) 177.17,33.43 177.08,33.52 167.18,33.52 166.95,33.29 166.3,33.29 166.09,33.49 164.98,33.49 164.2,34.28 164.05,34.28 163.69,34.64 162.79,34.64 161.96,35.47 159.44,35.47 159.13,35.79 156.51,35.79 155.93,35.21 153.34,35.21 153.09,35.46 148.49,35.46 147.9,36.05 147.41,36.05 147.1,36.36 147.1,36.89 143.95,40.04 143.95,45.28 143.08,46.15 138.92,46.15 137.78,47.29 134.22,47.29 133.07,48.44 128.51,48.44 125.9,45.83 122.76,45.83 120.72,47.86 114.5,47.86 106.87,55.49 104.99,55.49 103.26,57.21 103.26,60.43 104.28,61.45 104.28,62.7 103.81,63.17 103.81,73.47 101.15,76.13 101.15,76.85 100.77,77.23 99.24,77.23 95.66,80.81 94.8,80.81 90.44,85.18 87.88,85.18 86.03,87.03 85.21,87.03 84.82,87.41 84.82,90.18 87.76,93.12 87.76,98 86.4,99.36 81.31,99.36 79.11,101.56 75.84,101.56 74.44,102.96 v2(74.41,102.96)
  BOTTOM w0.102: v2(74.41,102.96) 74.43,102.98 74.43,104.79 v1(73.04,106.18)
GPU_EVENT#: length 82
  TOP w0.102: D2.1 85.7,99.41 86.47,98.64 86.47,98.18 v1(86.05,97.76)
  IN2 w0.089: v1(86.05,97.76) 86.17,97.65 86.17,92.32 84.39,90.54 v1(84.39,88)
  IN3 w0.089: v1(84.39,88) 84.19,88 83.88,87.69 83.88,85.76 84.71,84.93 84.71,83.02 83.88,82.19 83.88,76.05 83.08,75.25 83.08,75.08 82.58,74.57 82.14,74.57 81.8,74.23 81.8,73.89 80.64,72.74 80.64,54.62 80.2,54.18 80.2,52.82 79.94,52.56 77.52,52.56 76.39,51.44 76.39,51.12 74.44,49.17 73.58,49.17 72.2,47.79 72.2,47.34 72.57,46.98 v2(73.09,46.98)
  BOTTOM w0.079: U24.CK46 75.72,47.71 74.54,47.71 74.15,47.5 73.91,47.5 73.69,47.28 73.52,47.28 73.21,46.98 v2(73.09,46.98) 72.51,46.98 71.5,45.96 71.03,45.96 68.98,43.91 68.64,43.91
  BOTTOM w0.102: R673.2 61.02,41.25 62.15,42.38 62.93,42.38 63.54,42.99 63.54,43.81 63.64,43.91 68.64,43.91
GPU_EVENT#_GPU: length 5.5
  TOP w0.102: v1(86.47,99.45) 86.47,99.66 87.39,100.57 D2.2 88.1,100.57 88.78,99.88 88.78,99.61 88.68,99.5 88.68,99.39 R50.1 88.72,98.67 R53.1
GPU_GPIO0: length 10.6
  BOTTOM w0.102: U22.C6 98.03,94.23 98.03,92.72 97.78,92.47 97.01,92.47 96.75,92.2 95.83,92.2 95.23,91.61 92.32,91.61 90.66,89.95 R551.2
GPU_GPIO2: length 13.3
  TOP w0.102: R53.2 91.17,98.67 93.38,100.87 94.17,100.87 96.71,98.33 96.71,97.93 v2(97.12,97.52)
  BOTTOM w0.102: v2(97.12,97.52) 98.61,97.52 98.84,97.29 98.84,95.85 98.43,95.43 U22.D6
GPU_GPIO6: length 7
  BOTTOM w0.102: U22.A4 96.36,92.66 95.64,92.66 95.04,92.07 92.02,92.07 90.87,90.92 R549.2
GPU_GPIO21: length 10.2
  BOTTOM w0.102: U22.C4 96.33,94.23 96.33,93.59 96.2,93.46 95.69,93.46 95.54,93.31 95.54,92.89 94.95,92.3 91.92,92.3 91.03,91.4 89.47,91.4 89.32,91.55 R548.1
GPU_PEX_RST_HOLD#: length 12.7
  BOTTOM w0.102: U22.D5 97.18,95.03 97.18,92.96 96.65,92.43 95.73,92.43 95.14,91.84 92.23,91.84 90.88,90.49 89.58,90.49 89.42,90.33 89.42,90.18 89.11,89.88 88.95,89.88 R555.1
GPU_PWR_GD: length 54.9
  TOP w0.203: v1(76.52,105.24) 76.52,105.5 74.58,107.43 PR29.1
  IN1 w0.089: v1(76.52,105.24) 76.54,105.22 76.74,105.22 77.42,104.54 83.49,104.54 85.66,102.37 87.44,102.37 88.07,103 88.07,107.9 87.78,108.19 87.78,109 89.11,110.33 89.34,110.33 90.06,111.04 90.06,115.99 v1(92.39,118.32)
  BOTTOM w0.102: PR153.2 76.63,95.48 76.9,95.74 76.9,96.63 77.28,97.01 77.28,98.47 78.01,99.2 v1(78.27,99.2) 78.37,99.3 78.37,103.47 77.74,104.1 77.05,104.1 76.52,104.63 v1(76.52,105.24) ; R509.1 99.08,119.24 98.19,120.13 93.97,120.13 92.39,118.55 v1(92.39,118.32)
GPUT_CLK_L: length 137.7
  TOP w0.102: Q15.4 174.31,30.93 174.08,30.69 173.75,30.69 173.34,30.28 R341.1 173.36,30.16 v1(174.05,30.16) 173.87,29.98 v2(173.87,29.04)
  IN2 w0.089: v2(101.32,95.02) 101.32,92.78 103.25,90.85 103.25,90.28 106.93,86.6 110.98,86.6 114.77,82.81 114.77,82.53 117.78,79.52 120.3,79.52 128.85,70.97 128.85,67.46 133.78,62.53 137.36,62.53 138.78,61.11 140.14,61.11 142.88,58.38 142.88,56.2 145.75,53.33 145.75,51.59 143.55,49.39 142.99,49.39 v1(142.1,48.5)
  IN3 w0.089: v2(173.87,29.04) 173.86,29.04 173.48,29.42 172.63,29.42 172.24,29.03 170.77,29.03 170.53,28.78 167.07,28.78 166.66,28.37 163.63,28.37 163.49,28.24 159.65,28.24 158.88,29.01 157.8,29.01 157.55,29.27 156.54,29.27 155.93,29.88 154.61,29.88 153.48,31.01 147.46,31.01 146.62,30.16 142.5,30.16 139.96,32.7 139.96,33.33 139.55,33.75 139.55,35.13 139.37,35.31 137.22,35.31 136.25,36.27 136.25,38.04 136.96,38.75 139.61,38.75 140.51,39.64 140.51,44.06 141.07,44.62 141.07,45.93 140.56,46.43 140.56,47.21 141.86,48.5 v1(142.1,48.5)
  BOTTOM w0.102: v2(101.32,95.02) U22.D9
GPUT_DATA_L: length 137.9
  TOP w0.102: Q15.1 171.53,32.39 v1(171.17,32.03) 170.85,31.71 170.85,30.47 R340.1 171.13,29.8 v2(171.51,29.42)
  IN2 w0.089: v2(99.68,95.04) 100.45,95.04 100.82,95.41 101.66,95.41 101.81,95.26 101.81,92.77 103.59,91 103.59,90.42 107.07,86.94 111.12,86.94 115.11,82.95 115.11,82.68 117.92,79.86 120.44,79.86 129.2,71.11 129.2,67.6 133.92,62.88 137.5,62.88 138.92,61.45 140.29,61.45 143.22,58.52 143.22,56.44 146.09,53.57 146.09,51.45 143.65,49.01 143.24,49.01 v1(142.73,48.5)
  IN3 w0.089: v1(142.73,48.5) 142.28,48.04 141.89,48.04 140.91,47.06 140.91,46.57 141.42,46.06 141.42,44.49 140.85,43.92 140.85,39.5 139.76,38.4 137.1,38.4 136.6,37.9 136.6,36.42 137.36,35.65 139.51,35.65 139.89,35.27 139.89,33.89 140.31,33.48 140.31,32.84 142.64,30.5 146.48,30.5 147.32,31.35 153.62,31.35 154.75,30.22 156.07,30.22 156.68,29.61 157.69,29.61 157.94,29.35 159.02,29.35 159.79,28.58 163.35,28.58 163.48,28.71 166.52,28.71 166.93,29.13 170.38,29.13 170.68,29.42 v2(171.51,29.42)
  BOTTOM w0.102: U22.D8 99.7,95.06 v2(99.68,95.04)
H_CATERR#: length 7.9
  BOTTOM w0.079: 99.85,79.27 99.47,78.9 99.47,78.45 98.24,77.22 97.6,77.22 97.41,77.41 96.93,77.41 96.62,77.11 U24.J4
  BOTTOM w0.102: R591.1 102.22,80.38 102.09,80.25 101.76,80.25 101.53,80.02 100.85,80.02 100.29,79.46 100.04,79.46 99.85,79.27
H_PROCHOT#: length 151.5
  TOP w0.102: v2(171.54,27.34) 171.97,26.91 172.4,26.91 172.73,26.58 172.73,24.67 172.83,24.57 172.83,20.36 172.71,20.23 172.71,18.39 Q20.3 ; v2(138.26,30.57) 138.26,30.62 138.35,30.71 138.35,31.81 139.01,32.47 139.49,32.47 140.42,33.4 140.42,34.73 142.05,36.36 142.05,37.98 v1(142.16,38.1) 142.28,38.21 142.28,39.91 142.15,40.04 142.15,43.52 143.14,44.51 143.14,46.72 144.51,48.09 v1(144.51,49.26) ; v1(136.04,48.61) 136.1,48.55 136.62,48.55 136.72,48.65 PR60.1
  IN1 w0.089: v1(105.17,83.81) 106.09,82.89 106.09,76.01 106.9,75.2 106.9,69.46 107.8,68.56 107.8,67.57 109.61,65.77 109.61,65.52 110.85,64.27 110.85,62.25 115.67,57.43 120.34,57.43 121.1,58.19 123.52,58.19 123.82,57.89 123.82,55.42 125.1,54.15 130.5,54.15 v1(136.04,48.61)
  IN3 w0.089: v1(144.51,49.26) 144.35,49.1 136.52,49.1 v1(136.04,48.61) ; v2(138.26,30.57) 139.43,30.57 140.14,29.86 140.14,29.5 140.35,29.3 140.35,28.94 140.56,28.72 145.68,28.72 145.77,28.82 147.13,28.82 148.04,29.72 150.66,29.72 151.2,29.19 153.48,29.19 153.73,28.94 153.73,28.43 154.18,27.98 157.02,27.98 157.29,27.71 157.29,27.34 157.67,26.95 160.4,26.95 160.92,26.43 165.31,26.43 165.44,26.56 167.77,26.56 168.37,27.16 171.35,27.16 v2(171.54,27.34)
  BOTTOM w0.102: v2(138.26,30.57) 138.21,30.57 138.16,30.52 137.5,30.52 137.38,30.64 PR252.1 137.37,30.9 136.78,30.31 PU12.10 ; v1(136.04,48.61) 136.44,48.61 136.71,48.88 PR203.1 ; C725.2 98.12,84.82 98.46,84.82 98.74,84.55 R583.1 98.79,84.39 99.19,84.79 R582.1 99.7,84.79 99.73,84.82 103.2,84.82 D23.2 103.56,85.58 104.53,86.55 R571.2 105.02,83.95 v1(105.17,83.81)
H_VCCST_PWRGD: length 6.3
  BOTTOM w0.079: 99.5,49.75 99.25,49.5 98.59,49.5 98.45,49.36 97.71,49.36 U24.CF2
  BOTTOM w0.102: R637.2 101.06,51.53 101.26,51.74 R633.2 101.14,52.04 99.5,50.41 99.5,49.75
HDMI_EQ0: length 5.1
  TOP w0.102: U3.8 19.52,81.26 19.39,81.39 18.48,81.39 18.1,81.77 18.1,82.02 v1(17.58,82.53) R102.1 R103.1
HDMI_EQ1: length 5.3
  TOP w0.102: v1(22.9,85.51) 23.05,85.36 R100.1 22.93,84.7 22.41,84.19 22.41,83.92 R105.1 22.47,82.85 22.47,81.59 22.52,81.54 U3.2
HDMI_HPD: length 20.9
  TOP w0.102: v1(21.52,75.09) U3.21 ; Q10.3 16.61,88.62 15.31,87.32 R93.2 VC1.1 R98.1 15.94,84.95 v2(16.44,85.46)
  IN1 w0.089: v2(16.44,85.46) 17.33,85.46 18.73,84.06 18.73,81.44 19.22,80.95 19.22,77.39 v1(21.52,75.09)
HDMI_HPD_C: length 6.8
  TOP w0.102: CN4.19 11.12,81.77 11.77,81.77 v1(13.68,83.68) 13.93,83.93 C183.1 R98.2
HDMI_HPD_CON: length 207
  TOP w0.102: v1(70.74,12.33) 70.76,12.31 72.63,12.31 74,13.68 74,14.62 75.63,16.25 76.48,16.25 76.95,16.71 76.95,19.07 75.22,20.8 75.22,21.65 v1(75.36,21.79) 75.5,21.93 75.5,23.74 76.13,24.37 76.31,24.37 76.82,24.88 76.82,25.61 77.38,26.17 77.38,26.88 77.4,26.91 77.4,28.18 77.3,28.28 77.3,29.22 76.97,29.55 76.97,29.91 76.66,30.22 76.66,30.75 76.84,30.92 77.46,30.92 78.07,31.53 78.07,35.83 78.93,36.69 78.93,37.86 78.85,37.93 78.85,38.92 78.67,39.1 76.67,39.1 76.25,39.52 76.25,40.71 77.25,41.71 77.25,42.1 77.69,42.54 v2(77.69,42.77) ; R97.1 20.39,85.47 20.76,85.84 v1(20.76,86.22)
  IN1 w0.089: v1(70.74,12.33) 70.1,12.97 60.79,12.97 60.44,12.62 52.83,12.62 52.39,13.07 49.31,13.07 47.18,10.93 47.18,8.7 46.06,7.58 41.74,7.58 39.56,5.4 39.56,2.93 38.3,1.67 12.96,1.67 12.15,2.48 12.15,4.89 12.3,5.04 12.3,9.41 11.62,10.1 11.62,12.04 11.06,12.6 11.06,14.8 11.75,15.48 11.75,17.13 11.33,17.55 11.33,19.1 10.55,19.87 10.55,23.48 11.52,24.45 12.81,24.45 15.66,27.29 18.71,27.29 18.88,27.47 18.88,32.19 16.73,34.35 16.73,38.91 17.05,39.23 17.05,44.53 17.59,45.07 17.59,46.09 19.11,47.61 19.11,55.81 21.65,58.35 21.65,60.75 23.81,62.91 23.81,64.27 25.47,65.92 25.47,68.49 25.36,68.6 25.36,72.33 24.1,73.6 24.1,74.79 23.69,75.2 23.69,80.23 22.54,81.38 22.54,83.17 20.76,84.95 v1(20.76,86.22)
  BOTTOM w0.079: v2(77.69,42.77) 78,43.08 U24.CV42
HDMI_MB_HPD_R: length 8.9
  TOP w0.102: v1(20.13,86.62) Q10.1 19.05,86.18 18.32,85.45 R96.1 R97.2 19.61,85.14 20.38,84.37 20.38,83.17 20.71,82.84 20.71,82.44 21.02,82.14 U3.5
HDMI_SCLK: length 38.9
  TOP w0.102: CN4.15 10.96,79.61 10.96,80.58 11.59,81.22 11.9,81.22 v1(12.05,81.37) 13.63,82.94 D3.2 14.17,82.47 v2(13.96,82.26) ; v1(18.73,73.8) 19.09,74.15 19.82,74.15 20.05,74.38 R163.2 20.52,74.65 U3.19 ; Q13.3 23.67,63.98 23.48,63.79 22.86,63.79 C239.1 22.41,63.99 v1(21.78,63.36)
  IN1 w0.089: v1(21.78,63.36) 21.28,63.85 21.28,64.99 22.41,66.12 22.41,69.63 22.14,69.91 22.14,70.22 21.84,70.53 21.84,70.77 19.78,72.82 19.78,73.91 19.54,74.15 19.24,74.15 18.88,73.8 v1(18.73,73.8) 16.5,76.03 16.5,81.88 15.99,82.38 14.08,82.38 v2(13.96,82.26)
HDMI_SDATA: length 40.3
  TOP w0.102: CN4.16 12.48,80.08 12.48,81.22 13.12,81.85 14.62,81.85 15.05,82.28 D4.2 15.47,81.89 15.65,81.71 v2(16.09,81.71) ; U3.20 21.02,74.72 21.58,74.15 21.95,74.15 R164.2 21.95,73.87 21.4,73.32 19.76,73.32 v1(19.37,73.7) ; Q13.6 24.97,63.09 24.7,63.36 23.3,63.36 22.93,62.99 C249.1 22.53,62.85 21.65,62.85 v1(21.14,63.36)
  IN1 w0.089: v1(21.14,63.36) 20.89,63.61 20.89,65.15 22.02,66.28 22.02,69.46 21.74,69.73 21.74,70.06 21.44,70.36 21.44,70.61 19.37,72.68 v1(19.37,73.7) 18.93,73.27 18.68,73.27 16.09,75.86 v2(16.09,81.71)
HOLD#: length 4.2
  TOP w0.102: R335.1 162.38,31.14 162.59,31.36 R324.2 162.59,32.21 v1(162.8,32.42) v1(162.8,33.06)
  BOTTOM w0.102: v1(162.8,32.42) 163.43,33.06 U33.7
HP-L2: length 18.2
  TOP w0.381: R249.1 214.72,45.22 214.28,45.66 213.98,45.66 ; v2(204.43,38.11) 205.09,38.11 205.57,38.59 205.57,39 208.09,41.52 209.26,41.52 210.37,42.63 210.37,43.64 C333.2 211.14,44.64 212.74,46.24 212.78,46.24 R238.2 213.16,46.08 213.38,45.86
  BOTTOM w0.203: U30.32 205.26,37.63 204.77,38.11 v2(204.43,38.11)
HP-L3: length 3.9
  TOP w0.381: R238.1 214.56,46.62 C327.2 214.99,46.54 v2(215.25,46.8)
  BOTTOM w0.254: v2(215.25,46.8) 214.85,46.4 CN6.4
HP-R2: length 18.7
  TOP w0.381: v2(204.43,38.67) 204.43,39.19 209.62,44.38 C334.2 209.64,44.4 212.37,47.13 212.52,47.13 213.06,47.66 R232.2 213.16,47.98 213.48,48.31 ; 213.73,48.63 213.98,48.63 214.36,49.01 R224.1
  BOTTOM w0.203: v1(205.52,38.8) 205.67,38.64 205.67,37.19 205.66,37.17 U30.33
  BOTTOM w0.381: v2(204.43,38.67) 204.56,38.8 v1(205.52,38.8)
HP-R3: length 4
  TOP w0.381: R232.1 214.07,47.53 C323.2 215.17,47.72 v2(215.17,48.2)
  BOTTOM w0.254: CN6.2 214.51,47.4 214.72,47.61
  BOTTOM w0.381: v2(215.17,48.2) 215.17,48.07 214.72,47.61
HP_JD#: length 23.4
  TOP w0.381: v1(212.08,42.2) v1(211.58,41.71)
  IN2 w0.381: v1(212.08,42.2) 211.8,42.2 210.86,41.26 207.71,41.26 205.32,38.87 205.32,36.77 204.15,35.6 202.37,35.6 201.43,34.66 201.43,32.65 199.32,30.53 v1(199.32,30.07)
  BOTTOM w0.305: CN6.13 212.38,41.9 v1(212.08,42.2)
  BOTTOM w0.381: R715.2 199.04,30.5 199.32,30.22 v1(199.32,30.07)
HWPG: length 122
  TOP w0.102: U13.21 184.14,20.18 186.01,20.18 187.72,21.88 187.72,23.06 185.63,25.14 185.63,26.05 186.07,26.48 v2(186.07,26.71) ; D11.2 168.47,29.75 167.84,30.38 R336.2 167.84,31.24 168.34,31.74 D8.2 168.34,32.52 168.24,32.63 166.82,32.63 166,33.45 v2(166,34.28) ; D11.2 D12.2 ; D11.2 168.74,29.2 169.24,29.7 D9.2 169.78,28.69 170.5,27.98 170.74,27.98 170.82,28.05 R369.1 171.5,28.01 v1(172.15,27.37)
  IN1 w0.089: v2(166,34.28) 165.78,34.49 165.71,34.49 165.57,34.63 164.73,34.63 164.63,34.73 163.36,34.73 162.14,35.95 161.08,35.95 160.56,36.47 160.56,36.92 160.21,37.27 159.45,37.27 158.96,37.76 158.53,37.76 157.85,37.07 155.38,37.07 155.23,36.92 154.67,36.92 154.27,36.51 153.68,36.51 153.55,36.38 153.22,36.38 153.02,36.18 149.74,36.18 149.08,36.84 148.88,36.84 148.74,36.98 148.36,36.98 147.92,37.42 147.68,37.42 144.47,40.63 144.47,41.51 144.18,41.79 144.18,47.04 143.16,48.07 139.48,48.07 139.01,47.6 136.22,47.6 135.99,47.37 134.82,47.37 133.05,49.14 126.53,49.14 125.77,48.37 115.39,48.37 113.93,49.83 113.93,51.22 113.57,51.57 112.79,51.57 112.58,51.78 111.59,51.78 111.39,51.57 108.72,51.57 108.3,51.99 104.14,51.99 103.95,51.8 v1(103.95,51.75)
  IN3 w0.089: v1(172.15,27.37) 172.15,27.03 172.28,26.9 173.63,26.9 174.1,27.37 178.89,27.37 179.49,26.77 184.22,26.77 184.67,27.21 185.41,27.21 185.92,26.71 v2(186.07,26.71)
  BOTTOM w0.102: v1(103.95,51.75) 103.95,51.93 104.07,52.06 104.71,52.06 104.84,51.93 R636.2 105.21,52.4 104.99,52.61 v1(104.38,52.61) 104.38,53.55 D33.1
HWPG_1.5V: length 6.5
  TOP w0.102: PR109.1 167.95,25.41 168.03,25.49 PR102.2 167.77,26.08 167.14,26.71 v1(167.05,26.71) 167.01,26.71 166.76,26.95 166.76,28 167.06,28.29 R336.1
HWPG_1.8VS5: length 144.4
  TOP w0.102: v2(42.68,26.1) 42.45,26.33 42.45,26.45 42.15,26.75 PR101.2 PR91.1 ; D11.1 v1(165.46,28.49) 165.57,28.38 165.57,27.46 165.92,27.11 165.92,26.41 166.56,25.77 166.56,25.06 167.19,24.42 167.19,23.23 166.56,22.59 166.56,21.98 166.77,21.77 v2(166.77,21.5)
  IN1 w0.089: v2(42.68,26.1) 42.68,25.81 42.87,25.61 47.31,25.61 v2(49.49,23.43)
  IN2 w0.089: v2(166.77,21.5) 166.67,21.4 166.67,21.18 166.62,21.13 165.28,21.13 164.27,22.13 156.93,22.13 156.74,21.94 139.36,21.94 138.75,22.55 133.45,22.55 133.18,22.29 126.9,22.29 126.61,22.58 121.43,22.58 121.21,22.8 119.8,22.8 118.83,21.83 116.47,21.83 115.81,21.17 113.07,21.17 111.52,19.62 104.41,19.62 103.71,18.92 93.07,18.92 92.16,19.84 90.84,19.84 88.83,21.84 84.09,21.84 79.94,17.69 73.7,17.69 72.95,18.45 63.72,18.45 61.07,21.09 58.94,21.09 56.93,23.1 51.37,23.1 51.04,23.43 v2(49.49,23.43)
HWPG_1.35VGFX: length 2.4
  TOP w0.254: v1(141.58,69.98) 142.06,70.46 R175.2
  BOTTOM w0.254: PR158.2 PR157.2 141.9,69.67 v1(141.58,69.98)
HWPG_VDDR: length 177
  TOP w0.203: D12.1 166.76,28.39 166.76,29.78 166.58,29.96 166.58,31.45 D8.1 166.04,32.76 165.42,33.39 v1(165.42,33.51) v2(165.42,34.25)
  IN1 w0.203: v1(112.94,81.65) 115.78,81.65 117.03,80.4 123.38,80.4 v1(124.47,81.49)
  IN2 w0.203: v1(67.24,119.37) 67.37,119.37 68.01,118.73 70.29,118.73 71.18,117.84 71.18,116.32 71.69,115.81 73.09,115.81 73.98,114.92 73.98,113.65 74.86,112.76 75.53,112.76 78.24,110.04 81.66,110.04 82.09,109.61 82.45,109.61 83.72,108.34 87.55,108.34 88.8,107.1 90.95,107.1 93.31,104.74 93.31,103.08 94.42,101.97 94.42,98.67 94.28,98.52 94.28,94.36 95.06,93.59 95.06,92.05 98.48,88.63 102.42,88.63 106.2,84.85 109.89,84.85 112.94,81.8 v1(112.94,81.65) ; v1(124.47,81.49) 124.65,81.32 137.54,81.32 140.41,78.45 142.23,78.45 142.99,77.68 142.99,66.84 141.34,65.19 141.34,63 142.25,62.09 142.25,60.23 143.75,58.74 143.75,56.66 146.62,53.79 146.62,50.28 146.04,49.69 146.04,47.31 144.61,45.88 144.61,40.27 147.46,37.42 147.85,37.42 148.3,36.97 148.66,36.97 148.9,36.73 149.24,36.73 149.64,36.34 152.97,36.34 153.17,36.54 153.49,36.54 153.62,36.66 154.2,36.66 154.61,37.07 155.15,37.07 155.31,37.22 157.39,37.22 158.05,36.56 159.61,36.56 159.79,36.38 160.17,36.38 160.45,36.1 162.22,36.1 163.05,35.27 163.95,35.27 164.3,34.92 164.75,34.92 v2(165.42,34.25)
  BOTTOM w0.152: 66.76,120.74 66.84,120.82 PR128.1
  BOTTOM w0.178: 66.76,120.74 66.42,120.4 ; 66.42,120.4 PR131.1 ; 66.42,120.4 66.42,120.37 67.24,119.54 v1(67.24,119.37)
I2CA_SCL: length 10.3
  BOTTOM w0.102: U22.B7 98.84,93.44 98.84,92.7
  BOTTOM w0.305: 98.84,92.7 98.84,92.17 98.21,91.54 95.95,91.54 95.47,91.05 93.16,91.05 91.6,89.5 R556.1
I2CA_SDA: length 9.1
  BOTTOM w0.305: R557.1 92.57,89.85 93.34,90.62 95.64,90.62 96.13,91.11 98.39,91.11 99.3,92.02 99.3,92.96 U22.A7
ICMNT: length 79.1
  TOP w0.102: 200.59,15.99 200.25,15.99 199.65,16.58 U13.67 198.1,16.58 197.97,16.71 197.97,17.5 197.45,18.01 196.28,18.01 195.15,19.14 193.71,19.14 193.61,19.24 193.61,19.8 193.1,20.31 193.1,20.71 193.38,20.99 193.38,22.65 192.67,23.35 190.23,23.35 v2(189.55,24.04) ; 200.59,15.99 200.57,15.96 200.57,15.03 C457.2 ; 200.59,15.99 v1(200.62,16.01)
  IN2 w0.089: v2(136.76,32.29) 137.15,31.91 141.62,31.91 142.25,31.29 151.48,31.29 151.92,30.85 155.52,30.85 155.91,30.46 158.89,30.46 159.31,30.05 160.61,30.05 160.7,29.96 161.66,29.96 162.2,30.5 162.84,30.5 163.22,30.12 164.01,30.12 164.23,29.9 174.7,29.9 175.28,29.32 175.28,28.27 175.61,27.94 177.25,27.94 177.44,27.75 178.57,27.75 179.72,26.61 182.39,26.61 183.53,25.47 185.29,25.47 185.76,25.94 189.14,25.94 189.44,25.64 189.44,24.14 v2(189.55,24.04)
  BOTTOM w0.203: v2(136.76,32.29) 136.66,32.4 PR249.1 136.74,32.82 137.41,33.49 PC235.2
IDCHG_R: length 93
  TOP w0.102: U13.68 199.86,16.98 199.96,17.08 200.51,17.08 C453.2 201.48,16 201.86,15.61 202.47,15.61 202.8,15.94 v1(202.8,16.95) 202.8,17.28 v2(202.58,17.51)
  TOP w0.203: v2(138.06,32.88) 138.06,33.45 138.1,33.49 PC73.2
  IN1 w0.089: v2(138.06,32.88) 138.06,32.8 138.39,32.47 140.88,32.47 141.54,33.13 142.91,33.13 145.2,30.85 150.64,30.85 151.16,30.33 154.38,30.33 154.75,29.96 158.3,29.96 158.56,29.7 162.46,29.7 162.89,29.27 169.91,29.27 171,28.18 175.45,28.18 175.6,28.03 177.6,28.03 177.76,27.87 182.38,27.87 183.15,28.64 187.68,28.64 188.2,28.12 188.2,27.47 188.05,27.32 187.29,27.32 186.24,26.28 186.17,26.28 185.61,25.72 185.61,25.49 185.93,25.17 186.21,25.17 186.5,25.46 186.5,25.87 187.01,26.38 190.97,26.38 191.32,26.02 193.48,26.02 193.86,25.64 194.5,25.64 194.96,25.18 194.96,24.75 196.02,23.68 196.02,21.83 196.53,21.32 196.53,20.05 196.66,19.93 197.29,19.93 197.55,20.18 197.8,20.18 198.18,20.56 199.58,20.56 200.67,21.65 202.17,21.65 202.63,21.2 202.63,18.78 202.88,18.53 202.88,17.64 202.75,17.51 v2(202.58,17.51)
  BOTTOM w0.203: v2(138.06,32.88) 137.86,32.88 137.68,32.7 PR250.1
ILIM_HI: length 2.4
  TOP w0.102: U7.16 17.86,47.88 17.62,48.12 v1(16.98,48.12) 16.7,47.84 R235.2
ILIM_LO: length 2.8
  TOP w0.102: v1(15.87,48.8) 15.88,48.78 R223.2 16.96,48.78 17.37,48.38 U7.15
IMONCPU_1: length 35.8
  IN1 w0.102: v1(144.21,51.01) 143.83,51.39 143.83,51.43 141.97,53.29 141.97,54.58 140.48,56.07 140.48,57.82 137.49,60.81 134.51,60.81 131.44,63.87 131.44,66.52 128.89,69.07 124.12,69.07 123.86,69.33 v1(123.86,69.46)
  BOTTOM w0.178: v1(123.86,69.46) 123.86,69.07 123.35,68.57 123.35,67.22 PR161.2
  BOTTOM w0.254: PR191.2 144.84,51.29 144.56,51.01 v1(144.21,51.01)
IMVP_PWRGD: length 137.4
  TOP w0.102: v1(107.43,30.71) 107.25,30.53 107.25,29.58 v1(106.62,28.94) 105.98,28.31 105.98,28.05 105.41,27.49 101.1,27.49 100.65,27.04 100.65,26.66 100.9,26.4 100.9,25.13 99.6,23.84 94.39,23.84 93.58,23.03 93.58,21.75 v1(93.47,21.64) ; PR53.1 135.14,57.97 135.24,57.87 PR55.2 134.73,57.67 134.28,57.21 v1(133.08,57.21) ; Q12.2 v1(111.25,65.42)
  IN1 w0.089: v1(111.25,65.42) 111.25,62.41 115.84,57.82 120.18,57.82 120.94,58.58 123.73,58.58 124.22,58.1 124.22,55.59 125.26,54.55 131.15,54.55 132.75,56.15 132.75,56.88 v1(133.08,57.21) ; v1(64.68,30.49) 64.45,30.26 63.43,30.26 63.16,29.98 63.16,29.6 65.06,27.7 65.06,27.67 65.47,27.27 65.47,25.64 65.85,25.26 69.23,25.26 70.4,24.08 74.86,24.08 76.45,22.5 79.21,22.5 79.86,23.14 80.75,23.14 80.95,23.34 89.65,23.34 90.78,22.21 92.14,22.21 92.71,21.64 v1(93.47,21.64)
  IN3 w0.089: v1(111.25,65.42) 110.97,65.14 110.97,62.71 110.54,62.28 110.54,57.2 108.27,54.93 108.27,52.83 106.72,51.28 106.72,49.26 107.02,48.96 107.71,48.96 107.81,48.86 107.81,44.89 108.01,44.69 108.01,43.42 108.65,42.79 108.65,42.4 109.21,41.84 109.21,38.13 110.08,37.26 110.08,36.08 110.56,35.59 110.56,34.49 110.42,34.35 110.42,31.42 109.35,30.34 107.8,30.34 v1(107.43,30.71)
  BOTTOM w0.102: R702.2 63.94,31.48 64.68,30.75 v1(64.68,30.49)
IN_CLK: length 116.4
  TOP w0.102: v1(27.37,84.06) 26.95,83.64 26.95,83.54 26.86,83.45 26.86,82.97 27.41,82.42 27.41,81.46 27.21,81.27 26.07,81.27 26,81.34 C187.1
  IN3 w0.089: v1(27.37,84.06) 27.37,83.98 27.14,83.76 26.94,83.76 26.85,83.85 26.85,84.14 27.32,84.62 27.83,84.62 28.08,84.86 28.08,85.15 29.61,86.69 29.61,90.52 31.35,92.26 31.35,94.78 33.07,96.49 44.15,96.49 44.55,96.89 49.21,96.89 50.15,97.83 51.84,97.83 52.62,98.61 54.44,98.61 55.65,97.4 59.88,97.4 61.15,98.67 66.45,98.67 66.81,98.31 69.96,98.31 71.3,96.98 75.33,96.98 76.89,95.41 77.49,95.41 77.61,95.3 77.61,94.4 80.45,91.55 80.45,91.14 81.89,89.7 87.51,89.7 89.98,87.23 89.98,82.03 90.18,81.82 90.18,81.57 92.58,79.17 93.22,79.17 93.58,78.8 93.58,75.76 93.48,75.66 93.48,73.06 93.94,72.6 95.52,72.6 95.62,72.5 95.62,72.16 96.78,71 96.78,70.26 98.04,69 98.68,69 99.45,68.23 100.42,68.23 100.51,68.15 100.51,68.02 v2(100.32,67.83)
  BOTTOM w0.079: v2(100.32,67.83) 100.44,67.83 100.52,67.91 100.52,68.18 100.39,68.31 99.5,68.31 99.2,68.62 99.2,68.89 98.28,69.81 98.2,69.81 98.02,69.98 97.89,69.98 97.63,70.25 U24.AC2
IN_CLK#: length 116.4
  TOP w0.102: R116.1 26,80.84 26.21,81.05 27.3,81.05 27.62,81.37 27.62,82.51 27.07,83.06 27.07,83.36 27.14,83.43 v1(27.37,83.43)
  IN3 w0.089: v2(100.9,67.83) 100.71,68.02 100.71,68.23 100.5,68.44 99.53,68.44 98.77,69.2 98.12,69.2 96.98,70.34 96.98,71.09 95.82,72.25 95.82,72.59 95.6,72.81 94.02,72.81 93.69,73.15 93.69,75.58 93.79,75.68 93.79,78.89 93.3,79.37 92.67,79.37 90.38,81.66 90.38,81.91 90.18,82.11 90.18,87.31 87.59,89.9 81.98,89.9 80.66,91.22 80.66,91.64 77.81,94.48 77.81,95.38 77.58,95.62 76.98,95.62 75.41,97.18 71.38,97.18 70.05,98.51 66.89,98.51 66.53,98.87 61.06,98.87 59.79,97.6 55.74,97.6 54.52,98.82 52.54,98.82 51.75,98.03 50.07,98.03 49.13,97.09 44.46,97.09 44.07,96.7 32.98,96.7 31.15,94.86 31.15,92.35 29.41,90.61 29.41,86.77 27.87,85.24 27.87,84.95 27.75,84.82 27.24,84.82 26.65,84.23 26.65,83.76 26.86,83.55 27.24,83.55 v1(27.37,83.43)
  BOTTOM w0.079: v2(100.9,67.83) 100.69,68.04 100.69,68.25 100.46,68.48 99.57,68.48 99.37,68.69 99.37,68.96 98.35,69.98 98.27,69.98 98.05,70.19 U24.AC1
IN_CLK#_R: length 13.1
  TOP w0.102: v1(26.94,80.61) 26.91,80.63 R116.2
  BOTTOM w0.102: v1(26.94,80.61) 26.94,80.99 26.83,81.09 25.22,81.09 24.58,80.46 19.46,80.46 19.16,80.16 17.67,80.16 17.47,80.36 16.87,80.36 D26.2 16.27,80.36 15.92,80.36 15.78,80.22 C562.1
IN_CLK_R: length 13.2
  TOP w0.102: R110.2 26.86,81.77 v1(26.94,81.7)
  BOTTOM w0.102: C561.1 15.78,80.76 15.96,80.58 16.27,80.58 D25.2 16.87,80.58 17.56,80.58 17.76,80.38 19.07,80.38 19.37,80.68 24.49,80.68 25.13,81.31 26.83,81.31 26.94,81.41 v1(26.94,81.7)
IN_D0: length 125.1
  TOP w0.102: v1(27.62,75.81) 27.62,75.77 27.38,75.53 27.21,75.53 27.17,75.56 26.06,75.56 26,75.62 C203.1
  IN3 w0.089: v2(100.32,68.85) 100.52,69.05 100.52,69.17 100.45,69.23 99.31,69.23 98.94,69.61 98.27,69.61 97.38,70.51 97.38,71.45 96.32,72.51 96.32,73.02 96,73.33 96,73.83 96.3,74.14 96.3,76.56 94.19,78.67 94.19,79.81 91.15,82.86 91.15,87.62 90.08,88.68 90.08,89.18 89.69,89.57 88.67,89.57 87.94,90.31 82.13,90.31 81.05,91.39 81.05,91.81 78.22,94.64 78.22,95.84 78.01,96.05 77.1,96.05 75.58,97.58 71.66,97.58 70.31,98.92 67.21,98.92 66.65,99.48 64.11,99.48 63.86,99.73 59.29,99.73 58.53,98.97 56.27,98.97 55.84,99.4 52.14,99.4 51.28,98.54 44.88,98.54 43.43,97.09 32.78,97.09 30.69,95.01 30.69,94.07 30.7,94.07 30.7,92.45 29.02,90.77 29.02,88.23 26.83,86.04 26.83,85.02 25.81,83.99 25.81,82.41 25.16,81.76 25.16,78.18 26.54,76.8 26.54,75.87 26.82,75.59 27.41,75.59 v1(27.62,75.81)
  BOTTOM w0.079: v2(100.32,68.85) 100.37,68.85 100.58,69.06 100.58,69.21 100.5,69.29 99.42,69.29 98.23,70.48 98.16,70.51 97.98,70.51 97.87,70.47 97.64,70.47 97.58,70.48 97.46,70.51 97.35,70.51 97.11,70.45 97.05,70.38 97.05,70.05 96.83,69.84 96.67,69.84 96.41,70.11 96.41,70.32 96.51,70.42 96.69,70.42 96.75,70.35 U24.AC3
IN_D0#: length 125.2
  TOP w0.102: v1(27.62,75.17) 27.48,75.31 27.12,75.31 27.08,75.35 26.28,75.35 26,75.07 C206.1
  IN3 w0.089: v1(27.62,75.17) 27.41,75.39 26.74,75.39 26.33,75.79 26.33,76.71 24.95,78.09 24.95,81.84 25.61,82.5 25.61,84.08 26.63,85.1 26.63,86.13 28.81,88.31 28.81,90.86 30.49,92.53 30.49,95.09 32.69,97.29 43.34,97.29 44.8,98.75 51.2,98.75 52.06,99.6 55.92,99.6 56.36,99.17 58.45,99.17 59.21,99.94 63.94,99.94 64.2,99.68 66.74,99.68 67.3,99.12 70.4,99.12 71.74,97.78 75.66,97.78 77.19,96.25 78.09,96.25 78.42,95.92 78.42,94.73 81.25,91.9 81.25,91.48 82.22,90.51 88.02,90.51 88.76,89.78 89.77,89.78 90.28,89.27 90.28,88.77 91.35,87.7 91.35,82.94 94.4,79.89 94.4,78.75 96.51,76.64 96.51,74.05 96.2,73.75 96.2,73.42 96.52,73.1 96.52,72.59 97.58,71.53 97.58,70.59 98.36,69.81 99.02,69.81 99.39,69.44 100.54,69.44 100.72,69.25 100.72,69.02 v2(100.9,68.85)
  BOTTOM w0.079: v2(100.9,68.85) 100.75,69 100.75,69.28 100.57,69.46 99.49,69.46 98.33,70.61 98.2,70.68 97.96,70.68 97.84,70.64 97.66,70.64 97.61,70.65 97.47,70.68 97.33,70.68 97.17,70.64 96.97,70.59 96.96,70.59 96.44,70.59 U24.AC5
