# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.8V_DEEP_SUS on TOP (solid shape): 108.85,51.01 108.85,50.38 107.86,49.39 106.72,49.39 106.44,49.67 106.41,49.67 106.36,49.72 106.36,50.96 106.56,51.17 108.7,51.17
+1.8V_DEEP_SUS on TOP (solid shape): 100.19,42.91 100.19,42.48 100.26,42.4 100.9,42.4 101.15,42.15 101.15,41.64 101.41,41.39 102.04,41.39 102.37,41.06 102.37,39.53 102.2,39.36 100.65,39.36 99.38,40.63 99.35,40.63 99.17,40.8 99.17,42.81 99.43,43.06 100.04,43.06
+1.8V_DEEP_SUS on TOP (solid shape): 146.42,24.5 146.42,23.99 146.57,23.84 146.57,21.12 146.87,20.81 146.9,20.81 147.08,20.64 147.44,20.64 147.6,20.47 148.04,20.47 148.58,19.94 148.58,18.65 148.42,18.5 148.19,18.5 148.07,18.63 148.07,19.54 147.45,20.16 147.43,20.23 147.37,20.27 147.36,20.27 147.3,20.34 145.8,20.34 145.71,20.43 145.71,23 146.01,23.3 146.01,24.04 146,24.05 146,24.48 146.09,24.57 146.34,24.57
+1.8V_DEEP_SUS on BOTTOM (solid shape): 89.99,39.6 90.82,39.6 91.02,39.39 91.02,39.09 90.9,38.96 90.72,38.96 90.18,38.42 89.19,38.42 89.18,38.44 89.15,38.41 88.36,38.41 88.14,38.63 88.14,39.48 88.26,39.6 88.43,39.6 88.66,39.83 88.89,39.83 89.03,39.68 89.04,39.69 89.09,39.64 89.27,39.64 89.47,39.84 89.75,39.84
+1.8V_DEEP_SUS on IN2 (solid shape): outline of 1815 points within 81.01,38.89 107.61,50.96
+1.8V_S5 on TOP (solid shape): 28.76,34.66 28.76,33.51 28.89,33.39 30.03,33.39 30.67,32.75 30.67,28.13 30.62,28.08 28.51,28.08 27.11,29.48 27.11,31.3 27.29,31.48 27.29,31.63 27.32,31.65 27.32,32.07 27.29,32.1 27.29,32.42 26.99,32.73 26.99,34.66 27.24,34.91 28.51,34.91
+1.8V_S5 on TOP (solid shape): 25.46,92.44 25.46,91.68 25.59,91.55 25.59,90.51 25.44,90.36 25.13,90.36 24.45,91.05 24.19,91.05 23.25,91.99 23.25,92.71 23.24,92.72 23.24,92.95 23.25,92.99 23.29,93 23.39,93 23.43,92.99 23.44,92.95 23.44,92.23 23.64,92.23 23.64,92.95 23.65,92.99 23.69,93 23.84,93 23.9,93.01 23.94,93.06 23.98,93.08 24.83,93.08
+1.8V_S5 on TOP (solid shape): 21.14,93.06 21.15,93.05 21.19,93.01 21.25,93 21.39,93 21.43,92.99 21.44,92.95 21.44,92.23 21.64,92.23 21.64,92.95 21.65,92.99 21.69,93 21.79,93 21.83,92.99 21.84,92.95 21.84,92.72 21.84,92.71 21.84,91.76 21.78,91.65 21.76,91.53 21.78,91.41 21.84,91.3 21.84,90.83 21.8,90.76 21.78,90.69 21.78,90.54 21.52,90.28 18.98,90.28 18.35,90.92 18.35,92.7 18.73,93.08 21.1,93.08
+1.8V_S5 on TOP (solid shape): outline of 594 points within 100.14,29.6 106.84,38.98
+1.8V_S5 on BOTTOM (solid shape): outline of 175 points within 20.56,24.88 28.64,30.49
+1.8V_S5 on IN1 (solid shape): 24.57,92.32 24.57,90.79 23.81,90.03 19.87,90.03 19.49,90.41 19.49,91.05 21.02,92.57 24.32,92.57
+1.8V_S5 on SVCC (solid shape): outline of 87 points within 27.88,28.31 106.87,36.43
+1.8V_S5 on IN3 (solid shape): 145.1,36.82 145.1,35.44 144.99,35.34 144.99,33.94 144.92,33.65 145.1,33.41 145.1,33.01 144.97,32.88 144.21,32.88 144.02,33.06 144.02,33.24 144.05,33.31 144.13,33.34 144.38,33.94 143.81,33.63 143.81,33.6 143.76,33.55 143.7,33.61 143.7,34.62 143.87,34.79 143.87,35.67 143.74,35.8 143.74,36.73 144.08,37.07 144.84,37.07
+1.8V_S5 on IN3 (solid shape): outline of 3637 points within 14.92,28.56 30.67,92.57
+1.8V_SW on BOTTOM (solid shape): 15.94,26.45 15.94,25.51 15.81,25.39 15.35,25.39 15.17,25.21 15.17,24.75 15,24.57 14.67,24.57 14.62,24.62 14.62,25.79 14.92,26.1 14.92,26.33 15.17,26.58 15.81,26.58
+1.8V_SW on BOTTOM (solid shape): 19.79,26.67 20.12,26.67 20.24,26.54 20.24,26.24 20.46,26.02 20.46,25.61 20.33,25.49 20.25,25.49 19.98,25.77 19.34,25.77 19.19,25.92 19.19,26.73 19.32,26.86 19.59,26.86
+1.35V_GFX on TOP (solid shape): outline of 84 points within 110.3,103.53 111.82,107.68
+1.35V_GFX on TOP (solid shape): outline of 1062 points within 109.52,96.32 132.57,106.41
+1.35V_GFX on TOP (solid shape): outline of 2584 points within 129.35,78.42 142.94,117.98
+1.35V_GFX on BOTTOM (solid shape): outline of 207 points within 103.39,96.4 111.86,108.19
+1.35V_GFX on BOTTOM (solid shape): outline of 6959 points within 118.76,79.04 142.94,120.31
+1.35V_GFX on IN1 (solid shape): outline of 1902 points within 124.52,80.38 142.97,88.12
+1.35V_GFX on IN2 (solid shape): outline of 14651 points within 103.44,80.89 142.71,118.99
+1.35V_GFX on IN3 (solid shape): outline of 194 points within 127.06,105.09 131.76,109.05
+1.35V_GFX on IN3 (solid shape): outline of 5332 points within 104.3,80.15 142.94,120.77
+1V8_AON on TOP (solid shape): 102.42,98.54 102.42,98.42 102.41,98.4 102.36,98.28 102.33,98.15 102.33,97.49 102.42,97.4 102.42,97.4 102.04,97.01 101.15,97.01 101.03,96.89 100.26,96.89 100.14,97.01 100.14,98.05 100.14,98.28 100.39,98.54 101.79,98.54 101.92,98.67 102.3,98.67
+1V8_AON on TOP (solid shape): 27.11,98.28 27.11,95.87 26.91,95.67 25.92,95.67 25.72,95.87 25.72,96.15 25.73,96.19 25.84,96.24 25.88,96.33 25.88,97.68 25.88,97.69 25.88,98.42 26.2,98.74 26.66,98.74
+1V8_AON on BOTTOM (solid shape): 99.45,122.97 99.45,122.77 99.34,122.64 99.3,122.46 99.41,122.19 99.68,122.08 99.77,122.09 99.86,122.13 99.96,122.13 100.01,122.04 100.01,120.1 99.73,119.82 99.02,119.82 98.66,120.18 98.66,120.79 98.36,121.09 98.36,121.7 98.16,121.91 97.85,121.91 97.72,122.03 97.72,122.31 98,122.59 98,123.68 98.74,123.68
+1V8_AON on BOTTOM (solid shape): outline of 93 points within 83.42,85.53 98.69,98.03
+1V8_AON on IN1 (solid shape): 27.27,97.12 27.27,95.64 27.11,95.49 25.97,95.49 25.59,95.87 25.59,96.89 25.84,97.14 27.24,97.14
+1V8_AON on IN1 (solid shape): outline of 340 points within 70.55,95.85 84.55,99.61
+1V8_AON on IN1 (solid shape): outline of 505 points within 44.13,96.82 63.69,101.23
+1V8_AON on IN1 (solid shape): outline of 1007 points within 97.69,84.74 108.37,99.71
+1V8_GFX_MAIN on TOP (solid shape): 24.6,103.59 24.6,103.06 22.31,100.77 22.19,100.77 21.28,101.68 21.25,101.71 21.25,101.92 23.05,103.72 23.05,103.75 23.43,104.13 24.06,104.13
+1V8_GFX_MAIN on TOP (solid shape): outline of 171 points within 89.22,98.03 99.88,105.52
+1V8_GFX_MAIN on TOP (solid shape): outline of 354 points within 111.57,111.24 120.46,121.27
+1V8_GFX_MAIN on BOTTOM (solid shape): 120.58,117.97 120.58,115.56 120.46,115.43 118.04,115.43 117.66,115.81 117.66,117.84 117.92,118.1 120.46,118.1
+1V8_GFX_MAIN on BOTTOM (solid shape): 101.15,98.54 101.15,97.93 101.02,97.79 100.97,97.74 100.94,97.68 100.92,97.66 100.89,97.65 100.01,97.65 99.38,98.28 99.25,98.28 98.87,98.67 98.87,99.05 98.99,99.17 100.52,99.17
+1V8_GFX_MAIN on IN1 (solid shape): outline of 1033 points within 101.76,109.16 120.28,119.06
+1V8_GFX_MAIN on IN3 (solid shape): 24.05,104.49 24.05,104.47 24.18,104.28 24.4,104.2 24.51,104.22 24.61,104.28 24.65,104.29 24.68,104.27 24.7,104.25 24.7,103.24 24.32,102.86 23.11,102.86 22.99,102.98 22.99,103.62 23.87,104.51 24.02,104.51
+1V8_GFX_MAIN on IN3 (solid shape): outline of 1688 points within 98.84,97.73 119.85,119.04
+2.5V_SUS on TOP (solid shape): 36,34.15 36,32.88 35.62,32.5 33.84,32.5 33.46,32.88 33.46,34.53 33.72,34.78 35.37,34.78
+2.5V_SUS on TOP (solid shape): 68.35,102.89 68.35,102.31 67.56,101.52 67.41,101.52 67.02,101.92 67.02,102.88 67.24,103.11 68.13,103.11
+2.5V_SUS on TOP (solid shape): outline of 107 points within 47.05,91.43 53.02,96.76
+2.5V_SUS on BOTTOM (solid shape): 34.91,33.84 34.91,33.39 34.78,33.26 33.59,33.26 33.46,33.39 33.46,34.86 33.56,34.96 33.79,34.96
+2.5V_SUS on BOTTOM (solid shape): 53.02,97.4 53.02,95.74 52.89,95.62 51.59,95.62 51.34,95.36 49.34,95.36 49.34,95.58 51.13,95.58 51.13,95.83 49.34,95.83 49.34,97.14 50.48,98.28 52.13,98.28
+2.5V_SUS on BOTTOM (solid shape): 59.62,123.3 59.62,122.47 59.42,122.26 59.42,122.21 59.37,122.16 59.37,118.53 59.19,118.35 57.69,118.35 57.47,118.58 57.47,123.18 57.85,123.56 59.37,123.56
+2.5V_SUS on BOTTOM (solid shape): outline of 474 points within 18.35,85.08 31.24,102.86
+2.5V_SUS on IN1 (solid shape): 70.55,118.99 70.55,117.56 70.37,117.38 69.52,117.38 69.23,117.51 68.95,117.38 68.03,117.38 65.9,115.25 65.9,110.08 65.67,109.71 65.9,109.35 65.9,108.24 66.48,107.66 66.48,106.79 68.76,104.52 68.76,102.61 68.51,102.37 67.58,102.37 66.76,103.19 66.76,104.79 65.37,106.18 64.91,106.18 64.56,106.54 64.56,107.2 64.71,107.34 64.71,107.79 64.44,108.06 64.44,117.24 65.13,117.93 66.95,117.93 67.44,118.42 67.51,118.47 67.56,118.54 67.63,118.6 67.63,118.81 67.8,118.98 68.34,118.98 68.64,119.28 68.64,119.7 68.55,119.79 68.64,119.87 69.66,119.87
+2.5V_SUS on IN3 (solid shape): outline of 207 points within 57.95,116.45 70.67,119.56
+3V on TOP (solid shape): 59.5,102.6 59.5,101.97 59.37,101.84 59.04,101.84 58.91,101.97 58.48,101.97 58.35,102.09 58.35,102.6 58.63,102.88 59.22,102.88
+3V on TOP (solid shape): 148.65,22.39 148.65,22.21 148.28,21.84 148.28,21.78 148.27,21.74 148.27,21.69 148.27,21.4 148.21,21.34 147.93,21.34 147.76,21.5 147.76,22.03 148.38,22.64 148.4,22.64
+3V on TOP (solid shape): 26.17,6.23 26.52,6.23 26.52,6.23 27.57,6.23 27.62,6.29 27.82,6.29 27.95,6.16 27.95,5.04 27.42,4.51 27.42,2.83 26.86,2.27 25.33,2.27 25.21,2.4 25.21,3.67 25.2,3.68 25.2,3.86 24.95,4.1 24.95,6.34 25.08,6.46 25.94,6.46
+3V on TOP (solid shape): 18.1,88 18.1,85.97 17.94,85.81 17.94,84.97 18.35,84.57 19.68,84.57 20.03,84.22 20.03,83.86 19.98,83.81 18.53,83.81 18.4,83.93 17.57,83.93 17.47,84.03 17.47,84.94 16.79,85.62 16.75,85.69 16.7,85.74 16.7,87.87 16.96,88.12 17.97,88.12
+3V on TOP (solid shape): 26.35,84.19 26.35,83.68 26.22,83.55 25.84,83.55 25.72,83.43 25.72,82.54 25.59,82.41 24.57,82.41 24.45,82.54 24.45,82.92 24.32,83.04 23.68,83.04 23.56,82.92 23.56,81.77 23.68,81.65 23.68,80.73 23.52,80.57 22.91,80.57 22.88,80.6 22.88,81.78 22.79,81.87 22.79,84.06 23.05,84.31 26.22,84.31
+3V on TOP (solid shape): 24.32,76.26 24.32,75.3 25.21,74.41 25.97,74.41 26.1,74.28 26.1,73.01 25.93,72.85 25.87,72.81 25.81,72.76 24.31,72.76 24.17,72.9 23.71,72.9 23.67,72.86 23.56,72.86 22.88,73.54 22.88,74.2 22.54,74.54 22.16,74.54 21.91,74.79 21.91,75.3 21.98,75.37 23.25,75.37 23.43,75.55 23.43,76.06 23.65,76.27 24.31,76.27
+3V on TOP (solid shape): 64.45,42.53 64.45,42.23 63.38,42.23 63.26,42.35 62.06,42.35 61.89,42.18 61.8,42.1 61.76,41.98 61.76,41.7 61.77,41.65 61.78,41.6 61.78,40.37 61.66,40.25 61.4,40.25 61.3,40.35 61.3,42.46 61.42,42.58 61.78,42.58 61.86,42.66 61.86,42.76 62.04,42.94 64.04,42.94
+3V on TOP (solid shape): 203.21,13.04 203.21,12.74 204.23,11.72 204.23,11.42 204.64,11.01 205.26,11.01 205.34,10.93 205.34,10.7 205.75,10.3 207.53,10.3 207.63,10.2 207.63,9.74 207.58,9.69 204.66,9.69 203.91,10.44 203.91,10.55 203.52,10.94 203.52,11.8 203.12,12.2 202.98,12.2 202.5,12.69 202.5,13.12 202.63,13.24 203.01,13.24
+3V on TOP (solid shape): 52.76,106.03 52.86,105.96 52.97,105.94 52.99,105.94 53.02,105.9 53.02,105.18 53.02,105.17 53.02,104.62 53.02,104.61 53.02,104.13 52.89,104 51.62,104 51.5,104.13 51.5,105.52 51.53,105.53 51.69,105.67 51.75,105.88 51.75,105.93 51.73,106.01 51.78,106.06 52.73,106.06
+3V on TOP (solid shape): 151.54,29.61 151.54,28.31 151.32,28.08 151.32,27.17 151.22,27.07 151.22,26.7 151.22,26.68 151.53,26.37 151.55,26.26 151.46,26.2 151.41,26.2 151.32,26.16 151.28,26.07 151.28,24.75 149.29,24.75 149.03,25.01 149.03,26.99 148.65,27.37 148.65,28.66 148.69,28.74 148.7,28.84 148.69,28.94 148.65,29.03 148.65,29.15 148.55,29.25 148.55,29.6 148.65,29.7 151.45,29.7
+3V on TOP (solid shape): 205.5,27.34 205.5,27.22 205.57,27.06 205.73,26.99 205.93,26.99 206.05,26.87 206.03,26.83 205.99,26.75 205.98,26.66 206,26.55 206.05,26.45 206.06,26.43 206.06,26.4 206.03,26.36 205.98,26.32 205.94,26.28 205.86,26.32 205.78,26.33 205.64,26.3 205.53,26.23 205.46,26.2 205.39,26.23 205.29,26.33 204.84,26.33 204.56,26.61 204.56,27.29 204.62,27.35 204.84,27.35 204.9,27.35 204.97,27.37 205.47,27.37
+3V on TOP (solid shape): outline of 180 points within 132.2,17.89 136.92,27.21
+3V on BOTTOM (solid shape): 59.62,104.38 59.62,102.22 59.24,101.84 58.42,101.84 57.75,102.51 57.75,103.4 58.86,104.51 59.5,104.51
+3V on BOTTOM (solid shape): 24.83,75.93 24.83,74.41 24.57,74.15 22.41,74.15 22.16,74.41 22.16,75.79 22.29,75.92 23.43,75.92 23.7,76.19 24.57,76.19
+3V on BOTTOM (solid shape): 212.79,26.78 212.79,25.89 211.9,25.01 211.62,25.01 211.58,25.02 211.57,25.06 211.57,25.77 212.15,26.35 212.15,26.39 212.18,26.45 212.18,26.51 212.18,26.79 212.36,26.96 212.61,26.96
+3V on BOTTOM (solid shape): 216.27,33.62 216.27,31.28 216.22,31.23 215.58,31.23 215.45,31.36 215.45,31.89 214.59,32.75 214.34,32.75 214.28,32.8 212.79,32.8 212.79,33.05 214.1,33.05 214.1,33.25 212.79,33.25 212.79,33.55 214.1,33.55 214.1,33.75 212.79,33.75 212.79,34.05 214.1,34.05 214.39,34.05 214.49,34.15 215.73,34.15
+3V on BOTTOM (solid shape): 198.32,27.3 198.32,26.87 198.51,26.68 198.51,25.87 198.49,25.84 198.39,25.84 198.33,25.79 197.7,25.79 197.7,25.84 197.67,25.98 197.6,26.11 197.6,26.39 197.6,26.54 197.61,26.55 197.61,26.84 197.92,27.15 198,27.22 198.06,27.3 198.13,27.37 198.26,27.37
+3V on BOTTOM (solid shape): 195.3,29.56 195.43,29.56 195.52,29.52 195.62,29.5 195.82,29.5 196.56,28.76 196.56,28.33 196.27,28.04 196.23,28.08 196.06,28.18 195.86,28.22 195.5,28.22 195.34,28.19 195.19,28.12 195.13,28.18 194.47,28.18 194.42,28.23 194.42,29.5 194.5,29.58 195.29,29.58
+3V on BOTTOM (solid shape): 102.17,123.99 102.17,123.18 101.92,122.92 101.92,122.01 101.9,121.97 101.87,121.96 100.72,121.96 100.71,121.97 100.71,122.35 100.7,122.4 100.66,122.44 100.65,122.47 100.65,122.8 100.78,122.93 100.8,122.93 100.96,122.99 101.02,123.15 101.02,123.17 101.13,123.28 101.13,123.86 101.36,124.09 102.07,124.09
+3V on BOTTOM (solid shape): 60.45,45.05 60.51,45.04 60.77,45.04 60.77,44.97 60.75,44.94 60.72,44.92 60.62,44.89 60.53,44.83 60.29,44.59 60.27,44.58 60.2,44.54 60.17,44.46 60.17,44.25 60.2,44.17 60.29,44.13 60.38,44.07 60.49,44.05 60.6,44.07 60.69,44.13 60.76,44.16 60.8,44.23 60.81,44.24 60.88,44.31 61.91,44.31 61.96,44.26 61.96,43.85 61.85,43.74 61.85,43.59 61.78,43.57 61.64,43.57 61.51,43.67 61.35,43.7 61.21,43.67 61.08,43.59 61.07,43.57 61.02,43.57 60.99,43.58 60.97,43.59 60.76,43.59 60.68,43.55 60.64,43.47 60.58,43.38 60.56,43.27 60.58,43.16 60.64,43.07 60.68,42.98 60.76,42.95 60.97,42.95 60.99,42.95 61.02,42.96 61.21,42.96 61.29,42.94 61.35,42.94 61.42,42.94 61.49,42.96 61.63,42.96 61.63,42.88 61.66,42.77 61.72,42.67 61.85,42.54 61.85,42.51 61.23,41.9 59.75,41.9 59.5,42.15 59.5,44.94 59.62,45.07 60.38,45.07
+3V on BOTTOM (solid shape): outline of 169 points within 81.6,96.76 91.5,100
+3V on BOTTOM (solid shape): outline of 212 points within 16.7,81.9 26.1,88.38
+3V on IN1 (solid shape): 55.01,104.28 55.14,104.19 55.31,104.15 57.54,104.15 57.58,104.11 57.72,104.02 57.88,103.99 59.29,103.99 59.62,103.65 59.62,101.97 59.5,101.84 58.61,101.84 57.85,102.6 56.97,102.6 56.81,102.75 52.72,102.75 52.64,102.78 52.51,103.11 52.26,103.21 52.17,103.2 51.95,103.41 51.95,105.93 52.08,106.06 53.23,106.06
+3V on IN1 (solid shape): outline of 275 points within 22.92,28.05 34.22,39.86
+3V on IN2 (solid shape): outline of 1876 points within 56.18,21.58 97.32,30.09
+3V on IN2 (solid shape): outline of 9508 points within 15.56,5.69 61.07,115.3
+3V on SVCC (solid shape): 65.97,32.01 65.97,27.78 65.49,27.29 64.94,27.29 64.69,27.54 64.59,27.78 64.34,27.89 64.25,27.98 64.17,28.03 64.07,28.05 60.07,28.05 59.9,28.1 59.72,28.05 59.28,28.05 59.07,28.13 58.86,28.05 58.41,28.05 58.2,28.13 57.99,28.05 57.55,28.05 57.34,28.13 57.13,28.05 55.46,28.05 54.35,29.61 53.24,28.05 53.07,28.05 52.77,28.26 52.46,28.05 51.54,28.05 51.19,28.3 50.85,28.05 46.19,28.05 45.99,28.12 45.78,28.05 35.75,28.05 35.65,28.03 35.57,27.98 31.96,24.37 30.77,24.37 29.53,25.62 29.53,27.95 30.34,28.76 30.4,28.84 30.42,28.94 30.42,30.11 31.54,31.23 39.81,31.23 39.91,30.98 40.16,30.88 40.36,30.94 40.49,31.11 40.62,30.94 40.83,30.87 41.08,30.98 41.18,31.23 43.74,31.23 44.11,30.91 44.47,31.23 52.06,31.23 52.41,30.87 52.77,31.23 58.99,31.23 59.09,31.25 59.17,31.3 60.24,32.37 65.62,32.37
+3V on SVCC (solid shape): outline of 412 points within 48.82,23.61 217.28,126.48
+3V3_TPM on TOP (solid shape): 129.42,23.4 129.42,23.39 129.32,23.26 129.28,23.1 129.27,23.05 129.27,23 129.38,22.73 129.76,22.63 129.85,22.67 129.87,22.68 129.95,22.68 130.01,22.66 130.03,22.66 130.17,22.66 130.36,22.47 131.18,22.47 131.19,22.43 131.24,22.36 131.32,22.33 131.7,22.33 131.76,22.35 131.8,22.39 131.87,22.43 131.95,22.4 132.01,22.34 132.01,21.83 132.12,21.73 132.12,21.54 132.15,21.45 132.24,21.41 132.94,21.41 133.4,20.95 133.4,19.02 133.31,18.93 132.5,18.93 132.42,19.01 132.42,20.38 131.86,20.94 131.12,20.94 131.12,20.94 129.09,20.94 128.91,21.12 128.91,21.86 128.89,21.94 128.82,21.98 128.81,21.99 128.79,22.01 128.79,22.06 128.74,22.06 128.71,22.08 127.7,22.08 127.7,22.49 127.72,22.53 127.72,22.56 127.72,22.62 127.96,22.86 127.99,22.87 128.11,22.88 128.19,22.91 128.27,22.98 128.32,23.03 128.89,23.61 129.22,23.61
+3V3_TPM on IN3 (solid shape): outline of 234 points within 121.4,19.67 129.9,24.04
+3V3_TPM_VSB on TOP (solid shape): 128.59,18.53 128.46,18.4 128.46,17.89 128.71,17.64 129.09,17.64 129.22,17.51 133.71,17.51 133.72,17.47 133.76,17.38 133.84,17.35 134.66,17.35 134.69,17.35 134.77,17.33 134.81,17.25 134.81,16.5 134.56,16.24 128.18,16.24 127.87,16.55 127.87,16.65 127.89,16.67 127.95,16.78 127.98,16.9 127.92,17.1 127.75,17.23 127.72,17.25 127.72,18.79 127.79,18.86 128.59,18.86
+3V_DEEP_SUS on BOTTOM (solid shape): 106.08,32.14 106.08,30.9 106.04,30.86 106,30.82 105.42,30.24 103.85,30.24 103.48,29.87 103.44,29.89 103.36,29.92 103.26,29.93 103.15,29.92 103.05,29.87 103.03,29.86 102.91,29.86 102.84,29.85 102.77,29.82 102.76,29.82 102.1,29.82 102,29.87 101.89,29.88 101.79,29.87 101.69,29.83 101.68,29.82 101.62,29.82 101.41,30.03 101.41,30.52 101.57,30.68 101.86,30.68 101.97,30.8 102.5,30.8 102.68,30.97 102.68,31.99 103.41,31.99 103.64,31.76 104.89,31.76 105.32,32.19 106.03,32.19
+3V_DEEP_SUS on IN2 (solid shape): outline of 152 points within 101.28,29.37 108.77,31.36
+3V_DMIC on BOTTOM (solid shape): 39.25,116.34 39.53,116.34 39.81,116.06 39.81,115.12 39.76,115.07 36.49,115.07 36,115.56 36,116.57 36.23,116.8 38.8,116.8
+3V_EC on BOTTOM (solid shape): 180.68,23.63 180.3,23.25 180.3,22.8 180.22,22.72 179.79,22.72 179.36,22.29 179.36,21.17 179.28,21.09 178.63,21.09 178.63,23.28 178.7,23.35 179.23,23.35 179.79,23.91 180.68,23.91
+3V_LAN on TOP (solid shape): 44.14,103.79 44.14,102.78 44.22,102.7 44.22,101.99 44.16,101.93 43.7,101.93 43.61,102.01 43.61,102.31 43.94,102.64 43.94,103.79 43.94,103.8 44.13,103.8
+3V_LAN on TOP (solid shape): 42.12,112.15 42.12,111.82 41.67,111.37 41.67,110.91 41.77,110.81 41.77,110.78 41.99,110.56 41.99,108.68 42.35,108.32 43.11,108.32 43.34,108.09 43.34,107.03 43.06,107.03 43.04,107.05 43.04,107.76 42.89,107.91 42.33,107.91 42.07,108.16 41.41,108.16 41.33,108.24 41.33,109.7 41.16,109.87 39.99,109.87 39.53,110.32 39.53,111.62 39.61,111.7 40.98,111.7 41.49,112.2 42.07,112.2
+3V_LAN on TOP (solid shape): 49.65,115.3 49.74,115.26 49.75,115.17 49.74,115.11 49.73,115.05 49.83,114.8 50.07,114.68 50.1,114.65 50.1,114.03 50.35,113.78 51.25,113.78 51.98,113.04 52.41,113.04 52.97,112.49 52.97,111.21 52.16,111.21 52.16,112.11 51.76,112.51 50.14,112.51 49.92,112.51 49.68,112.27 49.68,112.05 49.68,108.85 49.28,108.44 48.64,108.44 48.39,108.2 48.39,106.84 47.85,106.3 46.26,106.3 46.25,106.31 46.25,106.48 46.27,106.5 47.57,106.5 47.98,106.9 47.98,108.78 47.98,108.78 47.98,109.04 47.67,109.35 47.67,111.61 47.31,111.97 47.31,114.92 47.69,115.3
+3V_LAN on IN3 (solid shape): outline of 511 points within 40.19,109.99 49.54,115.86
+3V_RTC on BOTTOM (solid shape): 68.2,27.99 68.2,26.77 67.98,26.55 66.46,26.55 66.41,26.49 66.11,26.49 65.87,26.73 65.87,27.7 66.36,28.18 68.01,28.18
+3V_RTC on BOTTOM (solid shape): 16.83,10.02 16.83,9 16.57,8.75 15.56,8.75 15.3,9 15.3,9.84 15.36,9.96 15.38,10.1 15.36,10.23 15.3,10.35 15.3,10.56 15.36,10.67 15.38,10.81 15.36,10.93 15.31,11.04 15.43,11.16 15.68,11.16
+3V_RTC on IN1 (solid shape): outline of 176 points within 45.02,12.43 47.43,16.75
+3V_RTC on IN3 (solid shape): 66.94,27.42 66.94,26.55 66.79,26.4 65.52,26.4 65.37,26.55 65.37,27.44 65.52,27.6 66.76,27.6
+3V_RTC_0 on BOTTOM (solid shape): 15.45,8.49 16.5,8.49 16.57,8.42 16.57,6.91 16.55,6.86 16.53,6.81 16.48,6.76 16.41,6.75 16.38,6.75 16.34,6.76 16.12,6.68 15.99,6.48 15.98,6.44 14.59,6.44 14.51,6.51 14.51,8.5 14.57,8.55 15.4,8.55
+3V_RTC_1 on BOTTOM (solid shape): 18.59,9.5 18.59,9.2 18.24,8.85 18.13,8.69 18.1,8.5 18.1,7.77 18.09,7.76 17.61,7.76 17.47,7.74 17.35,7.68 17,7.68 16.83,7.86 16.83,8.52 16.83,8.62 17.21,9 17.21,9.51 17.33,9.64 18.45,9.64
+3V_RTC_2 on BOTTOM (solid shape): 19.43,11.95 19.43,11.63 19.09,11.29 18.73,11.29 18.6,11.16 18.6,10.27 18.48,10.15 17.97,10.15 17.84,10.27 17.84,11.92 17.97,12.05 19.33,12.05
+3V_S5 on TOP (solid shape): 162.29,23.45 162.29,21.2 158.81,21.2 158.68,21.32 158.68,22.34 158.94,22.59 160.08,22.59 160.21,22.59 160.34,22.72 160.34,24.24 160.49,24.4 161.35,24.4
+3V_S5 on TOP (solid shape): 191.07,33.09 191.07,32.42 191.06,32.39 191.02,32.37 190.97,32.37 189.47,32.37 189.19,32.65 189.19,33.16 189.55,33.51 190.64,33.51
+3V_S5 on TOP (solid shape): 51.65,111.9 51.65,110.98 51.93,110.7 52.89,110.7 53.15,110.45 53.15,109.46 52.95,109.26 52.01,109.26 51.57,108.83 51.4,108.83 50.19,108.83 50.19,111.84 50.35,112 51.55,112
+3V_S5 on TOP (solid shape): 74.53,20.89 74.53,16.95 73.89,16.31 73.76,16.31 73.75,16.29 72.71,16.29 72.63,16.22 72.63,15.61 73.06,15.18 73.06,14.62 73,14.56 72.87,14.56 72.81,14.62 72.81,14.95 72.73,15.03 72.73,15.05 72.25,15.53 72.25,16.19 72.1,16.34 71.32,16.34 71.32,16.75 73.72,16.75 73.82,16.85 73.82,17.82 73.8,17.84 73.8,19.42 73.54,19.67 72.71,19.67 72.58,19.8 72.58,20.18 72.45,20.31 72.45,21.45 72.58,21.58 73.85,21.58
+3V_S5 on TOP (solid shape): 44.31,29.94 44.31,29.42 44.38,29.34 44.38,27.67 44.51,27.55 44.64,27.55 45.05,27.14 45.05,26.17 44.88,26.01 43.54,26.01 43.53,26.01 43.31,26.01 43.03,26.29 43.03,26.4 42.68,26.74 42.68,27.39 42.84,27.55 42.94,27.54 43.18,27.63 43.31,27.86 43.32,27.94 43.32,29.3 42.89,29.73 41.94,29.73 41.94,30.03 41.94,30.03 42.83,30.03 42.83,30.05 43.05,30.05 43.1,30.1 44.15,30.1
+3V_S5 on BOTTOM (solid shape): 25.21,12.36 25.21,12.05 25.26,12 26.25,12 26.27,11.97 26.27,11.67 26.17,11.57 25.33,11.57 25.21,11.44 25.03,11.44 24.9,11.57 24.9,12.33 24.98,12.41 25.16,12.41
+3V_S5 on BOTTOM (solid shape): 195.26,27.04 195.26,25.32 194.76,24.83 194.44,24.83 194.39,24.78 193.61,24.78 193.57,24.82 193.57,25.17 194.08,25.68 194.08,27.1 194.08,27.13 193.86,27.34 193.86,27.7 193.88,27.71 194.59,27.71
+3V_S5 on BOTTOM (solid shape): 92.72,26.35 93.05,26.35 93.05,25.87 93.18,25.74 93.18,25.56 93.05,25.44 92.14,25.44 92.08,25.51 92,25.57 91.92,25.65 91.39,25.65 91.17,25.87 91.17,26.3 91.22,26.35 92.26,26.35 92.27,26.35 92.72,26.35
+3V_S5 on BOTTOM (solid shape): 22.67,19.72 22.67,19.42 22.62,19.37 22.08,19.37 22.03,19.32 22.03,19.16 22.03,19.16 22.03,18.86 22.03,18.86 21.55,18.38 21.55,17.59 21.52,17.56 21.35,17.56 21.27,17.64 21.27,18.63 21.58,18.93 21.58,19.65 21.68,19.75 22.64,19.75
+3V_S5 on BOTTOM (solid shape): 60.89,54.34 60.89,45.83 60.77,45.71 59.75,45.71 59.5,45.96 59.5,52.82 59.54,52.83 59.67,52.86 59.77,52.94 60,53.16 60.08,53.28 60.11,53.43 60.11,54.47 60.77,54.47
+3V_S5 on BOTTOM (solid shape): 160.09,22.97 160.13,22.96 160.19,22.85 160.27,22.82 161.36,22.82 161.44,22.85 161.49,22.93 161.49,22.95 161.52,22.97 162.37,22.97 162.62,22.72 162.62,21.68 162.58,21.6 162.57,21.5 162.58,21.44 162.46,21.32 158.81,21.32 158.68,21.45 158.68,22.85 158.94,23.1 159.97,23.1
+3V_S5 on BOTTOM (solid shape): 105.61,29.9 105.75,29.74 105.95,29.68 106.06,29.69 106.15,29.73 106.22,29.74 106.28,29.71 106.42,29.59 106.59,29.55 106.84,29.65 106.97,29.89 106.97,29.93 107.91,29.93 107.91,28.59 107.85,28.53 107.84,28.52 107.65,28.39 107.58,28.18 107.59,28.1 107.62,28.02 107.64,27.98 107.43,27.77 104.38,27.77 104.02,28.13 104.02,28.64 103.77,28.89 103.77,29.78 103.92,29.93 105.59,29.93
+3V_S5 on BOTTOM (solid shape): outline of 233 points within 32.73,22.97 46.04,27.16
+3V_S5 on IN1 (solid shape): outline of 378 points within 51.24,108.83 59.24,117.72
+3V_S5 on IN1 (solid shape): outline of 923 points within 18.6,6.39 35.34,24.29
+3V_S5 on IN2 (solid shape): 19.73,8.25 19.73,7.8 19.29,7.35 18.1,7.35 17.94,7.5 17.94,9.1 18.12,9.28 18.71,9.28
+3V_S5 on IN2 (solid shape): 14.95,46.75 14.95,45.22 14.67,44.94 14.03,44.94 13.61,45.37 13.61,46.23 13.73,46.63 13.77,47.04 13.77,47.1 14.59,47.1
+3V_S5 on IN2 (solid shape): 20.34,19.93 20.43,19.88 20.44,19.78 20.41,19.72 20.41,19.65 20.5,19.41 20.74,19.31 20.9,19.36 21.02,19.48 21.1,19.53 21.18,19.5 21.27,19.42 21.27,18.15 21.14,18.02 20.15,18.02 20.15,18.07 20.03,18.31 19.78,18.4 19.71,18.39 19.64,18.37 19.41,18.37 19.12,18.66 19.12,19.54 19.11,19.56 19.11,19.8 19.24,19.93
+3V_S5 on IN2 (solid shape): outline of 1506 points within 15.17,89.22 59.24,118.73
+3V_S5 on SVCC (solid shape): outline of 190 points within 31.94,20.43 195.13,35.42
+3V_S5 on SVCC (solid shape): outline of 746 points within 3.02,34.02 24.83,93.46
+3V_SSD on TOP (solid shape): 36.07,4.43 36.45,4.43 36.48,4.43 38.7,4.43 38.73,4.43 39.11,4.43 39.18,4.43 39.43,4.18 39.43,2.27 39.3,2.15 35.62,2.15 35.49,2.27 35.49,4.3 35.62,4.43 36.04,4.43
+3V_SSD on TOP (solid shape): 22.16,8.5 22.16,6.46 22.41,6.21 22.41,5.7 23.05,5.07 23.05,4.18 23.3,3.92 24.45,3.92 24.57,3.8 24.57,2.4 24.45,2.27 23.44,2.27 23.44,2.28 22.28,2.28 22.27,2.29 21.93,2.29 21.58,2.63 21.58,3.61 21.79,4.66 21.09,5.47 21.09,8.32 21.4,8.62 22.03,8.62
+3V_SSD on BOTTOM (solid shape): 22.73,4.42 23.16,4.42 23.56,4.02 23.56,3.24 23.47,3.15 23.01,3.15 22.79,2.93 22.79,2.91 22.79,2.91 22.77,2.89 22.77,2.85 22.75,2.85 22.75,1.52 22.45,1.52 22.45,2.85 22.25,2.85 22.25,1.52 21.95,1.52 21.95,2.85 21.75,2.85 21.75,1.52 21.28,1.52 21.28,2.83 21.29,2.83 21.29,3.24 21.67,3.65 21.82,4.18 21.82,4.19 22.06,4.43 22.72,4.43
+3V_SSD on BOTTOM (solid shape): 39.65,4.06 39.65,4.05 39.71,3.86 39.81,3.68 39.81,1.67 39.8,1.64 39.76,1.62 39.5,1.62 39.46,1.64 39.45,1.67 39.45,2.75 39.45,2.85 39.25,2.85 39.25,1.67 39.24,1.64 39.2,1.62 39,1.62 38.96,1.64 38.95,1.67 38.95,2.75 38.95,2.91 38.85,3.01 37.45,3.01 37.45,3.01 37.3,3.01 37.25,2.96 37.25,1.67 37.24,1.64 37.2,1.62 37,1.62 36.96,1.64 36.95,1.67 36.95,2.75 36.95,2.85 36.75,2.85 36.75,1.67 36.74,1.64 36.7,1.62 36.5,1.62 36.46,1.64 36.45,1.67 36.45,2.75 36.45,2.85 36.25,2.85 36.25,1.67 36.24,1.64 36.2,1.62 36,1.62 35.96,1.64 35.95,1.67 35.95,2.75 35.95,2.85 35.75,2.85 35.75,1.67 35.74,1.64 35.7,1.62 35.5,1.62 35.46,1.64 35.45,1.67 35.45,2.75 35.45,2.85 35.44,2.85 35.44,2.93 35.37,3.01 35.37,4.02 35.75,4.4 39.3,4.4
+3V_SSD on IN2 (solid shape): outline of 246 points within 21.14,2.32 38.67,4.56
+3V_WLAN_P on BOTTOM (solid shape): 192.47,12.56 192.8,12.56 193.23,12.13 193.51,12.13 193.62,12.07 193.74,12.05 193.87,12.08 193.99,12.15 194.75,12.15 194.79,12.12 194.84,12.09 194.88,12.05 195.46,12.05 195.9,11.62 195.9,11.24 195.69,11.04 194.85,11.04 194.82,11.04 194.44,11.04 194.41,11.04 194.08,11.04 194.05,11.04 193.67,11.04 193.64,11.04 193.32,11.04 193.29,11.04 192.91,11.04 192.88,11.04 192.43,11.04 192.4,11.04 192.21,11.04 190.94,12.31 190.94,12.43 190.82,12.56 190.05,12.56 189.93,12.69 189.93,13.03 191.55,13.03 191.55,13.23 189.93,13.23 189.93,13.45 190.01,13.53 191.49,13.53
+3V_WLAN_P on BOTTOM (solid shape): 192.07,30.96 192.07,30.72 192.45,30.34 193.61,30.34 193.98,30.71 194.18,30.71 194.37,30.52 194.37,30.21 193.61,29.45 193.61,25.61 193.25,25.26 193.25,24.5 193.15,24.4 191.38,24.4 191.17,24.6 191.17,24.7 191.43,24.95 191.43,25.23 191.83,25.64 191.83,26.06 191.86,26.14 192.19,26.27 192.29,26.52 192.29,26.6 192.28,26.64 192.24,26.79 192.14,26.9 192.15,26.93 192.17,26.95 192.26,27.07 192.27,27.34 192.21,27.44 192.18,27.51 192.21,27.57 192.27,27.68 192.27,27.92 192.21,28.03 192.18,28.09 192.21,28.16 192.27,28.26 192.19,28.64 191.86,28.77 191.83,28.84 191.83,29.93 191.55,30.21 191.55,30.23 190.14,30.23 190.06,30.31 190.06,30.48 190.07,30.52 190.11,30.53 191.55,30.53 191.55,30.73 190.11,30.73 190.07,30.74 190.06,30.78 190.06,31.08 191.96,31.08
+3V_WLAN_P on IN1 (solid shape): outline of 1086 points within 190.43,11.38 198.31,25.11
+3VLCD_CON on TOP (solid shape): 63.14,103.87 63.18,103.86 63.19,103.82 63.19,103.5 63.43,103.26 63.43,102.22 63.18,101.97 62.82,101.97 62.8,101.97 62.78,101.99 62.5,102.13 62.21,101.99 62.2,101.98 62.18,101.97 62.14,101.97 61.78,102.33 61.78,102.48 62.06,102.75 62.37,102.75 62.55,102.93 62.55,103.8 62.62,103.87
+3VLCD_CON on BOTTOM (solid shape): 78.74,98.22 78.74,97.89 78.75,97.83 78.79,97.78 79.06,97.52 80.02,97.52 80.08,97.46 80.08,96.42 79.54,95.87 77.25,95.87 77.22,95.89 77.2,95.92 77.2,96.51 77.61,96.91 77.61,98.37 77.78,98.54 78.42,98.54
+3VLCD_CON on IN2 (solid shape): outline of 595 points within 61.53,96.96 78.8,102.91
+3VLCD_CON_R on TOP (solid shape): 61.63,106.13 61.63,105.66 61.63,105.46 62.16,104.92 62.16,103.85 62.04,103.72 62.04,103.09 61.93,102.98 61.28,102.98 61.02,103.24 61.02,103.98 60.9,104.1 60.9,105.15 60.77,105.27 60.77,105.89 60.78,105.94 60.79,105.98 60.79,106.18 61.02,106.41 61.35,106.41
+3VLCD_CON_R on BOTTOM (solid shape): 61.51,107.57 61.5,107.54 61.5,107.34 61.49,107.31 61.47,107.26 61.45,107.21 61.44,107.15 61.44,107.13 61.44,105.67 61.66,105.46 61.66,104.63 61.53,104.51 60.26,104.51 60.13,104.63 60.13,105.46 60.26,105.58 60.26,106.71 61.2,106.71 61.2,107.54 61,107.54 61,106.71 60.7,106.71 60.7,107.54 60.5,107.54 60.5,106.71 60.26,106.71 60.26,107.68 60.26,107.68 61.4,107.68
+3VPCU on TOP (solid shape): 139,28.87 139,28.12 138.71,27.82 138.03,27.82 137.96,27.9 137.96,28.51 137.98,28.54 137.98,29.02 138.16,29.2 138.67,29.2
+3VPCU on TOP (solid shape): 42.86,23.23 46.59,23.23 47.1,22.72 47.1,21.12 47.03,21.04 46.7,21.04 46.37,21.37 46.37,21.75 45.71,22.41 42.02,22.41 41.21,23.23 41.21,23.74 41.46,23.99 42.1,23.99
+3VPCU on TOP (solid shape): 152.45,30.96 152.49,30.95 156.09,30.95 156.44,30.61 156.92,30.61 157.85,29.68 157.85,28.06 157.78,27.99 156.59,27.99 156.45,27.85 156.45,27.47 156.34,27.37 155.57,27.37 155.56,27.38 155.95,27.38 155.95,28.09 155.75,28.09 155.75,27.38 155.56,27.38 155.55,27.38 155.55,28.29 155.58,28.3 155.62,28.32 155.66,28.36 155.69,28.4 155.72,28.44 155.74,28.49 155.76,28.54 155.76,28.59 155.76,28.64 155.76,28.69 155.74,28.75 155.71,28.8 155.68,28.84 155.66,28.87 155.54,28.99 153.99,28.99 153.88,28.88 153.88,28.39 153.93,28.34 153.94,28.3 153.98,28.26 154.02,28.22 154.06,28.19 154.09,28.17 154.15,28.11 154.15,27.38 154.14,27.37 153.96,27.37 153.95,27.39 153.95,28.09 153.75,28.09 153.75,27.4 153.72,27.37 153.42,27.37 152.85,27.94 152.84,27.93 152.46,27.93 152.37,28.02 152.37,30.88
+3VPCU on BOTTOM (solid shape): 214.23,32.5 214.48,32.5 214.95,32.04 214.95,30.85 214.82,30.72 214.44,30.72 214.36,30.8 214.36,32.08 214.2,32.25 212.89,32.25 212.79,32.25 212.79,32.55 214.18,32.55
+3VPCU on IN1 (solid shape): 41.21,31.39 41.21,30.57 41.06,30.42 39.74,30.42 39.48,30.67 39.48,31.56 39.64,31.72 40.88,31.72
+3VPCU on IN1 (solid shape): 214.79,31.89 214.79,30.72 214.69,30.62 214.16,30.62 213.98,30.8 213.98,31.99 214.06,32.07 214.62,32.07
+3VPCU on IN1 (solid shape): 26.47,72.89 26.5,72.8 26.43,72.72 26.19,72.37 26.45,72.02 26.51,71.98 26.52,71.91 26.53,71.74 26.6,71.6 26.6,71.45 26.52,71.21 26.6,70.97 26.6,70.68 26.56,70.58 26.54,70.47 26.62,70.24 26.83,70.11 26.84,70.11 27.24,69.71 27.24,68.82 26.84,68.41 26.15,68.41 25.75,68.81 25.75,72.9 25.87,73.01 26.35,73.01
+3VPCU on IN2 (solid shape): 41.54,31.56 41.54,31.1 41.51,31.07 40.11,31.07 39.71,31.47 39.71,32.04 39.97,32.29 40.8,32.29
+3VPCU on IN2 (solid shape): 113.68,53.25 113.68,52.11 113.52,51.95 112.79,51.95 112.51,52.23 112.51,53.22 112.69,53.4 113.52,53.4
+3VPCU on IN2 (solid shape): 27.07,70.02 27.07,67.36 27.02,67.31 26.44,67.31 26.4,67.35 26.4,70.01 26.48,70.09 26.97,70.09
+3VPCU on IN2 (solid shape): 195.05,36.25 195.05,35.71 194.16,34.83 192.78,34.83 192.44,34.49 189.95,34.49 189.71,34.39 189.61,34.15 189.61,34.1 189.62,34.05 189.61,33.96 189.53,33.91 187.8,33.91 187.52,33.63 187.43,33.61 187.36,33.66 187.23,33.79 187.06,33.83 186.84,33.76 186.72,33.57 186.68,33.51 186.61,33.49 186.47,33.47 186.35,33.4 186.28,33.38 186.21,33.4 186.11,33.47 185.99,33.49 185.89,33.47 185.79,33.43 185.73,33.41 185.66,33.44 185.55,33.52 185.41,33.55 185.16,33.45 185.06,33.21 185.06,33.17 185.07,33.13 185.05,33.04 184.97,33 180.78,33 180.78,33.01 180.15,33.01 180.02,32.88 180,32.88 179.89,32.78 179.66,32.78 179.56,32.88 179.56,33.38 179.53,33.41 179.64,33.51 179.64,33.79 179.82,33.97 186.87,34.59 193.7,36.44 194.85,36.44
+3VPCU on IN2 (solid shape): outline of 284 points within 47.61,104.74 54.54,110.6
+3VPCU on IN2 (solid shape): outline of 138 points within 137.91,27.27 159.5,29.48
+3VPCU on IN3 (solid shape): outline of 711 points within 112.13,27.16 139.1,52.79
+3VPCU_EC on TOP (solid shape): 175.68,23.25 175.68,22.88 175.5,22.57 175.68,22.26 175.68,22.13 175.37,21.83 175.27,21.83 175.24,21.84 175.01,21.84 174.71,22.13 174.71,22.26 174.67,22.3 174.67,22.31 174.61,22.39 174.53,22.44 174.53,22.45 174.31,22.67 174.28,22.67 174.28,23.55 174.33,23.61 175.32,23.61
+3VSPI on TOP (solid shape): 132.17,20.28 132.17,18.86 132.42,18.6 132.42,17.84 132.35,17.77 131.3,17.77 131.08,17.99 131.08,20.53 131.23,20.69 131.76,20.69
+3VSPI on TOP (solid shape): 164.93,32.98 164.93,32.02 164.91,31.99 164.4,31.99 164.27,31.86 164.27,30.62 164.2,30.54 164.2,29.93 164.1,29.83 164.1,29.65 163.75,29.3 163.59,29.3 163.33,29.04 163.33,28.89 163.16,28.71 162.19,28.71 162.04,28.87 162.04,29.86 162.34,30.16 162.63,30.16 163.11,30.64 163.11,32.12 163.31,32.32 163.31,33.06 163.38,33.13 164.78,33.13
+3VSPI on BOTTOM (solid shape): 165.03,34.28 165.03,32.48 165.02,32.41 165.01,32.35 165.02,32.28 165.03,32.21 165.03,31.43 164.91,31.3 163.92,31.3 163.76,31.46 163.76,32.37 164.15,32.75 164.15,34.4 164.27,34.53 164.78,34.53
+3VSPI on IN3 (solid shape): outline of 195 points within 119.29,17.3 123,22.41
+5V on TOP (solid shape): 18.4,32.32 18.4,29.98 18.48,29.9 18.48,28.69 18.06,28.27 15.75,28.27 15.66,28.36 15.66,31.86 16.29,32.5 18.22,32.5
+5V on TOP (solid shape): 215.49,15.53 215.53,15.53 215.58,15.48 215.71,15.48 216.03,15.16 216.03,13.74 215.8,13.52 215.73,13.52 215.48,13.42 215.38,13.17 215.39,13.07 215.43,12.98 215.43,12.84 215.28,12.69 214.69,12.69 214.69,15.51 214.76,15.57 215.44,15.57
+5V on TOP (solid shape): 62.04,101.71 62.04,101.21 62.09,101.16 62.09,100.98 62.15,100.82 62.31,100.75 62.37,100.75 62.4,100.74 62.42,100.7 62.42,99.55 62.36,99.49 61.59,99.49 61.02,100.06 61.02,100.82 60.77,101.08 60.23,101.08 60.15,101.12 60.14,101.21 60.15,101.27 60.16,101.33 60.05,101.58 59.77,101.7 59.75,101.74 59.75,102.6 60.01,102.86 60.89,102.86
+5V on TOP (solid shape): outline of 553 points within 203.11,23.96 214.67,32.65
+5V on BOTTOM (solid shape): 46.04,12.69 46.04,12.18 45.91,12.05 44.89,12.05 44.6,11.76 44.6,10.85 44.54,10.78 44.13,10.78 44,10.91 44,12.31 44.64,12.94 45.78,12.94
+5V on BOTTOM (solid shape): 180.64,28.12 180.64,27.37 180.45,27.17 177.21,27.17 177.21,27.18 176.84,27.18 176.84,27.17 175.99,27.17 175.27,26.45 174.26,26.45 174.03,26.68 174.03,27.18 174.39,27.54 174.9,27.54 175.63,28.28 180.48,28.28
+5V on BOTTOM (solid shape): 215.99,15.84 215.99,13.7 215.83,13.55 215.43,13.55 214.65,14.33 214.65,14.49 214.65,14.54 214.63,14.58 214.61,14.62 214.58,14.65 214.56,14.67 213.56,14.67 213.29,14.67 213.17,14.79 213.17,14.97 214.4,14.97 214.4,15.17 213.56,15.17 213.56,14.97 213.17,14.97 213.17,15.47 214.4,15.47 214.4,15.67 213.56,15.67 213.56,15.47 213.17,15.47 213.17,15.88 213.26,15.97 215.86,15.97
+5V on BOTTOM (solid shape): 212.43,29.91 212.43,27.98 212.29,27.85 212.16,27.8 211.9,27.55 211.26,27.55 211.18,27.63 211.18,27.69 211.19,27.69 211.19,28.74 211.43,28.99 212.04,29.23 211.51,29.61 211.49,29.6 211.44,29.63 211.45,29.69 211.46,29.7 211.46,29.82 211.62,29.98 212.35,29.98
+5V on BOTTOM (solid shape): 197.29,18.68 197.29,18.14 197.33,18.05 197.42,18.01 197.96,18.01 198.18,17.79 198.18,15.89 198.08,15.79 198.08,15.3 198.05,15.23 197.98,15.2 197.84,15.16 197.72,15.06 197.2,15.06 196.91,15.35 196.91,16.09 196.9,16.18 196.96,16.25 197.13,16.38 197.19,16.58 197.18,16.66 197.16,16.8 197.19,16.85 197.31,16.98 197.35,17.15 197.25,17.4 196.99,17.5 196.87,17.48 196.77,17.42 196.31,17.42 196.22,17.47 196.21,17.56 196.23,17.6 196.23,17.64 196.23,17.94 196.23,18.03 196.26,18.1 196.35,18.13 196.4,18.12 196.48,18.13 196.55,18.15 196.66,18.09 196.79,18.07 197.04,18.17 197.14,18.42 197.09,18.61 196.96,18.74 196.91,18.83 196.96,18.92 197.03,18.95
+5V on BOTTOM (solid shape): outline of 175 points within 118.43,14.64 125.28,20.81
+5V on BOTTOM (solid shape): outline of 254 points within 12.38,81.14 22.29,86.85
+5V on IN1 (solid shape): 18.53,32.03 18.53,28.69 18.38,28.54 16.14,28.54 15.51,29.17 15.51,32.65 15.71,32.85 17.71,32.85
+5V on IN1 (solid shape): outline of 476 points within 13.27,70.65 23.38,86.09
+5V on IN1 (solid shape): outline of 641 points within 128.15,26.35 145.48,29.42
+5V on IN2 (solid shape): 175.21,27.14 175.21,26.84 174.8,26.43 174.77,26.4 174.75,26.36 174.12,26.36 173.96,26.52 173.96,27.46 174.12,27.61 174.73,27.61
+5V on IN2 (solid shape): outline of 217 points within 143.57,25.72 153.71,28.21
+5V on SVCC (solid shape): outline of 1311 points within 2.73,1.52 218.28,33.51
+5V_HDMIC on BOTTOM (solid shape): 15.96,83.93 18.1,83.93 19.06,82.96 19.07,82.93 19.06,82.91 19,82.81 18.98,82.69 19.07,82.44 19.3,82.31 19.32,82.31 19.44,82.19 19.44,81.67 19.35,81.58 18.35,81.58 18.33,81.58 17.92,81.98 17.84,81.98 16.65,83.17 16.24,83.17 15.99,82.92 14.26,82.92 13.96,82.61 13.7,82.51 13.6,82.26 13.57,82.23 13.57,81.19 12.13,79.74 11.24,79.74 10.98,80 10.98,81.06 13.85,83.93 15.92,83.93
+5V_KB on BOTTOM (solid shape): outline of 135 points within 195.79,11.67 205.24,16.93
+5V_PVDD on BOTTOM (solid shape): 210.88,33.26 210.88,30.76 210.87,30.74 210.86,30.73 210.78,30.65 210.75,30.54 210.75,30.24 210.78,30.13 210.86,30.05 210.87,30.04 210.88,30.02 210.88,29.72 210.87,29.69 210.72,29.59 210.68,29.45 210.68,29.15 210.72,29.01 210.84,28.93 210.86,28.92 210.88,28.9 210.88,27.8 210.75,27.67 210.02,27.67 209.92,27.77 209.92,28.48 210.12,28.69 210.12,29.91 209.84,30.19 208.98,30.19 208.58,30.58 208.58,30.94 208.61,30.96 208.68,30.96 208.93,30.72 210.05,30.72 210.25,31.08 210.13,31.35 210.12,31.36 210.12,31.38 210.12,32.89 210.12,32.9 210.12,33.23 210.04,33.31 208.95,33.31 208.77,33.13 208.42,33.13 208.37,33.18 208.37,33.29 208.42,33.34 208.65,33.34 208.82,33.51 210.63,33.51
+5V_S5 on TOP (solid shape): 17.89,24.24 17.89,22.74 17.61,22.47 17.61,21.98 17.44,21.8 15.07,21.8 14.07,22.81 14.07,24.18 14.39,24.5 17.64,24.5
+5V_S5 on TOP (solid shape): 29.27,17.64 29.27,16.87 30.16,15.99 30.16,14.85 29.65,14.34 27.36,14.34 27.34,14.35 27.33,14.37 27.2,14.53 27,14.59 26.98,14.59 26.73,14.85 26.73,17.64 26.99,17.89 29.02,17.89
+5V_S5 on BOTTOM (solid shape): 22.29,43.93 22.29,43.67 22.54,43.42 23.56,43.42 23.68,43.29 23.68,41.77 23.56,41.64 21.4,41.64 21.32,41.72 21.32,42.23 21.12,42.43 19.7,42.43 19.54,42.58 19.54,43.75 19.61,43.81 19.69,43.82 19.74,43.83 20.24,43.83 20.27,43.83 21.51,43.83 21.68,43.83 21.91,44.06 22.16,44.06
+5V_S5 on BOTTOM (solid shape): 204.54,22.59 204.72,22.54 204.89,22.59 205.65,22.59 205.65,21.57 205.56,21.49 204.3,21.49 203.98,21.17 203.55,21.17 203.48,21.2 203.45,21.27 203.22,21.6 202.83,21.47 202.2,21.47 201.97,21.59 201.72,21.52 201.69,21.5 201.61,21.58 201.61,22.34 201.72,22.45 203.77,22.45 203.78,22.46 203.83,22.46 203.84,22.45 204.18,22.37 204.47,22.57 204.48,22.59 204.53,22.59
+5V_S5 on BOTTOM (solid shape): 29.96,18.73 29.99,18.61 30.05,18.51 30.08,18.44 30.05,18.37 29.98,18.26 29.96,18.12 29.98,17.99 30.05,17.87 30.08,17.8 30.05,17.74 29.96,17.45 30.1,17.19 30.14,17.11 30.1,17.03 30.01,16.53 30.5,16.38 30.57,16.4 30.64,16.44 30.74,16.45 30.8,16.36 30.8,14.85 30.68,14.73 30.64,14.69 30.41,14.46 27.27,14.46 27.14,14.56 26.99,14.59 26.92,14.59 26.46,14.59 26.42,14.6 26.41,14.64 26.41,14.76 25.81,14.76 25.8,14.93 25.83,14.96 26.41,14.96 26.41,15.26 25.8,15.26 25.8,15.43 25.83,15.46 26.41,15.46 26.41,15.76 25.8,15.76 25.8,15.93 25.83,15.96 26.41,15.96 26.41,16.26 25.8,16.26 25.8,16.43 25.83,16.46 26.41,16.46 26.41,16.62 26.44,16.63 26.51,16.68 26.53,16.76 26.53,16.86 26.88,17.21 26.94,17.21 27.03,17.22 27.13,17.26 28.15,17.26 28.26,17.36 28.26,18.27 28.76,18.78 29.95,18.78
+5V_S5 on IN1 (solid shape): outline of 3490 points within 13.93,11.29 32.45,44.51
+5V_S5 on SVCC (solid shape): outline of 181 points within 20.38,10.27 207.83,25
+5VA on TOP (solid shape): outline of 195 points within 199.17,30.45 203.39,38.24
+5VA on BOTTOM (solid shape): 201.66,37.55 202.68,37.55 202.7,37.53 202.7,36.99 202.96,36.74 202.96,35.73 202.86,35.62 202.76,35.73 202.76,36.23 202.6,36.38 202.14,36.38 201.89,36.13 201.46,36.13 201.31,36.28 199.91,36.28 199.68,36.51 199.68,36.84 199.72,36.95 199.74,37.07 199.74,37.3 199.88,37.45 200.09,37.45 200.13,37.49 200.14,37.5 200.22,37.54 200.3,37.6 200.98,37.6 201.04,37.6 201.61,37.6
+5VODD on BOTTOM (solid shape): outline of 314 points within 121.47,16.37 133.03,22.64
+5VPCU on TOP (solid shape): 19.52,47.46 19.52,47.28 19.45,47.21 19.45,46.29 19.52,46.21 19.52,45.93 19.57,45.88 19.57,44.64 19.49,44.56 17.46,44.56 17.21,44.82 17.21,46.7 18.05,47.53 19.44,47.53
+5VPCU on TOP (solid shape): 32.07,21.45 32.07,16.64 31.89,16.64 31.61,16.37 30.29,16.37 29.64,17.01 29.64,18.83 29.48,19 29.48,19.62 29.52,19.67 29.52,21.19 29.91,21.58 31.94,21.58
+5VPCU on TOP (solid shape): 22.69,30.59 24.32,30.59 24.57,30.34 24.57,28.94 24.32,28.69 24.32,28.56 23.88,28.12 23.26,28.12 23.2,28.12 22.9,28.12 22.9,28.32 23.62,28.32 23.62,28.52 22.9,28.52 22.9,28.79 22.85,28.84 22.01,28.84 21.86,28.99 21.86,30.26 22.21,30.62 22.67,30.62
+5VPCU on TOP (solid shape): 24.51,26.37 24.54,26.32 24.59,26.28 24.62,26.25 24.85,26.25 25.11,26 25.11,25.39 25.33,25.16 25.33,23.61 25.08,23.35 23.43,23.35 23.3,23.48 23.3,25.13 22.9,25.54 22.9,26.32 23.62,26.32 23.62,26.52 22.95,26.52 22.91,26.56 22.91,26.68 22.94,26.72 23.62,26.72 23.62,26.73 24.15,26.73
+5VPCU on BOTTOM (solid shape): 75.12,102.6 75.12,102.22 75.22,102.12 75.25,102.07 75.25,100.06 75.12,99.94 74.72,99.94 73.82,100.84 73.73,100.9 73.62,100.93 73.61,100.94 73.48,100.94 73.42,101 73.42,101.61 73.43,101.62 73.5,101.73 73.52,101.85 73.52,101.89 73.72,102.09 73.76,102.13 73.8,102.17 74.26,102.63 74.29,102.62 74.5,102.61 74.68,102.73 74.99,102.73
+5VPCU on SVCC (solid shape): 157.79,38.96 157.93,38.82 158.08,38.7 162.95,35.85 168.2,33.76 168.43,33.71 168.66,33.69 178.7,33.59 188.13,34.43 197.11,37.45 197.57,37.45 197.98,37.04 197.98,34.43 197.57,34.02 197.55,34.02 197.34,34.02 197.22,34.21 197.01,34.28 196.81,34.21 196.69,34.02 195.57,34.02 195.44,34.17 195.26,34.23 195.08,34.17 194.96,34.02 192.97,34.02 192.88,34 192.8,33.95 191.09,32.24 189.4,32.24 188.5,32.85 187.6,32.24 183.12,32.24 183.02,32.22 182.94,32.17 182.18,31.41 179.8,31.41 179.03,32.17 178.95,32.22 178.85,32.24 167.55,32.24 166.99,32.8 166.91,32.86 166.81,32.88 163.59,32.88 161.66,34.81 161.58,34.87 161.48,34.89 158.56,34.89 158.5,34.9 158.43,34.91 158.36,34.9 158.3,34.89 157.93,34.89 157.86,34.9 157.8,34.91 157.73,34.9 157.66,34.89 157.29,34.89 157.23,34.9 157.16,34.91 157.09,34.9 157.03,34.89 149.42,34.89 148.4,35.91 148.4,36.84 148.5,36.94 148.94,36.94 150.2,36.56 151.52,36.43 153.63,36.77 155.53,37.76 157.17,38.97 157.78,38.97
+5VPCU on SVCC (solid shape): outline of 538 points within 17.72,16.12 98.61,103.36
+V3A_LX on BOTTOM (solid shape): 151.62,35.22 151.62,30.59 151.04,30.01 147.95,30.01 147.38,29.43 147.38,28.68 147.25,28.56 146.34,28.56 146.24,28.66 146.24,29.81 145.81,30.24 145.81,31.42 145.85,31.46 147.34,31.46 147.53,31.65 147.58,31.65 147.84,31.75 147.95,32.02 147.94,32.06 147.99,32.11 147.99,34.03 148.01,34.09 148.02,34.16 147.95,34.36 147.78,34.5 147.78,35.19 147.76,35.21 147.84,35.29 148.39,35.29 148.78,35.67 151.17,35.67
+V3A_LX_R on BOTTOM (solid shape): 145.98,29.2 145.98,28.64 146.29,28.33 147.23,28.33 147.36,28.21 147.36,27.39 147.23,27.27 146.32,27.27 146.19,27.39 145.65,27.39 144.97,28.08 144.97,29.3 145.07,29.4 145.78,29.4
+V3A_OUT on TOP (solid shape): 155.9,36.68 155.9,36.19 156.07,36.03 159.49,36.03 159.59,35.93 159.59,34.96 159.46,34.83 159.3,34.83 158.77,34.3 157.72,34.3 157.56,34.15 157.56,33.87 157.55,33.86 157.55,33.74 157.47,33.67 156.53,33.67 156.27,33.41 156.27,31.61 156.14,31.48 152.72,31.48 152.59,31.61 152.59,36.05 152.84,36.31 153.35,36.31 153.6,36.56 153.99,36.56 154.11,36.69 154.24,36.69 154.49,36.94 155.64,36.94
+V3A_OUT on BOTTOM (solid shape): 155.72,36.81 155.8,36.81 155.95,36.66 155.95,36.12 156.09,35.98 159.61,35.98 159.72,35.88 159.72,35.12 159.58,34.98 159.58,34.97 159.39,34.78 159.19,34.78 158.2,33.79 156.83,33.79 156.56,33.53 156.56,33.51 156.4,33.35 156.4,30.36 156.27,30.23 153.15,30.23 151.93,31.45 151.93,35.03 151.95,35.04 151.95,35.67 152.59,36.31 153.6,36.31 154.11,36.82 155.71,36.82
+V5P5A_LX on BOTTOM (solid shape): 42.12,22.19 42.12,21.96 42.02,21.86 42.02,21.47 42.23,21.27 43.34,21.27 43.45,21.17 43.45,18.99 43.37,18.91 41.69,18.91 41.31,18.53 41.31,17.72 41.21,17.61 38.31,17.61 38.16,17.77 38.16,20.69 38.75,21.27 40.17,21.27 41.21,22.31 42,22.31
+V5P5A_OUT on TOP (solid shape): 36.64,21.45 36.64,18.27 37.4,17.51 38.42,17.51 38.67,17.25 38.67,16.24 38.61,16.19 38.56,16.14 38.55,16.12 38.52,16.12 36.06,16.12 36.04,16.12 36.02,16.13 35.75,16.24 35.48,16.13 35.46,16.12 35.44,16.12 33.72,16.12 32.83,17 32.83,21.68 32.98,21.83 36.26,21.83
+V5P5A_OUT on BOTTOM (solid shape): 36.89,20.69 36.89,17.64 35.75,16.5 35.75,14.85 35.62,14.72 33.72,14.72 33.46,14.97 33.46,15.47 33.58,15.58 33.58,15.89 33.36,16.1 33.35,16.1 32.98,16.47 32.96,16.48 32.85,16.54 32.73,16.57 32.6,16.54 32.49,16.48 32.47,16.47 32.42,16.47 31.96,16.93 31.96,17.13 32.45,17.61 32.45,21.07 32.95,21.58 36,21.58
+VCC1.05_OUT_FET on BOTTOM (solid shape): 108.72,65.65 108.72,65.24 108.9,65.06 109.87,65.06 110.09,65.29 110.78,65.29 110.86,65.21 110.86,64.13 110.7,63.97 108.19,63.97 108.02,64.01 107.84,63.97 107.63,63.97 107.3,64.3 107.3,65.7 107.4,65.8 108.57,65.8
+VCC1.05_OUT_FET on BOTTOM (solid shape): 104.05,57.72 105.15,56.27 106.88,55.73 106.98,55.73 107.08,55.73 107.63,55.18 107.63,53.25 107.48,53.1 106.41,53.1 106.28,53.22 106.28,53.76 104.24,55.8 104.24,56.01 103.36,56.88 102.35,56.88 102.27,56.96 102.27,57.67 102.32,57.72
+VCC1.05_OUT_FET on IN1 (solid shape): outline of 325 points within 101.94,53.12 108.63,65.37
+VCC1.05_OUT_PCH on BOTTOM (solid shape): 83.63,39.32 83.94,39.32 84.1,39.47 84.25,39.47 84.27,39.47 84.29,39.46 84.44,39.31 84.44,38.66 84.31,38.53 83.33,38.53 83.2,38.66 83.2,39.37 83.3,39.47 83.48,39.47
+VCC1.05_OUT_SFR on BOTTOM (solid shape): 102.24,56.63 102.83,56.63 103.06,56.4 103.06,56.23 103.05,56.23 103.05,55.73 103.03,55.71 102.58,55.71 102.59,55.85 102.55,55.98 102.55,55.99 102.53,56.02 102.49,56.06 102.44,56.1 102.39,56.16 102.32,56.16 102.28,56.17 102.23,56.17 102.18,56.17 102.13,56.17 102.08,56.16 101.27,56.16 101.19,56.08 101.19,55.92 101.19,55.9 101.19,55.59 101.19,55.55 101.21,55.5 101.21,55.4 101.19,55.34 101.19,55.3 101.19,55.23 101.1,55.14 101.1,54.77 101.21,54.66 101.21,54.48 101.03,54.3 100.98,54.27 100.94,54.24 100.72,54.03 100.66,53.93 100.64,53.82 100.64,52.56 98.14,50.06 97.91,50.06 97.83,50.14 97.83,50.47 97.93,50.57 98.24,50.57 100.32,52.65 100.32,52.66 100.32,54.2 100.7,54.58 100.7,54.62 100.7,56.46 100.93,56.68 102.19,56.68
+VCCFPGM on TOP (solid shape): 82.57,74.14 82.57,71.76 82.49,71.68 82.11,71.68 81.98,71.55 81.98,70.74 82.19,70.53 82.41,70.53 82.61,70.34 82.61,69.68 82.53,69.61 81.17,69.61 81.09,69.68 81.09,73.84 81.47,74.22 82.49,74.22
+VCCFPGM on BOTTOM (solid shape): outline of 116 points within 81.16,70.65 82.92,74.36
+VCCIN on TOP (solid shape): 83.53,58.91 83.53,53.75 83.43,53.66 83.43,51.95 83.56,51.81 83.56,51.78 83.58,51.77 83.58,51.12 83.38,50.92 82.65,50.92 82.59,50.85 82.59,49.19 82.79,48.98 83.42,48.98 83.75,48.65 83.75,47.87 83.4,47.51 83.4,47.26 83.3,47.15 82.97,47.15 82.89,47.23 82.89,47.45 82.18,48.17 80.91,48.17 80.86,48.22 80.86,48.42 81.27,48.84 81.27,53.45 82.08,54.27 82.08,59.17 82.28,59.37 83.07,59.37
+VCCIN on TOP (solid shape): outline of 223 points within 89.95,48.02 94.75,59.8
+VCCIN on TOP (solid shape): outline of 345 points within 84.6,66.15 91.28,86.09
+VCCIN on BOTTOM (solid shape): outline of 203 points within 92.26,47.38 94.63,56.12
+VCCIN on BOTTOM (solid shape): outline of 240 points within 108.55,47.98 129.67,82.03
+VCCIN on BOTTOM (solid shape): outline of 514 points within 80.18,43.42 83.72,53.77
+VCCIN on BOTTOM (solid shape): outline of 681 points within 82.86,67.69 93.31,77.17
+VCCIN on BOTTOM (solid shape): outline of 666 points within 83.62,77.23 89.88,85.08
+VCCIN on IN1 (solid shape): outline of 467 points within 98.35,72.12 101.92,79.36
+VCCIN on IN2 (solid shape): outline of 311 points within 80.45,44.94 84,54.85
+VCCIN on IN2 (solid shape): outline of 578 points within 115.64,50.81 124.24,75.65
+VCCIN on SVCC (solid shape): outline of 526 points within 80.96,36.94 126.3,84.82
+VCCIN on IN3 (solid shape): 120,74.15 120,67.42 120.61,66.81 120.61,58.53 120.1,58.03 117.56,58.03 116.29,59.3 116.29,67.42 115.45,68.26 115.45,74.18 116.14,74.87 119.29,74.87
+VCCIN_AUX on TOP (solid shape): outline of 95 points within 113.3,35.5 119.14,47.71
+VCCIN_AUX on TOP (solid shape): outline of 1518 points within 84.82,40.75 105.24,65.75
+VCCIN_AUX on BOTTOM (solid shape): 93.79,46.67 93.79,46.47 93.74,46.42 93.74,44.94 93.79,44.89 93.79,42.66 93.25,42.12 92.39,42.12 92.26,42.26 92.26,47.07 92.44,47.26 93.2,47.26
+VCCIN_AUX on BOTTOM (solid shape): 92.85,41.08 93.27,41.08 93.39,40.96 93.41,40.96 93.43,40.95 93.54,40.88 93.67,40.87 93.76,40.85 93.79,40.77 93.79,40.22 93.6,40.03 93.32,40.03 93.22,39.93 93.02,39.93 92.64,39.56 92.64,39.2 92.58,39.14 92.08,39.14 91.99,39.23 91.99,40.53 91.99,40.63 91.76,40.86 91.76,41.1 91.91,41.26 92.67,41.26
