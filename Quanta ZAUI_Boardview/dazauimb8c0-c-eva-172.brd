# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_CB6: length 5.3
  TOP w0.102: v1(55.43,54.72) 54.62,53.91 R207.2
  BOTTOM w0.127: v1(55.43,54.72) 55.43,54.09 55.71,53.81 57.08,53.81 57.48,54.2 JDIM1.100
M_A_CB7: length 2.8
  TOP w0.102: v1(56.7,54.7) 56.09,54.08 R206.2
  BOTTOM w0.127: v1(56.7,54.7) 56.98,54.7 57.49,55.2 JDIM1.104
M_A_CKE0: length 37.9
  TOP w0.127: v1(52.79,56.5) 52.39,56.09 52.39,55.82 52.51,55.69 53.05,55.69 53.35,55.99 53.58,55.99 53.7,55.87 53.7,55.55 53.82,55.43 53.99,55.43 54.11,55.55 54.11,55.87 54.23,55.99 54.39,55.99 54.51,55.87 54.51,55.55 54.63,55.43 54.8,55.43 54.92,55.55 54.92,55.71 55.61,56.4 57.02,56.4 57.87,55.55 57.87,54.8 58.94,53.73 63.32,53.73 63.68,54.09 63.99,54.09 64.52,53.55 65.48,53.55 65.97,54.04 66.74,54.04 66.81,54.11 67.04,54.11 67.12,54.04 67.53,54.04 67.65,54.16 67.65,54.27 67.77,54.39 67.94,54.39 68.06,54.27 68.06,54.16 68.18,54.04 68.35,54.04 68.46,54.16 68.46,54.27 68.58,54.39 68.75,54.39 68.87,54.27 68.87,54.16 68.99,54.04 69.51,54.04 69.63,53.92 69.63,53.67 69.75,53.55 69.92,53.55 70.04,53.67 70.04,53.92 70.16,54.04 70.32,54.04 70.44,53.92 70.44,53.67 70.56,53.55 70.73,53.55 70.85,53.67 70.85,54.16 70.98,54.29 71.31,54.29 71.46,54.44 71.46,54.61 71.34,54.73 70.35,54.73 70.23,54.85 v2(70.23,55.17)
  BOTTOM w0.079: v2(70.23,55.17) 70.17,55.23 70.17,55.99 70.52,56.35 70.52,56.76 70.62,56.85 70.62,57.35 71.2,57.92 72.08,57.92 72.34,57.66 73.25,57.66 73.57,57.98 73.97,57.98 74.04,58.05 74.26,58.05 U24.BG49
  BOTTOM w0.127: v1(52.79,56.5) 52.34,56.04 51.95,56.04 51.54,56.46 JDIM1.109
M_A_CKE1: length 44.7
  TOP w0.089: 78.75,59.68 78.75,58.99 78.37,58.61 v2(78.37,58.53)
  TOP w0.127: v1(55.79,55.84) 55.79,55.61 55.96,55.45 56.66,55.45 56.93,55.71 57.11,55.71 57.46,55.36 57.46,54.6 58.74,53.33 63.36,53.33 63.56,53.12 66.38,53.12 66.41,53.15 71.33,53.15 71.46,53.28 71.46,53.83 72.08,54.46 72.08,54.62 71.69,55.01 71.69,55.18 71.81,55.3 71.98,55.3 72.35,54.93 72.53,54.93 72.66,55.06 72.66,55.33 72.81,55.49 72.96,55.49 73.08,55.6 73.08,55.98 73.2,56.09 73.37,56.09 73.49,55.98 73.49,55.6 73.61,55.49 73.78,55.49 73.9,55.6 73.9,55.98 74.02,56.09 74.18,56.09 74.3,55.98 74.3,54.85 74.41,54.75 74.59,54.75 74.71,54.87 74.71,55.36 74.84,55.49 75.02,55.49 75.14,55.36 75.14,55.28 75.96,54.47 77.99,54.47 78.12,54.34 79.97,54.34 80.55,54.93 80.55,59.22 79.89,59.88 78.95,59.88 78.75,59.68
  BOTTOM w0.076: U24.BF41 78.65,58.81 v2(78.37,58.53)
  BOTTOM w0.127: JDIM1.110 56.63,56.7 55.79,55.87 v1(55.79,55.84)
M_A_CLKN0: length 37.7
  IN1 w0.089: v1(52.79,64.91) 52.84,64.91 53.22,64.53 53.22,63.38 53.78,62.83 55.5,62.83 58.79,59.54 59.09,59.54 60.29,60.74 60.41,60.74 60.71,60.44 60.71,60.31 59.51,59.11 59.51,58.82 59.93,58.4 60.22,58.4 61.42,59.6 61.54,59.6 61.84,59.3 61.84,59.18 61.28,58.61 61.28,58.25 62.51,57.01 69.4,57.01 70.28,56.12 70.58,56.12 70.71,55.98 70.71,55.88 v2(70.54,55.71)
  BOTTOM w0.079: v2(70.54,55.71) 70.6,55.71 70.96,56.07 71.25,56.07 71.43,56.25 72.71,56.25 73.05,56.59 74.44,56.59 74.84,56.76 74.88,56.76 U24.BL48
  BOTTOM w0.102: JDIM1.139 51.19,63.95 51.38,63.77 51.74,63.77 51.93,63.95 52.93,63.95 53.21,64.24 53.21,64.51 52.82,64.91 v1(52.79,64.91)
M_A_CLKN1: length 42.1
  IN1 w0.089: v2(77.52,59.41) 77.33,59.22 77.33,58.96 77.15,58.79 76.74,58.79 75.78,57.82 73.68,57.82 73.43,57.57 72.27,57.57 72.15,57.69 71.48,57.69 70.84,58.33 70.5,58.33 70,57.82 64.48,57.82 60.37,61.93 60.25,61.93 59.12,60.8 58.83,60.8 58.41,61.22 58.41,61.51 59.54,62.64 59.54,62.76 59.24,63.06 59.11,63.06 57.99,61.94 57.7,61.94 57.28,62.35 57.28,62.65 58.4,63.77 58.4,63.9 58.11,64.19 57.98,64.19 57.31,63.52 56.96,63.52 56.6,63.89 56.6,64.23 57.27,64.9 57.27,65.03 56.91,65.39 55.7,65.39 55.5,65.59 55.05,65.59 54.91,65.45 54.91,65.28 55.28,64.91 v1(55.35,64.91)
  BOTTOM w0.076: v2(77.52,59.41) 77.52,59.21 77.77,58.96 U24.BF42
  BOTTOM w0.102: v1(55.35,64.91) 55.03,64.59 55.03,64.32 55.15,64.2 JDIM1.140
M_A_CLKP0: length 37.7
  IN1 w0.089: v2(71.13,55.71) 70.92,55.92 70.92,56.07 70.66,56.32 70.37,56.32 69.48,57.21 62.6,57.21 61.48,58.33 61.48,58.53 62.05,59.1 62.05,59.39 61.63,59.81 61.34,59.81 60.14,58.61 60.01,58.61 59.71,58.9 59.71,59.03 60.91,60.23 60.91,60.52 60.5,60.94 60.2,60.94 59,59.74 58.88,59.74 55.59,63.03 53.87,63.03 53.43,63.47 v1(53.43,64.91)
  BOTTOM w0.079: U24.BL47 75.36,56.59 74.88,56.59 74.48,56.42 73.12,56.42 72.78,56.08 71.5,56.08 v2(71.13,55.71)
  BOTTOM w0.102: JDIM1.137 51.21,63.46 51.31,63.55 51.83,63.55 52.02,63.74 53.02,63.74 53.43,64.15 v1(53.43,64.91)
M_A_CLKP1: length 42.1
  IN1 w0.089: v1(54.71,64.91) 54.71,65.54 54.97,65.8 55.59,65.8 55.79,65.59 56.99,65.59 57.47,65.11 57.47,64.82 56.8,64.15 56.8,63.97 57.05,63.73 57.22,63.73 57.9,64.4 58.19,64.4 58.61,63.98 58.61,63.69 57.48,62.56 57.48,62.44 57.78,62.14 57.9,62.14 59.03,63.26 59.32,63.26 59.74,62.85 59.74,62.55 58.61,61.43 58.61,61.3 58.91,61.01 59.04,61.01 60.16,62.13 60.46,62.13 64.56,58.03 69.91,58.03 70.42,58.53 70.93,58.53 71.56,57.9 72.23,57.9 72.36,57.77 73.34,57.77 73.59,58.03 75.72,58.03 76.69,58.99 77.07,58.99 77.13,59.05 77.13,59.22 v2(76.92,59.42)
  BOTTOM w0.076: v2(76.92,59.42) 76.92,59.4 77.35,58.97 U24.BF43
  BOTTOM w0.102: v1(54.71,64.91) 54.81,64.81 54.81,64.24 55.06,63.99 57.34,63.99 57.63,63.7 JDIM1.138
M_A_CS#0: length 44
  TOP w0.089: 74.86,57.06 74.86,56.75 75.7,55.92 77.48,55.92 78.4,55 79.08,55 79.83,55.75 v2(79.83,55.76)
  TOP w0.127: v1(51.69,68.95) 52.45,68.19 52.53,68.19 53.21,67.51 53.21,66.86 53.53,66.53 54.54,66.53 54.7,66.69 56.54,66.69 57,67.14 62.4,67.14 63.44,66.1 67.08,66.1 67.2,65.98 67.2,65.33 67.32,65.21 67.49,65.21 67.61,65.33 67.61,65.98 67.73,66.1 67.89,66.1 68.01,65.98 68.01,65.33 68.13,65.21 68.3,65.21 68.42,65.33 68.42,65.52 68.55,65.66 68.77,65.66 68.9,65.53 68.9,65.01 69.4,64.5 70.5,64.5 71.26,65.26 72.22,65.26 72.47,65.02 72.47,60.57 73.09,59.96 73.09,58.84 74.86,57.06
  BOTTOM w0.076: U24.BM38 79.95,55.88 v2(79.83,55.76)
  BOTTOM w0.127: JDIM1.149 51.2,68.46 v1(51.69,68.95)
M_A_CS#1: length 43.3
  TOP w0.089: v2(77.56,58.51) 77.56,58.88 77.45,58.99 76.82,58.99 76.49,59.32 76.49,59.55 76.64,59.7 76.64,60.36
  TOP w0.127: v1(53.12,69.95) 53.13,69.95 53.58,69.51 53.94,69.51 54.67,70.24 54.67,71.06 55.64,72.02 64.58,72.02 65.26,72.71 70.47,72.71 73.09,70.09 74.61,70.09 75.47,69.23 75.47,68.64 75.88,68.24 75.88,67.12 75.47,66.71 75.47,65.92 75.63,65.77 75.98,65.77 76.14,65.62 76.14,65.29 76.02,65.17 75.81,65.17 75.65,65.01 75.65,64.76 75.83,64.58 76.01,64.58 76.14,64.45 76.14,64.17 76.34,63.97 76.34,63.49 76.12,63.27 75.93,63.27 75.8,63.14 75.8,61.96 76.44,61.33 76.44,60.57 76.64,60.36
  BOTTOM w0.127: JDIM1.157 52.62,70.46 v1(53.12,69.95) ; v2(77.56,58.51) 77.61,58.51 78,58.12 U24.BG42
M_A_DIM0_ODT0: length 44.4
  TOP w0.089: v2(79,56.7) 79,56.93 78.42,57.52 78.42,57.59 77.89,58.12 77.31,58.12 77.18,58.25 77.18,58.56 76.97,58.76 76.79,58.76 76.31,59.24 76.31,60.25 76.07,60.5
  TOP w0.127: 76.07,60.5 75.4,61.16 75.4,63.71 75.23,63.88 75.23,68.86 74.41,69.68 72.91,69.68 70.29,72.3 69.15,72.3 68.92,72.07 68.52,72.07 68.29,72.3 68.11,72.3 67.88,72.07 67.7,72.07 67.47,72.3 67.3,72.3 67.07,72.07 66.89,72.07 66.66,72.3 66.48,72.3 66.25,72.07 66.08,72.07 65.85,72.3 65.67,72.3 65.44,72.07 65.24,72.07 64.78,71.61 55.81,71.61 55.08,70.88 55.08,70.07 54.11,69.1 53.41,69.1 53.05,69.46 51.9,69.46 51.78,69.58 51.78,69.85 v1(51.88,69.95)
  BOTTOM w0.127: U24.BJ39 79.3,57.08 79,56.78 v2(79,56.7) ; JDIM1.155 v1(51.88,69.95)
M_A_DIM0_ODT1: length 36.3
  TOP w0.127: v1(52.51,71.82) 52.51,71.37 51.22,70.08 51.22,68.72 52.26,67.68 52.44,67.68 52.8,67.32 52.8,66.6 53.27,66.13 55.23,66.13 55.78,65.58 62.82,65.58 63.11,65.29 65.7,65.29 68.34,62.65 69.11,62.65 70.01,61.74 70.01,61.11 70.29,60.83 v2(70.29,60.31)
  BOTTOM w0.079: v2(70.29,60.31) 70.7,60.72 72.57,60.72 72.72,60.56 73.03,60.56 73.35,60.89 73.91,60.89 74.03,61.02 74.54,61.02 74.64,60.92 75.73,60.92 76.03,60.62 U24.BB45
  BOTTOM w0.127: v1(52.51,71.82) 52.15,71.46 JDIM1.161
M_A_DQ0: length 31.4
  IN1 w0.089: v1(55.74,40.91) 55.74,41.31 55.95,41.51 56.07,41.51 56.17,41.41 56.35,41.41 56.45,41.52 56.45,41.64 56.32,41.77 56.32,41.89 56.47,42.03 56.59,42.03 56.81,41.82 57.01,41.82 57.23,42.04 57.36,42.04 57.45,41.96 57.58,41.96 57.69,42.07 57.69,42.21 57.61,42.29 57.61,42.42 57.74,42.55 57.86,42.55 58.07,42.34 58.19,42.34 58.32,42.47 58.32,42.6 58.12,42.8 58.12,42.92 58.24,43.05 58.37,43.05 58.57,42.85 58.7,42.85 58.82,42.97 58.82,43.1 58.62,43.3 58.62,43.43 58.75,43.55 58.87,43.55 59.07,43.35 59.2,43.35 59.32,43.48 59.32,43.6 59.12,43.8 59.12,43.93 59.25,44.06 59.37,44.06 59.58,43.85 59.7,43.85 59.83,43.98 59.83,44.1 59.62,44.31 59.62,44.43 61.99,46.8 62.6,46.8 63,46.39 63.33,46.39 63.59,46.65 63.59,47.05 64.17,47.64 65.97,47.64 66.23,47.89 66.48,47.89 v2(66.92,48.32)
  BOTTOM w0.076: 74.71,51.85 74.7,51.85 74.47,51.61 74.32,51.61 74.32,51.61
  BOTTOM w0.079: 74.32,51.61 73.86,51.61 73.73,51.48 72.55,51.48 70.74,49.67 70.32,49.67 69.35,48.7 67.41,48.7 67.04,48.32 v2(66.92,48.32) ; U24.CA48 74.71,51.85
  BOTTOM w0.102: v1(55.74,40.91) 56.09,40.55 57.39,40.55 57.55,40.71 JDIM1.46
M_A_DQ1: length 32.1
  IN1 w0.089: v2(65.1,48.37) 64.01,48.37 63.51,47.87 62.9,47.87 62.45,47.41 61.78,47.41 57.09,42.72 56.2,42.72 54.23,40.75 52.64,40.75 51.93,41.46 51.62,41.46 51.47,41.31 51.47,41.11 51.78,40.8 51.78,40.68 51.62,40.52 v1(51.62,40.27)
  BOTTOM w0.079: U24.CA47 75.37,51.85 75.14,52.08 73.85,52.08 73.59,51.82 72.42,51.82 70.62,50.02 70.17,50.02 69.18,49.03 65.62,49.03 65.35,48.77 65.35,48.62 v2(65.1,48.37)
  BOTTOM w0.102: v1(51.62,40.27) 51.6,40.27 51.41,40.45 JDIM1.45
M_A_DQ2: length 30.4
  IN1 w0.089: v2(66.32,48.31) 66.22,48.31 65.85,47.94 64.04,47.94 63.68,47.57 63.04,47.57 62.58,47.12 61.89,47.12 57.13,42.35 56.3,42.35 54.32,40.37 53.84,40.37 53.75,40.28 53.75,39.88 53.66,39.79 53.49,39.79 53.4,39.88 53.4,40.16 53.31,40.25 v1(52.89,40.25)
  BOTTOM w0.079: U24.CA49 73.86,51.85 73.66,51.65 72.48,51.65 70.68,49.85 70.24,49.85 69.26,48.86 67.23,48.86 67.12,48.75 66.86,48.75
  BOTTOM w0.102: JDIM1.49 51.84,41.45 52.89,40.4 v1(52.89,40.25) ; 66.86,48.75 66.48,48.75 66.32,48.59 v2(66.32,48.31)
M_A_DQ3: length 31
  IN1 w0.089: v2(65.97,51.04) 65.87,50.94 65.11,50.94 64.65,50.47 63.17,50.47 62.67,50.98 59.77,50.98 58.91,50.12 58.91,47.8 56.83,45.72 56.83,45.48 56.45,45.1 53.25,45.1 53.07,44.91 53.07,44.6 52.98,44.51 52.8,44.51 52.71,44.6 52.71,44.77 52.61,44.87 52.36,44.87 51.91,44.41 51.91,44.26 v1(51.62,43.98)
  BOTTOM w0.076: U24.BV49 74.26,53.05 73.07,53.05 72.63,52.6 72.18,52.6 70.31,50.74 69.67,50.74 69.28,50.35 66.67,50.35 v2(65.97,51.04)
  BOTTOM w0.102: JDIM1.59 51.6,43.95 v1(51.62,43.98)
M_A_DQ4: length 32.8
  IN1 w0.089: v2(68.13,48.32) 67.73,47.92 67.1,47.92 66.72,47.53 66.36,47.53 66.07,47.25 66.07,46.91 65.98,46.82 65.8,46.82 65.71,46.91 65.71,47.24 65.62,47.33 65.45,47.33 65.36,47.24 65.36,46.38 65.27,46.29 65.09,46.29 65,46.38 65,47.24 64.91,47.33 64.74,47.33 64.65,47.24 64.65,46.38 64.56,46.29 64.38,46.29 64.29,46.38 64.29,46.94 64.17,47.06 64.05,47.06 63.88,46.89 63.88,46.48 63.21,45.81 62.54,45.81 62.45,45.9 62.45,46.38 62.36,46.47 62.18,46.47 62.09,46.38 62.09,45.9 62,45.81 61.41,45.81 61.26,45.65 61.26,45.52 61.44,45.34 61.44,45.21 61.35,45.12 61.16,45.12 61,45.27 60.88,45.27 60.15,44.54 60.15,43.87 58.32,42.05 58.11,42.05 58.02,41.96 58.02,41.75 57.91,41.64 57.79,41.64 57.77,41.66 57.64,41.66 57.51,41.54 57.51,41.41 57.54,41.39 57.54,41.26 57.15,40.88 56.98,40.88 56.91,40.96 v1(56.91,41.31)
  BOTTOM w0.076: v2(68.13,48.32) 68.97,48.32 69.18,48.53 69.43,48.53 70.39,49.49 70.8,49.49
  BOTTOM w0.079: 70.8,49.49 72.62,51.31 73.8,51.31 73.93,51.45 74.54,51.45 74.65,51.56 75.7,51.56 76.24,51.86 U24.CA45
  BOTTOM w0.102: v1(56.91,41.31) 57.3,41.71 JDIM1.50
M_A_DQ5: length 32.6
  IN1 w0.089: v2(67.79,50.7) 67.62,50.53 65.14,50.53 64.79,50.18 63.05,50.18 62.54,50.68 59.89,50.68 59.24,50.04 59.24,47.72 57.13,45.61 57.13,45.37 56.52,44.75 54.73,44.75 54.64,44.66 54.64,44.49 54.55,44.4 54.38,44.4 54.28,44.49 54.28,44.66 54.19,44.75 53.72,44.75 v1(52.94,43.98)
  BOTTOM w0.079: v2(67.79,50.7) 68.17,51.09 70.09,51.09 72.02,53.02 72.57,53.02 72.93,53.38 73.98,53.38 74.11,53.51 74.54,53.51 74.55,53.5 75.11,53.5 75.5,53.11 U24.BV47
  BOTTOM w0.102: JDIM1.63 52.43,44.95 52.94,44.44 v1(52.94,43.98)
M_A_DQ6: length 33.3
  IN1 w0.089: v1(56.37,43.96) 56.56,43.96 60.3,47.71 60.3,47.83 59.87,48.26 59.87,48.39 60,48.52 60.12,48.52 60.55,48.08 60.68,48.08 60.81,48.21 60.81,48.33 60.21,48.93 60.21,49.06 60.33,49.19 60.46,49.19 61.05,48.6 61.17,48.6 61.3,48.72 61.3,48.85 60.85,49.3 60.85,49.42 60.98,49.55 61.1,49.55 61.66,48.99 61.79,48.99 61.92,49.12 61.92,49.23 61.33,49.82 61.33,49.95 61.48,50.1 62.24,50.1 62.74,49.6 66.11,49.6 66.28,49.77 66.45,49.77 v2(66.64,49.58)
  BOTTOM w0.079: U24.BV45 76.27,52.39 76.07,52.18 75.27,52.18 75.21,52.25 73.78,52.25 73.52,51.98 72.35,51.98 70.56,50.2 70.1,50.2 69.1,49.2 67.02,49.2 v2(66.64,49.58)
  BOTTOM w0.102: JDIM1.58 56.62,43.71 56.37,43.95 v1(56.37,43.96)
M_A_DQ7: length 31.7
  IN1 w0.089: v2(68.97,50.71) 68.97,50.53 68.59,50.15 66.1,50.15 65.87,49.92 65.67,49.92 65.44,50.15 65.21,50.15 64.95,49.89 62.92,49.89 62.42,50.39 61.34,50.39 61,50.05 60.84,50.05 60.51,50.38 60.35,50.38 60.24,50.27 60.24,50.14 60.63,49.76 60.63,49.63 60.5,49.5 60.22,49.5 60.08,49.36 59.96,49.36 59.83,49.49 59.7,49.49 59.58,49.37 59.58,49.24 59.83,48.99 59.83,48.8 59.57,48.55 59.57,48.12 59.85,47.84 59.85,47.67 59.66,47.48 59.42,47.48 59.29,47.35 59.29,47.11 59.16,46.98 58.92,46.98 58.79,46.85 58.79,46.61 58.66,46.48 58.42,46.48 58.29,46.35 58.29,46.11 56.59,44.41 55.48,44.41 v1(55.05,43.98)
  BOTTOM w0.079: v2(68.97,50.71) 69.17,50.91 70.15,50.91 72.09,52.85 72.64,52.85 73,53.22 74.05,53.22 74.18,53.34 74.47,53.34 74.48,53.33 74.75,53.33 U24.BV48
  BOTTOM w0.102: v1(55.05,43.98) 55.89,44.82 57.47,44.82 57.58,44.71 JDIM1.62
M_A_DQ8: length 40.8
  IN1 w0.089: v1(53.15,34.63) 53.15,34.03 53.24,33.95 53.6,33.95 53.69,34.03 53.69,34.44 53.78,34.53 53.96,34.53 54.05,34.44 54.05,34.03 54.13,33.95 54.31,33.95 54.4,34.03 54.4,34.49 54.49,34.58 54.67,34.58 54.76,34.49 54.76,34.03 54.85,33.95 58.41,33.95 63.63,39.17 67.05,39.17 69.37,41.48 69.37,41.58 71.36,43.57 71.54,43.57 72.71,44.74 72.71,45.18 74.12,46.6 74.3,46.6 74.64,46.94 74.64,49.43 75.61,50.4 75.82,50.4 76.66,51.24 76.66,51.44 76.8,51.58 77.27,51.58 77.66,51.18 v2(77.72,51.18)
  BOTTOM w0.102: JDIM1.17 52.35,33.45 53.15,34.25 v1(53.15,34.63) ; v2(77.72,51.18) 78,50.9 U24.CC42
M_A_DQ9: length 42
  IN1 w0.089: v2(79.04,51.17) 78.65,51.56 77.54,51.56 77.34,51.76 76.72,51.76 76.48,51.51 76.48,51.31 75.74,50.57 75.54,50.57 74.28,49.32 74.28,47.97 73.47,47.16 73.47,46.72 73.09,46.34 72.38,46.34 71.15,45.11 71.15,44.98 71.32,44.81 71.32,44.68 71.2,44.55 71.07,44.55 70.89,44.73 70.77,44.73 70.14,44.1 70.14,43.7 70.05,43.61 69.87,43.61 69.78,43.52 69.78,43.34 69.87,43.26 70.13,43.26 70.27,43.12 70.27,42.91 70.12,42.76 69.99,42.76 69.95,42.8 69.83,42.8 69.7,42.68 69.7,42.55 69.74,42.51 69.74,42.39 69.62,42.26 69.49,42.26 69.43,42.32 69.27,42.32 69.18,42.23 69.18,42.07 69.24,42.01 69.24,41.88 69.11,41.76 68.99,41.76 68.95,41.8 68.82,41.8 68.7,41.67 68.7,41.55 68.79,41.45 68.79,41.32 66.93,39.46 63.51,39.46 59.24,35.19 57.66,35.19 57.57,35.1 57.57,34.89 57.67,34.78 58.06,34.78 58.15,34.7 58.15,34.33 58.06,34.24 55.65,34.24 v1(55.26,34.63)
  BOTTOM w0.102: JDIM1.16 56.48,33.2 55.26,34.43 v1(55.26,34.63) ; U24.CC39 79.2,50.62 79.16,50.62 78.92,50.86 78.92,51.11 78.98,51.17 v2(79.04,51.17)
M_A_DQ10: length 39.8
  IN1 w0.089: v1(51.78,34.63) 51.78,34.58 52.7,33.65 58.54,33.65 60.47,35.59 60.6,35.59 60.79,35.39 60.92,35.39 61.05,35.52 61.05,35.65 60.85,35.84 60.85,35.97 60.98,36.09 61.1,36.09 61.3,35.9 61.42,35.9 61.55,36.02 61.55,36.15 61.35,36.35 61.35,36.47 61.48,36.6 61.6,36.6 61.8,36.4 61.93,36.4 62.05,36.53 62.05,36.65 61.86,36.85 61.86,36.97 61.98,37.1 62.11,37.1 62.3,36.9 62.43,36.9 62.56,37.03 62.56,37.15 62.36,37.35 62.36,37.48 63.76,38.87 67.17,38.87 69.66,41.36 69.66,41.46 71.48,43.28 71.67,43.28 73.09,44.7 73.09,45.08 74.9,46.89 74.9,49.43 75.68,50.22 75.89,50.22 76.88,51.2 v2(77.09,51.2)
  BOTTOM w0.102: v2(77.09,51.2) 77.09,51.17 77.35,50.91 U24.CC43 ; JDIM1.21 51.65,34.45 51.78,34.58 v1(51.78,34.63)
M_A_DQ11: length 41.4
  IN1 w0.089: v2(79.67,50.26) 79.67,50.01 79.44,49.77 78.93,49.77 78.65,49.49 78.65,48.73 77.4,47.48 76.71,47.48 76.31,47.08 76.31,46.8 76.69,46.41 76.69,46.01 76.26,45.58 76.26,44.44 75.28,43.45 75.28,43 73.8,41.53 73.49,41.53 71.25,39.28 71.25,37.54 70.43,36.72 70.43,36.59 70.67,36.35 70.67,36.23 70.54,36.1 70.42,36.1 70.17,36.34 70.05,36.34 69.92,36.22 69.92,36.09 70.17,35.85 70.17,35.72 70.04,35.6 69.91,35.6 69.67,35.84 69.55,35.84 69.42,35.71 69.42,35.59 69.66,35.35 69.66,35.22 69.54,35.09 69.41,35.09 68.66,35.84 68.51,35.84 68.41,35.74 68.41,35.59 69.03,34.97 69.03,34.84 68.91,34.72 68.78,34.72 68.16,35.34 67.98,35.34 67.3,34.66 67.3,33.66 66.29,32.65 60.9,32.65 59.43,31.18 v1(57.16,31.18)
  BOTTOM w0.102: JDIM1.8 57.19,31.2 v1(57.16,31.18) ; v2(79.67,50.26) 79.95,49.98 U24.CE38
M_A_DQ12: length 42.9
  IN1 w0.089: v2(79.67,51.17) 79.56,51.17 79.44,51.06 79.44,50.76 79.56,50.65 79.95,50.65 80.13,50.82 80.13,52.42 80,52.55 79.57,52.55 79.36,52.35 79.36,51.96 79.15,51.74 77.61,51.74 77.41,51.94 76.65,51.94 76.36,51.65 75.73,51.65 75.24,51.17 75.24,50.53 74.1,49.39 74.1,48.05 73.41,47.36 72.91,47.36 72.68,47.13 72.68,47.08 69.48,43.88 69.48,42.89 69.33,42.73 69,42.73 68.85,42.58 68.85,42.25 68.24,41.64 68.24,41.18 67.52,40.47 67.4,40.47 67.17,40.7 67.04,40.7 66.91,40.57 66.91,40.45 67.15,40.22 67.15,40.09 66.82,39.76 64.83,39.76 64.74,39.85 64.74,40.31 64.65,40.4 64.47,40.4 64.39,40.31 64.39,39.85 64.3,39.76 63.4,39.76 59.14,35.5 55.94,35.5 55.85,35.41 55.85,35.21 55.94,35.11 56.37,35.11 56.53,34.96 v1(56.53,34.68)
  BOTTOM w0.102: v2(79.67,51.17) 79.95,50.9 U24.CC38 ; JDIM1.20 57.03,34.2 56.55,34.68 v1(56.53,34.68)
M_A_DQ13: length 41
  IN1 w0.089: v1(55.88,31.18) 56.33,31.63 59.47,31.63 60.78,32.94 66.17,32.94 66.97,33.74 66.97,34.78 68.59,36.41 68.71,36.41 69.12,36 69.25,36 69.37,36.13 69.37,36.25 68.97,36.66 68.97,36.78 69.09,36.91 69.22,36.91 69.63,36.5 69.75,36.5 69.9,36.65 69.9,37.03 69.99,37.12 70.37,37.12 70.9,37.65 70.9,39.42 73.35,41.87 73.73,41.87 74.98,43.12 74.98,43.59 75.93,44.54 75.93,45.5 76.52,46.09 76.52,46.34 76.13,46.72 76.13,47.16 76.71,47.74 77.41,47.74 77.89,48.22 77.89,49.74 77.97,49.82 78.66,49.82 79.04,50.21 v2(79.04,50.26)
  BOTTOM w0.102: v2(79.04,50.26) 79.3,50 U24.CE39 ; v1(55.88,31.18) 55.9,31.18 56.88,30.2 JDIM1.4
M_A_DQ14: length 40
  IN1 w0.089: v2(77.72,50.24) 77.72,50.18 77.13,49.59 77.13,48.86 75.83,47.56 75.83,46.54 75.63,46.34 75.63,44.75 74.63,43.75 74.63,43.66 73.7,42.73 73.46,42.73 73,42.27 73,42 70.55,39.55 70.55,39.02 69.46,37.93 68.69,37.93 68.38,37.62 68.38,37.28 68.42,37.24 68.42,36.85 66.53,34.96 66.53,34.53 66.12,34.12 66.12,33.61 65.77,33.26 60.64,33.26 59.36,31.98 55.93,31.98 55.13,31.17 v1(53.78,31.17)
  BOTTOM w0.102: JDIM1.3 52.56,29.95 v1(53.78,31.17) ; v2(77.72,50.24) 78,49.95 U24.CE42
M_A_DQ15: length 38.8
  IN1 w0.089: v2(76.75,49.33) 76.24,48.81 76.24,48.6 75.63,47.99 75.63,46.6 75.25,46.21 75.25,44.85 74.29,43.9 74.29,43.73 73.58,43.03 73.3,43.03 72.71,42.43 72.71,42.19 70.22,39.7 70.22,39.1 69.38,38.26 68.44,38.26 67.55,37.37 67.55,36.51 67.35,36.31 67.23,36.31 67.14,36.4 67.01,36.4 66.89,36.28 66.89,36.15 66.98,36.06 66.98,35.94 66.23,35.19 66.23,34.66 65.82,34.25 65.82,33.74 65.64,33.56 60.48,33.56 59.24,32.32 55.86,32.32 55.17,31.63 52.82,31.63 v1(52.41,31.23)
  BOTTOM w0.102: U24.CE43 77.3,49.81 76.82,49.33 v2(76.75,49.33) ; JDIM1.7 51.48,30.95 51.75,31.23 v1(52.41,31.23)
M_A_DQ16: length 30.7
  IN1 w0.089: v1(52.26,45.73) 53.38,46.85 56,46.85 56.78,47.63 56.78,49.95 59.3,52.46 65.37,52.46 65.49,52.34 67.89,52.34 v2(68.67,51.56)
  BOTTOM w0.079: U24.BT48 74.72,54.35 74.55,54.17 74.33,54.09 73.87,54.09 73.76,53.98 72.28,53.98 71.42,53.12 71.42,53.06 70.31,51.95 69.06,51.95 v2(68.67,51.56)
  BOTTOM w0.102: v1(52.26,45.73) 51.83,46.16 51.42,46.16 51.21,45.95 JDIM1.67
M_A_DQ17: length 31.4
  IN1 w0.089: v2(69.91,51.55) 69.53,51.17 67.92,51.17 67.67,51.42 67.6,51.42 67.27,51.75 64.75,51.75 64.28,51.28 63.49,51.28 62.97,51.8 59.46,51.8 57.36,49.71 57.36,47.39 56.23,46.25 54.79,46.25 54.65,46.11 54.65,45.81 54.75,45.71 v1(55.05,45.71)
  BOTTOM w0.079: v2(69.91,51.55) 70.14,51.55 71.59,52.99 71.59,53.05 72.35,53.81 73.83,53.81 73.94,53.92 74.37,53.92 74.55,53.99 74.66,54.03 75.02,54.08 75.24,54.17 U24.BT47
  BOTTOM w0.102: v1(55.05,45.71) 55.05,46.09 55.67,46.71 JDIM1.70
M_A_DQ18: length 29.8
  IN1 w0.089: v1(53.53,45.73) 54.34,46.54 56.11,46.54 57.07,47.51 57.07,49.83 59.4,52.16 65.21,52.16 65.33,52.04 67.51,52.04 v2(67.63,51.93)
  BOTTOM w0.079: U24.BT49 74.23,54.25 73.8,54.25 73.72,54.17 72.23,54.17 71.25,53.19 71.25,53.13 70.24,52.12 68.06,52.12 67.87,51.93 v2(67.63,51.93)
  BOTTOM w0.102: JDIM1.71 52.41,46.95 53.53,45.83 v1(53.53,45.73)
M_A_DQ19: length 30.1
  IN1 w0.089: v2(67.88,53.61) 67.82,53.61 66.76,54.66 63.28,54.66 62.94,54.32 58.51,54.32 57.89,53.69 57.76,53.69 57.56,53.9 57.43,53.9 57.3,53.77 57.3,53.65 57.51,53.44 57.51,53.32 57.38,53.19 57.26,53.19 57.07,53.38 56.95,53.38 56.82,53.25 56.82,53.13 57.01,52.94 57.01,52.81 56.42,52.23 56.1,52.23 56.01,52.32 56.01,52.65 55.92,52.74 55.74,52.74 55.65,52.65 55.65,52.32 55.56,52.23 55.38,52.23 55.3,52.32 55.3,52.63 55.21,52.72 55.03,52.72 54.94,52.63 54.94,52.32 54.85,52.23 54.68,52.23 54.54,52.09 v1(54.54,51.55)
  BOTTOM w0.076: v2(67.88,53.61) 68.23,53.96 70.82,53.96 71.87,55.01 72.76,55.01 73.43,55.68 74.26,55.68 U24.BN49
  BOTTOM w0.102: JDIM1.84 55.89,50.2 v1(54.54,51.55)
M_A_DQ20: length 32.5
  IN1 w0.089: v1(56.32,45.73) 56.32,45.93 57.66,47.27 57.66,47.47 57.75,47.56 57.91,47.56 58,47.65 58,47.83 57.91,47.92 57.75,47.92 57.66,48.01 57.66,48.19 57.75,48.27 58.29,48.27 58.38,48.36 58.38,48.54 58.29,48.63 57.75,48.63 57.66,48.72 57.66,48.9 57.75,48.99 58.29,48.99 58.38,49.07 58.38,49.25 58.29,49.34 57.75,49.34 57.66,49.43 57.66,49.58 59.56,51.48 62.88,51.48 63.37,50.99 64.4,50.99 64.87,51.46 66.98,51.46 v2(67.12,51.32)
  BOTTOM w0.079: v2(67.12,51.32) 67.12,52.18 68.16,53.22 70.56,53.22 72.01,54.68 72.9,54.68 73.55,55.33 74,55.33 74.14,55.18 74.46,55.18 74.59,55.22 74.76,55.22 74.84,55.16 75.1,55.16 75.11,55.17 75.21,55.22 75.67,55.22 75.74,55.3 76.11,55.3 76.27,55.14 U24.BT45
  BOTTOM w0.102: v1(56.32,45.73) 56.35,45.71 JDIM1.66
M_A_DQ21: length 31.6
  IN1 w0.089: v2(69.15,53.59) 69.15,53.71 68.64,54.22 67.69,54.22 66.96,54.95 63.13,54.95 62.8,54.62 57.57,54.62 56.6,53.66 54.8,53.66 54.04,52.89 54.04,50.93 53.91,50.81 v1(53.91,50.41)
  BOTTOM w0.079: U24.BN47 75.4,55.39 75.17,55.39 75.05,55.33 74.89,55.33 74.81,55.39 74.56,55.39 74.44,55.35 74.21,55.35 74.05,55.51 73.5,55.51 72.83,54.84 71.94,54.84 70.88,53.79 69.35,53.79 v2(69.15,53.59)
  BOTTOM w0.102: v1(53.91,50.41) 55.11,49.2 JDIM1.80
M_A_DQ22: length 32.3
  IN1 w0.089: v2(66.1,53.58) 65.61,54.08 63.63,54.08 63.26,53.71 58.76,53.71 55.51,50.46 55.51,49.03 55.28,48.8 54.91,48.8 54.82,48.89 54.82,49.05 54.73,49.14 54.55,49.14 54.46,49.05 54.46,48.89 54.38,48.8 54.2,48.8 54.11,48.89 54.11,49.02 54.02,49.11 53.84,49.11 53.75,49.02 53.75,48.89 53.66,48.8 53.49,48.8 53.4,48.89 53.4,49 53.31,49.08 53.13,49.08 53.04,49 53.04,48.89 52.95,48.8 52.82,48.8 v1(52.26,48.25)
  BOTTOM w0.079: 66.71,54.29 70.68,54.29 71.73,55.35 72.62,55.35 73.29,56.01 74.54,56.01 74.64,55.91 75.98,55.91 U24.BN45
  BOTTOM w0.102: v2(66.1,53.58) 66.1,53.68 66.71,54.29 ; JDIM1.79 51.68,48.95 52.26,48.37 v1(52.26,48.25)
M_A_DQ23: length 30.8
  IN1 w0.089: v1(52.39,50.41) 53.35,49.44 53.6,49.44 53.68,49.53 53.68,49.78 53.77,49.87 53.95,49.87 54.04,49.78 54.04,49.53 54.13,49.44 54.31,49.44 54.4,49.53 54.4,49.83 54.48,49.92 54.66,49.92 54.75,49.83 54.75,49.53 54.84,49.44 55.1,49.44 55.21,49.54 55.21,50.58 58.63,54.01 63.1,54.01 63.46,54.37 66.51,54.37 v2(67.27,53.61)
  BOTTOM w0.079: U24.BN48 74.95,55.59 74.73,55.59 74.47,55.84 73.36,55.84 72.69,55.18 71.8,55.18 70.75,54.12 67.79,54.12 v2(67.27,53.61)
  BOTTOM w0.102: JDIM1.83 52.06,49.95 52.39,50.28 v1(52.39,50.41)
M_A_DQ24: length 38.8
  IN1 w0.089: v2(77.67,54.04) 77.67,54.2 77.53,54.35 75.84,54.35 75.58,54.09 75.58,53.65 73.6,51.68 72.57,51.68 69.23,48.33 69.23,47.87 68.16,46.8 67.69,46.8 65.07,44.18 62.52,44.18 61.91,43.57 61.91,43 61.82,42.91 61.03,42.91 60.91,42.79 60.91,42.42 60.76,42.26 60.38,42.26 57.37,39.25 53.03,39.25 52.95,39.34 52.95,39.62 52.86,39.71 52.68,39.71 52.59,39.62 52.59,38.95 52.49,38.85 52.34,38.85 52.23,38.95 52.23,39.57 52.15,39.66 51.97,39.66 51.88,39.57 51.88,38.59 51.55,38.26 v1(51.55,38.24)
  BOTTOM w0.102: U24.BV42 78,53.71 v2(77.67,54.04) ; v1(51.55,38.24) 51.55,38.26 51.36,38.45 JDIM1.37
M_A_DQ25: length 39.2
  IN1 w0.089: v2(79.07,53.92) 79.04,53.92 78.43,54.53 75.68,54.53 75.35,54.2 75.35,53.73 73.61,51.98 73.14,51.98 72.86,52.26 72.67,52.26 72.45,52.05 72.33,52.05 71.98,52.4 71.85,52.4 71.73,52.27 71.73,52.15 72.08,51.79 72.08,51.67 71.95,51.54 71.83,51.54 71.11,52.26 70.95,52.26 70.84,52.15 70.84,52.02 71.57,51.29 71.57,51.17 71.45,51.04 71.32,51.04 70.97,51.39 70.85,51.39 70.72,51.27 70.72,51.14 71.07,50.79 71.07,50.66 70.95,50.54 70.82,50.54 70.52,50.84 70.4,50.84 70.27,50.71 70.27,50.59 70.57,50.29 70.57,50.16 70.44,50.03 70.32,50.03 70.02,50.33 69.89,50.33 69.77,50.21 69.77,50.08 70.07,49.78 70.07,49.66 68.93,48.53 68.93,47.99 68.05,47.1 67.51,47.1 65.84,45.43 65.57,45.43 65.47,45.33 65.47,45.06 65.35,44.94 64.84,44.94 64.75,44.85 64.75,44.58 64.66,44.49 64.49,44.49 64.4,44.58 64.4,44.85 64.31,44.94 64.13,44.94 64.04,44.85 64.04,44.58 63.95,44.49 63.77,44.49 63.69,44.58 63.69,44.85 63.6,44.94 63.42,44.94 63.33,44.85 63.33,44.58 63.24,44.49 62.41,44.49 61.65,43.72 61.17,43.72 57.26,39.81 v1(57.14,39.81)
  BOTTOM w0.102: JDIM1.42 57.24,39.71 v1(57.14,39.81) ; v2(79.07,53.92) 79.3,53.68 U24.BV39
M_A_DQ26: length 38
  IN1 w0.089: v1(52.97,38.24) 52.97,38.8 53.1,38.92 53.86,38.92 53.95,38.84 53.95,38.4 54.04,38.31 54.21,38.31 54.3,38.4 54.3,38.84 54.39,38.92 54.57,38.92 54.66,38.84 54.66,38.4 54.75,38.31 54.93,38.31 55.01,38.4 55.01,38.84 55.1,38.92 57.5,38.92 60.55,41.97 61.73,41.97 62.29,42.53 62.29,43.54 62.64,43.88 65.26,43.88 67.87,46.49 68.26,46.49 69.52,47.75 69.52,48.19 72.75,51.42 73.6,51.42 75.63,53.45 76.13,53.45 76.66,53.97 v2(77.03,53.97)
  BOTTOM w0.102: v1(52.97,38.24) 52.97,38.9 52.41,39.45 JDIM1.41 ; v2(77.03,53.97) 77.35,53.65 U24.BV43
M_A_DQ27: length 38.6
  IN1 w0.089: v1(57.08,36) 58.93,36 64.18,41.26 65.19,41.26 65.28,41.17 65.28,40.38 65.37,40.3 65.55,40.3 65.64,40.38 65.64,41.17 65.73,41.26 65.9,41.26 65.99,41.17 65.99,40.36 66.08,40.27 66.26,40.27 66.35,40.36 66.35,41.21 67.21,42.07 67.33,42.07 67.55,41.85 67.68,41.85 67.8,41.97 67.8,42.1 67.58,42.32 67.58,42.32 67.32,42.58 67.32,42.71 67.44,42.83 67.57,42.83 68.05,42.35 68.18,42.35 68.31,42.47 68.31,42.6 67.83,43.08 67.83,43.27 68.45,43.89 68.77,43.89 71.47,46.58 71.74,46.58 72.15,46.99 72.15,47.69 74.96,50.5 74.96,51.14 75.21,51.38 75.64,51.82 76.73,52.18 77.19,52.18 77.5,52.49 78.92,52.49 79.01,52.57 79.62,53.01 v2(79.62,53.01)
  BOTTOM w0.102: JDIM1.28 57.29,36.2 v1(57.08,36) ; U24.BW38 79.95,52.69 v2(79.62,53.01)
M_A_DQ28: length 40
  IN1 w0.089: v1(55.81,39.81) 55.75,39.74 54.85,39.74 54.71,39.87 54.71,40.05 54.98,40.32 57.31,40.32 60.67,43.67 60.67,44.34 60.94,44.61 61.23,44.61 61.58,44.26 61.78,44.26 62.01,44.49 62.01,44.79 62.19,44.97 62.41,44.97 62.6,44.78 62.79,44.78 62.9,44.89 62.9,45.21 62.99,45.3 63.54,45.3 64.02,45.78 65.71,45.78 67.33,47.41 67.94,47.41 68.64,48.11 68.64,48.72 69.42,49.5 69.42,50.3 70.42,51.3 70.42,52.18 70.98,52.74 73.52,52.74 76.08,55.31 77.84,55.31 77.99,55.15 78.44,55.15 v2(79.67,53.92)
  BOTTOM w0.102: v1(55.81,39.81) 55.81,38.85 55.96,38.71 JDIM1.38 ; v2(79.67,53.92) 79.95,53.64 U24.BV38
M_A_DQ29: length 38.1
  IN1 w0.089: v2(78.97,53.01) 78.63,52.67 77.39,52.67 77.14,52.42 75.99,52.42 74.78,51.21 74.78,50.58 72.83,48.63 72.77,48.63 71.94,47.8 71.94,47.2 71.62,46.87 71.35,46.87 68.65,44.18 68.33,44.18 66.98,42.83 66.98,42.25 66.29,41.57 64.07,41.57 59.02,36.51 54.75,36.51 54.52,36.28 54.52,35.88 54.77,35.62 55.31,35.62 v1(55.69,36)
  BOTTOM w0.102: U24.BW39 79.3,52.69 v2(78.97,53.01) ; JDIM1.24 56.28,35.2 55.69,35.8 v1(55.69,36)
M_A_DQ30: length 36.6
  IN1 w0.089: v2(77.67,53.04) 77.64,53.04 77.51,53.04 77.09,52.62 75.94,52.62 74.59,51.27 74.59,50.64 74.13,50.18 74.13,50.18 72.79,48.84 72.45,48.84 71.72,48.11 71.72,47.38 71.5,47.17 71.22,47.17 68.62,44.56 68.3,44.56 66.69,42.95 66.69,42.45 66.11,41.87 63.91,41.87 58.88,36.84 53.4,36.84 53.29,36.94 v1(52.89,36.94)
  BOTTOM w0.102: JDIM1.25 51.53,35.45 52.89,36.82 v1(52.89,36.94) ; U24.BW42 78,52.69 77.67,53.01 v2(77.67,53.04)
M_A_DQ31: length 35.6
  IN1 w0.089: v1(51.62,36.94) 52.13,37.45 53.27,37.45 53.56,37.17 58.79,37.17 63.8,42.18 66,42.18 66.38,42.56 66.38,43.26 67.99,44.87 68.51,44.87 70.9,47.26 70.9,47.78 72.27,49.15 72.85,49.15 74.34,50.64 74.34,51.27 75.95,52.88 76.67,52.88 76.77,52.97 76.9,52.97 76.95,53.03 76.96,53.03 v2(76.97,53.04)
  BOTTOM w0.102: v2(76.97,53.04) 76.97,52.97 77.35,52.6 U24.BW43 ; v1(51.62,36.94) 51.14,36.45 JDIM1.29
M_A_DQ32: length 40.9
  IN1 w0.089: v1(52.87,76.97) 52.82,76.97 52.37,77.43 52.37,77.79 52.46,77.88 53.11,77.88 53.19,77.79 53.19,77.47 53.28,77.38 53.46,77.38 53.55,77.47 53.55,77.79 53.64,77.88 57.39,77.88 59.1,76.16 59.1,72.89 60.91,71.09 60.91,67.43 63.66,64.68 64.45,64.68 64.91,64.22 64.91,63.63 64.83,63.54 64.51,63.54 64.43,63.45 64.43,63.27 64.51,63.18 64.83,63.18 64.91,63.09 64.91,62.57 65.68,61.8 67.67,61.8 67.76,61.71 68.86,61.71 69.81,60.77 69.94,60.77 v2(70.45,61.28)
  BOTTOM w0.079: v2(70.45,61.28) 70.47,61.28 70.67,61.47 72.49,61.47 72.5,61.46 73.67,61.46 73.82,61.61 74.39,61.61 74.92,61.86 U24.AY48
  BOTTOM w0.102: v1(52.87,76.97) 52.87,77.23 52.14,77.95 JDIM1.187
M_A_DQ33: length 41.7
  IN1 w0.089: v1(55.03,76.97) 55.03,76.62 54.81,76.4 54.17,76.4 53.96,76.61 53.96,77.44 54.05,77.53 56.85,77.53 56.98,77.4 57.11,77.4 57.21,77.51 57.34,77.51 57.46,77.38 57.46,77.26 57.36,77.15 57.36,77.03 57.48,76.9 57.61,76.9 57.71,77.01 57.84,77.01 57.97,76.88 57.97,76.75 57.86,76.65 57.86,76.52 57.99,76.4 58.11,76.4 58.22,76.5 58.34,76.5 58.47,76.38 58.47,76.25 58.36,76.15 58.36,76.02 58.81,75.57 58.81,72.45 58.9,72.36 59.19,72.36 60.62,70.94 60.62,66.8 60.7,66.71 61.14,66.71 63.44,64.4 63.44,63.63 65.56,61.51 67.45,61.51 67.56,61.4 67.89,61.4 68.03,61.26 68.03,60.99 68.12,60.9 68.35,60.9 68.69,61.25 v2(68.69,61.31)
  BOTTOM w0.079: U24.AY47 75.38,61.86 75.15,62.09 74.12,62.09 73.98,61.95 73.68,61.95 73.53,61.8 72.64,61.8 72.63,61.8 69.55,61.8 69.05,61.31 v2(68.69,61.31)
  BOTTOM w0.102: v1(55.03,76.97) 55.89,77.84 57.34,77.84 57.47,77.7 JDIM1.186
M_A_DQ34: length 39.7
  IN1 w0.089: v2(69.03,60.22) 68.33,60.22 67.33,61.22 65.44,61.22 62.89,63.77 62.89,63.89 63.15,64.15 63.15,64.28 63.03,64.4 62.9,64.4 62.64,64.14 62.52,64.14 62.39,64.27 62.39,64.4 62.65,64.65 62.65,64.78 62.52,64.91 62.4,64.91 62.14,64.65 62.01,64.65 61.89,64.77 61.89,64.9 62.15,65.16 62.15,65.28 62.02,65.41 61.89,65.41 61.64,65.15 61.51,65.15 61.38,65.28 61.38,65.4 61.64,65.66 61.64,65.79 61.52,65.91 61.39,65.91 61.13,65.65 61.01,65.65 60.88,65.78 60.88,65.9 61.14,66.16 61.14,66.29 61.01,66.41 60.89,66.41 60.63,66.16 60.5,66.16 60.32,66.34 60.32,70.24 60.04,70.52 60.04,70.65 60.2,70.81 60.2,70.94 60.08,71.06 59.95,71.06 59.79,70.9 59.66,70.9 59.54,71.03 59.54,71.15 59.7,71.31 59.7,71.44 59.57,71.57 59.45,71.57 59.28,71.4 59.16,71.4 59.03,71.53 59.03,71.65 59.2,71.82 59.2,71.94 59.07,72.07 58.94,72.07 58.78,71.9 58.66,71.9 58.52,72.04 58.52,75.45 57.23,76.74 56.95,76.74 56.62,76.4 56.18,76.4 56.05,76.53 56.05,76.83 56.2,76.97 v1(56.35,76.97)
  BOTTOM w0.076: v2(69.03,60.22) 69.78,60.97 69.78,61.56 69.86,61.64 72.56,61.64 72.57,61.63 73.6,61.63 73.75,61.78 74.25,61.78 U24.AY49
  BOTTOM w0.102: v1(56.35,76.97) 56.62,76.7 JDIM1.182
M_A_DQ35: length 41
  IN1 w0.089: v2(67.96,59.45) 67.55,59.04 66.99,59.04 66.66,59.37 64.91,59.37 57.86,66.42 57.86,70.44 57.24,71.06 56.96,71.06 56.15,71.86 56.15,71.98 56.42,72.25 56.42,72.38 56.3,72.5 56.17,72.5 55.9,72.24 55.78,72.24 55.65,72.36 55.65,72.49 56.15,72.98 56.15,73.11 56.02,73.24 55.9,73.24 55.4,72.74 55.27,72.74 54.52,73.49 54.52,74 v1(55.74,75.22)
  BOTTOM w0.079: U24.AU45 76.27,62.34 76.14,62.2 75.3,62.2 75.25,62.26 74.05,62.26 73.91,62.11 73.61,62.11 73.46,61.96 72.71,61.96 72.7,61.97 68.78,61.97 68.01,61.2 68.01,59.5 v2(67.96,59.45)
  BOTTOM w0.102: JDIM1.174 56.15,74.7 55.74,75.12 v1(55.74,75.22)
M_A_DQ36: length 41.7
  IN1 w0.089: v1(51.57,76.95) 51.57,78.06 51.73,78.22 57.46,78.22 59.4,76.28 59.4,73.01 61.2,71.21 61.2,67.55 63.79,64.97 64.58,64.97 65.21,64.34 65.21,63.41 65.3,63.32 66.11,63.32 66.2,63.24 66.2,63.06 66.11,62.97 65.3,62.97 65.21,62.88 65.21,62.69 65.81,62.09 67.79,62.09 67.88,62.01 68.99,62.01 69.34,61.65 71.52,61.65 71.61,61.56 v2(71.61,61.1)
  BOTTOM w0.079: U24.AY45 76.03,61.86 75.72,61.54 74.65,61.54 74.43,61.45 73.89,61.45 73.74,61.3 71.78,61.3 71.63,61.15 71.63,61.12 v2(71.61,61.1)
  BOTTOM w0.102: JDIM1.183 v1(51.57,76.95)
M_A_DQ37: length 41
  IN1 w0.089: v2(65.44,59.78) 65.42,59.8 64.91,59.8 58.15,66.56 58.15,66.78 58.24,66.87 58.98,66.87 59.07,66.96 59.07,67.14 58.98,67.22 58.24,67.22 58.15,67.31 58.15,67.49 58.24,67.58 59,67.58 59.09,67.67 59.09,67.85 59,67.94 58.24,67.94 58.15,68.02 58.15,68.2 58.24,68.29 59,68.29 59.09,68.38 59.09,68.56 59,68.65 58.24,68.65 58.15,68.74 58.15,68.91 58.24,69 58.98,69 59.07,69.09 59.07,69.27 58.98,69.36 58.24,69.36 58.15,69.45 58.15,69.62 58.24,69.71 58.75,69.71 58.84,69.8 58.84,69.98 58.75,70.07 58.24,70.07 58.15,70.16 58.15,70.6 57.39,71.36 57.08,71.36 56.75,71.69 56.75,71.86 56.84,71.95 57.2,71.95 57.29,72.04 57.29,72.22 57.2,72.3 56.84,72.3 56.75,72.39 56.75,72.57 56.84,72.66 57.2,72.66 57.29,72.75 57.29,72.93 57.2,73.02 56.84,73.02 56.75,73.1 56.75,73.28 v1(57.08,73.61)
  BOTTOM w0.076: 67.99,62.81 71.76,62.81 72.32,63.37 73.34,63.37
  BOTTOM w0.079: 73.34,63.37 73.97,63.37 74.11,63.52 74.54,63.52 74.71,63.35 75.12,63.35 U24.AU47
  BOTTOM w0.102: JDIM1.170 57.18,73.7 v1(57.08,73.61) ; 67.99,62.81 65.73,60.55 65.73,60.07 v2(65.44,59.78)
M_A_DQ38: length 39.8
  IN1 w0.089: v2(65.06,58.69) 64.76,58.69 56.55,66.89 55.48,66.89 54.67,67.7 54.67,68.4 54.76,68.49 55.14,68.49 55.23,68.58 55.23,68.76 55.14,68.84 54.35,68.84 54.27,68.93 54.27,69.11 54.35,69.2 55.14,69.2 55.23,69.29 55.23,69.47 55.14,69.56 54.23,69.56 54.14,69.64 54.14,69.82 54.23,69.91 55.14,69.91 55.23,70 55.23,70.18 55.14,70.27 54.76,70.27 54.67,70.36 54.67,70.57 53.81,71.44 53.64,71.44 v1(51.62,73.46)
  BOTTOM w0.079: 66.48,60.82 68.31,62.64 71.83,62.64 72.39,63.21 74.03,63.21 74.18,63.35 74.47,63.35 74.7,63.12 U24.AU48
  BOTTOM w0.102: JDIM1.169 v1(51.62,73.46) ; 66.48,60.82 66.43,60.77 66.43,59.63 66.1,59.3 65.67,59.3 v2(65.06,58.69)
M_A_DQ39: length 39.5
  IN1 w0.089: v1(52.97,73.45) 53.38,73.04 53.5,73.04 53.74,73.28 53.87,73.28 54,73.15 54,73.03 53.64,72.67 53.64,72.55 53.76,72.42 53.89,72.42 54.25,72.78 54.37,72.78 54.5,72.65 54.5,72.53 54.26,72.28 54.26,72.16 54.38,72.03 54.51,72.03 54.75,72.27 54.88,72.27 55,72.15 55,72.02 54.76,71.78 54.76,71.65 54.89,71.53 55.01,71.53 55.25,71.77 55.38,71.77 55.5,71.64 55.5,71.52 55.26,71.28 55.26,71.15 55.69,70.73 57.16,70.73 57.57,70.32 57.57,66.3 64.79,59.08 65.84,59.08 v2(66.23,58.69)
  BOTTOM w0.079: 66.64,60.17 66.64,60.59 68.52,62.48 71.9,62.48 72.46,63.04 74.24,63.04 U24.AU49
  BOTTOM w0.102: 66.64,60.17 66.64,59.09 v2(66.23,58.69) ; v1(52.97,73.45) 52.97,73.7 52.21,74.46 JDIM1.173
M_A_DQ40: length 46.9
  IN1 w0.089: v1(53.66,89.14) 53.27,88.75 53.27,88.31 53.43,88.15 56.62,88.15 63.79,80.99 66.05,80.99 68.95,78.09 68.95,77.74 69.94,76.74 69.94,74.74 71.01,73.67 71.14,73.67 71.23,73.75 71.35,73.75 71.48,73.63 71.48,73.5 71.39,73.42 71.39,73.29 71.52,73.17 71.64,73.17 71.73,73.25 71.86,73.25 71.98,73.13 71.98,73 71.89,72.91 71.89,72.79 72.17,72.51 72.17,70.57 74.29,68.46 74.29,67.8 74.92,67.16 74.92,63.3 75.69,62.53 77.13,62.53 77.52,62.14 77.65,62.14 v2(77.69,62.11)
  BOTTOM w0.102: v1(53.66,89.14) 52.31,87.79 51.55,87.79 51.21,87.45 JDIM1.225 ; U24.AY42 78,61.83 77.72,62.11 v2(77.69,62.11)
M_A_DQ41: length 47.2
  IN1 w0.089: v2(79.62,62.16) 79.13,62.66 77.58,62.66 77.3,62.94 75.89,62.94 75.33,63.5 75.33,67.37 74.69,68 74.69,68.9 72.76,70.83 72.76,73.21 71.81,74.16 71.81,74.8 70.99,75.63 70.99,78.47 70.11,79.34 68.52,79.34 68.32,79.55 68.32,79.68 68.56,79.92 68.56,80.05 68.44,80.18 68.31,80.18 68.06,79.93 67.94,79.93 67.81,80.05 67.81,80.18 68.06,80.43 68.06,80.55 67.93,80.68 67.81,80.68 67.56,80.43 67.44,80.43 66.29,81.57 66.09,81.57 66.01,81.66 66.01,81.89 65.92,81.98 65.74,81.98 65.65,81.89 65.65,81.66 65.56,81.57 65.38,81.57 65.29,81.66 65.29,81.81 65.21,81.9 65.03,81.9 64.94,81.81 64.94,81.66 64.85,81.57 64.67,81.57 64.58,81.66 64.58,81.86 64.49,81.95 64.32,81.95 64.23,81.86 64.23,81.66 64.14,81.57 64.03,81.57 56.51,89.09 v1(56.32,89.09)
  BOTTOM w0.102: v1(56.32,89.09) 56.32,88.89 57,88.21 JDIM1.228 ; U24.AY38 v2(79.62,62.16)
M_A_DQ42: length 46.2
  IN1 w0.089: v2(77.03,62.11) 76.81,62.33 75.59,62.33 74.72,63.2 74.72,67.06 74.08,67.7 74.08,68.23 71.88,70.43 71.88,72.39 69.65,74.62 69.65,76.51 69.6,76.56 69.47,76.56 69.17,76.26 69.05,76.26 68.92,76.39 68.92,76.52 69.22,76.82 69.22,76.94 69.1,77.07 68.97,77.07 68.67,76.77 68.54,76.77 68.42,76.89 68.42,77.02 68.72,77.32 68.72,77.44 68.51,77.65 68.51,78.01 65.83,80.69 63.67,80.69 56.55,87.81 52.98,87.81 52.26,88.53 v1(52.26,89.11)
  BOTTOM w0.102: v2(77.03,62.11) 77.35,61.78 U24.AY43 ; JDIM1.229 51.6,88.45 v1(52.26,89.11)
M_A_DQ43: length 47.4
  IN1 w0.089: v2(78.97,61.25) 78.33,60.6 75.84,60.6 73.7,62.74 73.7,66.55 73.47,66.79 71.61,66.79 70.03,68.37 70.03,69.05 69.94,69.14 69.7,69.14 69.61,69.23 69.61,69.41 69.7,69.49 69.94,69.49 70.03,69.58 70.03,69.76 69.94,69.85 69.7,69.85 69.61,69.94 69.61,70.12 69.7,70.21 69.94,70.21 70.03,70.29 70.03,70.75 69.5,71.28 69.15,71.28 68.97,71.46 68.97,71.94 64.32,76.59 64.32,77.43 57.64,84.11 53.99,84.11 53.9,84.2 53.9,84.73 53.81,84.82 53.64,84.82 53.55,84.73 53.55,84.2 53.46,84.11 53.17,84.11 53.02,84.26 v1(53.02,84.95)
  BOTTOM w0.102: JDIM1.211 52.03,83.95 v1(53.02,84.95) ; U24.BB39 79.16,60.98 v2(78.97,61.25)
M_A_DQ44: length 47.8
  IN1 w0.089: v1(55.03,89.09) 55.05,89.09 55.7,88.44 56.75,88.44 63.91,81.28 66.17,81.28 68.4,79.05 69.99,79.05 70.69,78.35 70.69,77.01 70.6,76.92 70.36,76.92 70.27,76.83 70.27,76.66 70.36,76.57 70.6,76.57 70.69,76.48 70.69,76.3 70.6,76.21 70.36,76.21 70.27,76.12 70.27,75.95 70.36,75.86 70.6,75.86 70.69,75.77 70.69,75.59 70.6,75.5 70.51,75.5 70.42,75.41 70.42,75.23 70.51,75.15 70.6,75.15 70.69,75.06 70.69,74.86 72.46,73.09 72.46,70.71 74.49,68.69 74.49,67.9 75.13,67.26 75.13,63.4 75.79,62.73 77.22,62.73 77.47,62.48 78.65,62.48 v2(78.97,62.16)
  BOTTOM w0.102: U24.AY39 v2(78.97,62.16) ; v1(55.03,89.09) 55.03,88.78 56.01,87.8 56.39,87.8 56.83,87.36 57.26,87.36 57.42,87.21 JDIM1.224
M_A_DQ45: length 47.2
  IN1 w0.089: v2(79.62,61.25) 78.78,60.4 75.74,60.4 73.5,62.64 73.5,66.45 73.37,66.58 70.83,66.58 68.95,68.46 68.95,68.9 69.27,69.22 69.27,70.25 69.15,70.37 68.92,70.37 68.67,70.63 68.67,71.83 68.54,71.96 68.41,71.96 68.03,71.57 67.91,71.57 67.78,71.7 67.78,71.83 68.16,72.21 68.16,72.33 64.03,76.46 64.03,77.31 57.53,83.81 51.83,83.81 51.62,84.01 v1(51.62,84.95)
  BOTTOM w0.102: JDIM1.215 v1(51.62,84.95) ; U24.BB38 v2(79.62,61.25)
M_A_DQ46: length 47.1
  IN1 w0.089: v1(55.05,84.96) 55.05,84.49 55.14,84.4 57.76,84.4 65.09,77.07 65.09,76.23 65.54,75.78 65.67,75.78 65.85,75.96 65.97,75.96 66.1,75.83 66.1,75.71 65.92,75.53 65.92,75.4 66.05,75.28 66.17,75.28 66.35,75.45 66.48,75.45 66.6,75.33 66.6,75.2 66.42,75.02 66.42,74.9 66.55,74.77 66.68,74.77 66.86,74.95 66.98,74.95 67.11,74.83 67.11,74.7 66.93,74.52 66.93,74.4 67.05,74.27 67.18,74.27 67.36,74.45 67.48,74.45 67.61,74.32 67.61,74.2 67.43,74.02 67.43,73.89 67.56,73.77 67.68,73.77 67.86,73.95 67.99,73.95 68.11,73.82 68.11,73.69 67.93,73.52 67.93,73.39 68.06,73.26 68.18,73.26 68.36,73.44 68.49,73.44 68.62,73.32 68.62,73.19 68.44,73.01 68.44,72.89 68.56,72.76 68.69,72.76 68.87,72.94 68.99,72.94 69.12,72.81 69.12,72.69 68.94,72.51 68.94,72.38 69.07,72.26 69.56,72.26 70.36,71.46 70.36,68.8 70.58,68.57 70.7,68.57 70.83,68.69 70.95,68.69 71.08,68.57 71.08,68.44 70.96,68.32 70.96,68.2 71.08,68.07 71.35,68.07 71.46,67.96 71.46,67.3 71.77,66.99 73.59,66.99 73.91,66.68 73.91,62.84 75.21,61.54 76.17,61.54 76.9,60.8 77.44,60.8 77.69,61.05 v2(77.69,61.18)
  BOTTOM w0.102: U24.BB42 77.96,60.8 v2(77.69,61.18) ; v1(55.05,84.96) 55.47,85.38 57.41,85.38 57.59,85.21 JDIM1.216
M_A_DQ47: length 46.3
  IN1 w0.089: v2(77.08,61.18) 77.07,61.19 76.81,61.19 76.25,61.74 75.31,61.74 74.11,62.95 74.11,66.77 73.69,67.19 71.97,67.19 71.77,67.4 71.77,68.3 70.65,69.41 70.65,71.88 66.08,76.45 66.08,76.93 65.73,77.28 65.39,77.28 65.06,77.61 65.06,77.82 65.92,78.68 65.92,78.81 65.8,78.93 65.67,78.93 64.74,78 64.62,78 64.49,78.13 64.49,78.25 65.34,79.11 65.34,79.23 65.22,79.36 65.09,79.36 64.24,78.51 64.11,78.51 63.99,78.63 63.99,78.76 64.44,79.21 64.44,79.34 64.32,79.46 64.19,79.46 63.74,79.01 63.61,79.01 56.75,85.86 56.15,85.86 55.98,85.7 55.98,85.42 v1(56.45,84.95)
  BOTTOM w0.076: U24.BB43 v2(77.08,61.18)
  BOTTOM w0.102: v1(56.45,84.95) 57.19,84.21 JDIM1.212
M_A_DQ48: length 38.1
  IN1 w0.089: v1(56.7,78.78) 57.62,78.78 59.9,76.49 59.9,75.21 59.99,75.13 60.45,75.13 60.54,75.04 60.54,74.86 60.45,74.77 59.99,74.77 59.9,74.68 59.9,74.5 59.99,74.41 60.45,74.41 60.54,74.33 60.54,74.15 60.45,74.06 59.99,74.06 59.9,73.97 59.9,73.67 60.76,72.82 60.76,72.69 60.69,72.63 60.69,72.5 60.82,72.38 60.94,72.38 61.01,72.44 61.13,72.44 61.26,72.32 61.26,72.19 61.2,72.13 61.2,72 61.32,71.87 61.45,71.87 61.51,71.94 61.64,71.94 61.71,71.87 61.71,67.77 64,65.48 64.79,65.48 65.06,65.2 65.19,65.2 65.45,65.46 65.57,65.46 65.7,65.34 65.7,65.21 65.44,64.95 65.44,64.83 65.56,64.7 65.69,64.7 65.95,64.96 66.07,64.96 66.2,64.84 66.2,64.71 65.88,64.39 65.88,64.27 66.01,64.14 66.13,64.14 66.45,64.46 66.58,64.46 66.7,64.33 66.7,64.21 66.44,63.95 66.44,63.82 66.53,63.73 67.2,63.73 67.39,63.54 67.39,63.2 68.08,62.51 70.11,62.51 70.34,62.75 v2(70.34,63.33)
  BOTTOM w0.079: U24.AR48 74.72,64.36 74.49,64.13 74.18,64.13 74.03,64.28 72.76,64.28 71.62,63.14 70.69,63.14 70.47,63.36 70.37,63.36 v2(70.34,63.33)
  BOTTOM w0.102: v1(56.7,78.78) 56.78,78.7 JDIM1.190
M_A_DQ49: length 38.8
  IN1 w0.089: v1(53.2,79.28) 53.29,79.28 53.48,79.48 57.74,79.48 61.12,76.1 61.12,73.28 62.29,72.11 62.29,68.03 62.47,67.85 64.53,67.85 64.84,67.54 64.84,66.63 65.41,66.06 66.48,66.06 68.39,64.15 68.39,63.37 68.66,63.1 69.31,63.1 v2(69.57,63.36)
  BOTTOM w0.079: U24.AR47 75.37,64.11 74.71,64.11 74.57,63.96 74.11,63.96 73.96,64.11 72.83,64.11 71.69,62.98 70.07,62.98 69.68,63.36 v2(69.57,63.36)
  BOTTOM w0.102: JDIM1.195 51.18,79.95 51.34,80.12 52.54,80.12 53.2,79.46 v1(53.2,79.28)
M_A_DQ50: length 37.1
  IN1 w0.089: v2(71.59,63.66) 71.74,63.66 72.43,64.36 72.43,64.97 71.88,65.52 71.47,65.52 71.17,65.81 70.7,65.81 70.3,66.21 69.85,66.21 69.71,66.35 69.71,66.48 69.86,66.63 69.86,66.76 69.74,66.89 69.61,66.89 69.46,66.73 69.33,66.73 69.21,66.86 69.21,66.98 69.36,67.14 69.36,67.26 69.24,67.39 69.11,67.39 68.95,67.23 68.83,67.23 68.7,67.36 68.7,67.48 68.86,67.64 68.86,67.77 68.73,67.89 68.61,67.89 68.45,67.74 68.33,67.74 68.2,67.86 68.2,67.99 68.36,68.14 68.36,68.27 68.23,68.39 68.1,68.39 67.95,68.24 67.82,68.24 67.66,68.4 67.66,68.87 67.57,68.96 67.11,68.96 67.02,69.05 67.02,69.22 67.11,69.31 67.57,69.31 67.66,69.4 67.66,69.89 66.6,70.95 66.6,71.69 66.69,71.78 67.11,71.78 67.19,71.87 67.19,72.05 67.11,72.14 66.69,72.14 66.6,72.23 66.6,72.41 66.69,72.49 66.93,72.49 67.02,72.58 67.02,72.76 66.93,72.85 66.69,72.85 66.6,72.94 66.6,73.14 63.52,76.21 63.52,77.1 57.58,83.04 v1(56.96,83.04)
  BOTTOM w0.076: v2(71.59,63.66) 71.9,63.66
  BOTTOM w0.079: U24.AR49 74.24,64.36 74.16,64.45 72.69,64.45 71.9,63.66
  BOTTOM w0.102: v1(56.96,83.04) 57.12,83.21 JDIM1.208
M_A_DQ51: length 36.7
  IN1 w0.089: v1(52.38,83.02) 53.06,82.34 57.45,82.34 62.94,76.85 62.94,74.54 66.01,71.47 66.01,69.22 69.71,65.52 v2(70.14,65.52)
  BOTTOM w0.079: v2(70.14,65.52) 70.17,65.52 70.48,65.83 73.71,65.83 73.9,66.02 74.56,66.02 74.67,65.91 75.74,65.91 76.03,65.62 U24.AM45
  BOTTOM w0.102: v1(52.38,83.02) 52.38,82.9 52.05,82.56 51.56,82.56 51.16,82.95 JDIM1.207
M_A_DQ52: length 39.2
  IN1 w0.089: v2(70.4,63.94) 69.96,63.49 69.96,63.21 69.55,62.81 68.54,62.81 68.1,63.25 68.1,64.03 67.58,64.55 67.45,64.55 67.26,64.36 67.14,64.36 67.01,64.48 67.01,64.61 67.2,64.8 67.2,64.92 67.08,65.05 66.95,65.05 66.76,64.86 66.63,64.86 66.51,64.99 66.51,65.29 66.03,65.77 64.12,65.77 62,67.89 62,71.99 60.83,73.16 60.83,75.98 57.62,79.19 55.64,79.19 v1(55.23,78.78)
  BOTTOM w0.079: v2(70.4,63.94) 70.42,63.96 70.42,63.97 71.62,65.17 74.01,65.17 74.07,65.22 75.68,65.22 75.76,65.3 76.19,65.3 76.27,65.22 U24.AR45
  BOTTOM w0.102: JDIM1.194 56.16,79.7 v1(55.23,78.78)
M_A_DQ53: length 36.2
  IN1 w0.089: v1(51.75,79.28) 51.75,79.49 52.04,79.77 57.86,79.77 61.42,76.22 61.42,73.4 62.58,72.23 62.58,69.49 63.59,68.48 64.47,68.48 68.88,64.07 v2(68.97,64.07)
  BOTTOM w0.079: v2(68.97,64.07) 69.31,64.41 70.59,64.41 71.52,65.34 73.94,65.34 74,65.39 75.39,65.39 U24.AM47
  BOTTOM w0.102: v1(51.75,79.28) 51.42,78.95 JDIM1.191
M_A_DQ54: length 35.9
  IN1 w0.089: v2(70.76,65.37) 70.76,65.42 70.74,65.44 70.74,65.48 70.3,65.92 69.73,65.92 66.31,69.34 66.31,73.02 66.09,73.23 65.97,73.23 65.45,72.72 65.33,72.72 65.2,72.84 65.2,72.97 65.71,73.48 65.71,73.61 65.59,73.73 65.46,73.73 65.08,73.35 64.95,73.35 64.83,73.47 64.83,73.6 65.21,73.99 65.21,74.11 63.23,76.09 63.23,76.97 57.58,82.63 56.1,82.63 v1(55.69,83.04)
  BOTTOM w0.076: 73.99,65.85 73.81,65.67 70.98,65.67 70.76,65.45 v2(70.76,65.37)
  BOTTOM w0.079: 73.99,65.85 74.47,65.85 74.7,65.62 U24.AM48
  BOTTOM w0.102: v1(55.69,83.04) 55.69,82.66 56.17,82.18 57.26,82.18 57.28,82.21 JDIM1.204
M_A_DQ55: length 35.2
  IN1 w0.089: v2(69.73,65.09) 65.72,69.1 65.72,71.35 62.65,74.42 62.65,76.73 57.33,82.05 53.16,82.05 52.28,81.17 v1(52.28,81.16)
  BOTTOM w0.076: v2(69.73,65.09) 69.73,64.93 70.09,64.58 70.52,64.58 71.45,65.5 73.87,65.5 73.99,65.62 U24.AM49
  BOTTOM w0.102: v1(52.28,81.16) 51.49,81.95 JDIM1.203
M_A_DQ56: length 52.3
  IN1 w0.089: v1(53.48,90.84) 53.94,91.3 56.88,91.3 56.94,91.36 57.3,91.36 59.5,89.16 59.5,88.3 61.52,86.28 61.64,86.28 61.83,86.47 61.96,86.47 62.09,86.34 62.09,86.21 61.9,86.02 61.9,85.9 62.04,85.76 62.16,85.76 62.42,86.02 62.54,86.02 62.68,85.88 62.68,85.76 62.42,85.5 62.42,85.38 62.56,85.24 62.68,85.24 62.94,85.5 63.07,85.5 63.2,85.36 63.2,85.24 62.95,84.98 62.95,84.85 63.08,84.72 63.21,84.72 63.46,84.97 63.59,84.97 63.72,84.84 63.72,84.71 63.47,84.46 63.47,84.33 63.68,84.12 67.9,84.12 68.2,83.83 68.2,82.63 68.44,82.38 68.62,82.38 72.38,78.62 72.38,77.78 72.93,77.23 73.57,77.23 74.25,76.55 74.25,73.58 74.76,73.06 74.76,69.79 75.3,69.25 75.3,68.31 76.01,67.6 76.01,66.95 76.52,66.44 76.52,65.95 76.06,65.5 76.06,64.47 76.54,63.98 76.54,63.64 76.63,63.55 77.22,63.55 77.66,63.98 77.74,63.98 v1(77.75,63.99)
  BOTTOM w0.102: U24.AT42 77.75,63.98 v1(77.75,63.99) ; JDIM1.233 51.18,89.45 51.37,89.65 52.64,89.65 53.48,90.49 v1(53.48,90.84)
M_A_DQ57: length 52.9
  IN1 w0.089: v1(79.03,63.98) 78.64,63.59 77.51,63.59 77.27,63.34 76.51,63.34 76.34,63.51 76.34,63.89 75.8,64.42 75.8,65.54 76.31,66.05 76.31,66.35 75.8,66.86 75.8,67.5 75.1,68.2 75.1,69.12 74.47,69.75 74.47,72.92 73.87,73.52 73.87,74.26 73.72,74.41 73.72,75.4 73.18,75.94 72.42,75.94 72.09,76.27 72.09,78.5 68.49,82.09 68.3,82.09 67.91,82.49 67.91,83.5 67.58,83.83 65.05,83.83 64.96,83.74 64.96,83.46 64.87,83.37 64.68,83.37 64.6,83.46 64.6,83.74 64.51,83.83 64.32,83.83 64.23,83.74 64.23,83.46 64.14,83.37 63.38,83.37 62.64,84.12 62.64,84.24 62.8,84.4 62.8,84.53 62.67,84.66 62.54,84.66 62.38,84.5 62.25,84.5 62.12,84.64 62.12,84.76 62.28,84.93 62.28,85.05 62.14,85.19 62.02,85.19 61.86,85.03 61.73,85.03 61.6,85.16 61.6,85.29 61.76,85.45 61.76,85.57 61.62,85.71 61.5,85.71 61.34,85.55 61.21,85.55 61.08,85.68 61.08,85.81 61.24,85.97 61.24,86.09 61.1,86.23 60.98,86.23 60.81,86.07 60.69,86.07 60.55,86.2 60.55,86.33 60.71,86.49 60.71,86.62 60.58,86.75 60.45,86.75 60.29,86.59 60.17,86.59 60.03,86.73 60.03,86.85 60.19,87.01 60.19,87.14 60.06,87.27 59.93,87.27 59.77,87.11 59.65,87.11 59.51,87.25 59.51,87.37 59.67,87.53 59.67,87.66 59.54,87.79 59.41,87.79 59.25,87.63 59.12,87.63 58.99,87.77 58.99,87.89 59.15,88.06 59.15,88.18 59.01,88.32 58.89,88.32 58.73,88.16 58.6,88.16 58.47,88.29 58.47,88.42 58.63,88.58 58.63,88.7 58.49,88.84 58.37,88.84 58.21,88.68 58.08,88.68 57.95,88.81 57.95,88.94 58.11,89.1 58.11,89.22 57.97,89.36 57.85,89.36 57.68,89.2 57.56,89.2 57.42,89.33 57.42,89.46 57.58,89.62 57.58,89.75 57.45,89.88 57.32,89.88 57.16,89.72 57.04,89.72 56.49,90.27 v1(56.49,90.84)
  BOTTOM w0.102: v1(56.49,90.84) 56.84,90.49 56.98,90.49 57.26,90.21 JDIM1.236 ; U24.AT39 79.05,63.97 v1(79.03,63.98)
M_A_DQ58: length 50.6
  IN1 w0.089: v1(52.84,93.36) 53.27,92.92 53.73,92.92 54.23,93.43 54.49,93.43 54.58,93.34 54.58,93.03 54.67,92.94 54.86,92.94 54.95,93.03 54.95,93.34 55.04,93.43 57.64,93.43 64.63,86.44 66.29,86.44 67.02,85.71 68.62,85.71 69.68,84.64 71.41,84.64 75.04,81.01 75.04,77.91 75.77,77.18 75.77,75.18 76.52,74.43 76.52,73.52 76.34,73.34 76.34,70.14 76.65,69.83 77.03,69.83 77.17,69.69 77.17,68.17 77.34,68 77.84,68 78.02,67.82 78.02,67.19 78.07,67.15 78.07,66.43 77.91,66.28 77.6,66.28 77.3,65.98 77.3,65.11 77.12,64.92 v1(77.1,64.92)
  BOTTOM w0.102: JDIM1.245 51.99,92.45 52.84,93.31 v1(52.84,93.36) ; U24.AR43 77.33,64.45 77.09,64.91 77.1,64.92 v1(77.1,64.92)
M_A_DQ59: length 51.8
  IN1 w0.089: v1(79.67,63.98) 79.1,63.41 77.59,63.41 77.32,63.14 75.99,63.14 75.53,63.6 75.53,67.47 74.9,68.1 74.9,69.02 74.18,69.73 74.18,72.78 73.7,73.27 73.42,73.27 73,73.69 73,75.46 72.83,75.63 72.32,75.63 71.8,76.15 71.8,78.38 68.37,81.8 68.1,81.8 67.54,81.24 67.42,81.24 67.28,81.38 67.28,81.51 67.78,82 67.78,82.13 67.64,82.26 67.52,82.26 67.02,81.77 66.9,81.77 66.76,81.9 66.76,82.03 67.19,82.46 67.19,82.59 67.08,82.7 66.91,82.7 66.72,82.51 66.56,82.51 66.45,82.62 66.45,82.88 66.29,83.04 63.28,83.04 56.67,89.65 55.33,89.65 55.05,89.93 v1(55.05,90.84)
  BOTTOM w0.102: v1(79.67,63.98) 79.68,63.97 U24.AT38 ; v1(55.05,90.84) 55.08,90.82 55.08,90.82 56,89.9 56.65,89.9 57.35,89.21 JDIM1.232
