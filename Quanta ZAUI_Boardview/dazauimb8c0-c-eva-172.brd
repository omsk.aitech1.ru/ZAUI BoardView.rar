# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
D-0_6X0_3-0_32H-SMT
  custom 0.051x0.051 smd: 1(-0.242,0) 2(0.242,0)
D-1_85X1_25-2P-0_95H
  rect 0.787x0.889 smd: 1(-1.07,0) 2(1.07,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-SOD323-1_7X1_25-PMEG4005AEA
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-SOD323-1_85X1_25-0_95H
  rect 0.559x0.813 smd: 1(-1.15,0) 2(1.15,0)
DCJK-30706-00042-001-3P-SMT
  oval 1.6x2.489 hole 0.991x1.905: 1(0,8.15)
  oval 1.092x2.108 hole 0.508x1.499: 2(2.15,7.5) 3(-2.15,7.5)
  oval 1.194x3.607 hole 0.508x2.997: 4(-4.25,0) 5(4.25,0)
DDR4-D4AR0-26001-1P40-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
DFN8-2X2-5-9P-MAX8902B
  rect 0.305x0.889 smd: 1(-0.75,-1.15) 2(-0.25,-1.15) 3(0.25,-1.15) 4(0.75,-1.15) 5(0.75,1.15) 6(0.25,1.15) 7(-0.25,1.15) 8(-0.75,1.15)
  rect 1.295x0.711 smd: 9(0,0)
DFN14-3X2-4-15P-0_85H
  rect 0.203x0.711 smd: 1(-1.2,-1) 2(-0.8,-1) 3(-0.4,-1) 4(0,-1) 5(0.4,-1) 6(0.8,-1) 7(1.2,-1) 8(1.2,1) 9(0.8,1) 10(0.4,1) 11(0,1) 12(-0.4,1) 13(-0.8,1) 14(-1.2,1)
  rect 2.591x0.914 smd: 15(0,0)
DFN1006-3-1X0_6-0_55H-3P
  rect 0.356x0.254 smd: 1(0.325,0.225) 2(0.325,-0.225)
  rect 0.457x0.559 smd: 3(-0.275,0)
DFN-8L-3X3-65-5P-0_9H
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(-0.51,0)
ESD10-4_1X2-8-11P
  rect 0.203x0.508 smd: 1(-1.8,-0.95) 2(-1,-0.95) 3(-0.2,-0.95) 4(0.6,-0.95) 5(1.4,-0.95) 6(1.8,0.95) 7(1,0.95) 8(0.2,0.95) 9(-0.6,0.95) 10(-1.4,0.95)
  rect 1.397x0.787 smd: 11(-0.4,0)
ESD-1X0_6-2P
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
H-C75D75N
  round 1.905 hole 1.905 unplated: (0,0)
H-C98D98N
  round 2.489 hole 2.489 unplated: (0,0)
H-C256I186D102P2
  round 6.502 hole 2.591: 1(0,0)
H-DAVIDOFF-1
  round 5.994 hole 3.2: 1(0,0)
H-DAVIDOFF-1-1
  custom 2.15x2.15 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(0,2.921) 3(2.066,2.066) 4(2.921,0) 5(2.066,-2.066) 6(0,-2.921) 7(-2.066,-2.066) 8(-2.921,0) 9(-2.066,2.066)
H-DAVIDOFF-3
  custom 2.25x2.25 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(2.235,0) 3(1.581,1.581) 4(0,2.235) 5(-1.581,1.581) 6(-2.235,0) 7(-1.581,-1.581) 8(0,-2.235) 9(1.581,-1.581)
H-S157D157N
  rect 3.988x3.988 hole 3.988 unplated: (0,0)
H-TIC157BC276D150P2
  round 7.01 hole 3.81: 1(0,0)
HDMI-10591-19001-19P
  round 0.813 hole 0.559: 1(-4.5,6.65) 2(-4,8.2) 3(-3.5,6.65) 4(-3,8.2) 5(-2.5,6.65) 6(-2,8.2) 7(-1.5,6.65) 8(-1,8.2) 9(-0.5,6.65) 10(0,8.2) 11(0.5,6.65) 12(1,8.2) 13(1.5,6.65) 14(2,8.2) 15(2.5,6.65) 16(3,8.2) 17(3.5,6.65) 18(4,8.2) 19(4.5,6.65)
  oval 1.803x2.794 hole 0.787x1.803: 20(-9.25,0) 22(9.25,0)
  oval 1.803x3.607 hole 0.787x2.591: 21(-7.25,7.6) 23(7.25,7.6)
HG-C276D126P2
  round 7.01 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(2.235,0) 3(1.581,1.581) 4(0,2.235) 5(-1.581,1.581) 6(-2.235,0) 7(-1.581,-1.581) 8(0,-2.235) 9(1.581,-1.581)
HG-C354I158D118P2
  round 8.992 hole 2.997: 1(0,0)
  round 0.61 hole 0.356: 2(0,3.048) 3(2.155,2.155) 4(3.048,0) 5(2.155,-2.155) 6(0,-3.048) 7(-2.155,-2.155) 8(-3.048,0) 9(-2.155,2.155)
HG-C354I274D220P2
  round 8.992 hole 5.588: 1(0,0)
  round 0.61 hole 0.356: 2(0,3.683) 3(2.604,2.604) 4(3.683,0) 5(2.604,-2.604) 6(0,-3.683) 7(-2.604,-2.604) 8(-3.683,0) 9(-2.604,2.604)
HG-O335X315D252X232P2
  oval 8.509x8.001 hole 6.401x5.893: 1(0,0)
  round 0.61 hole 0.356: 2(0,3.556) 3(2.514,2.514) 4(3.683,0) 5(2.514,-2.514) 6(0,-3.556) 7(-2.514,-2.514) 8(-3.683,0) 9(-2.514,2.514)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L2_5X2-1_2
  rect 0.787x2.007 smd: 1(-1,0) 2(1,0)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L6_6X6_6-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
L6_6X6_6-3H
  rect 1.854x3.505 smd: 1(-2.775,0) 2(2.775,0)
LGA16-3X3-5
  rect 0.305x0.94 smd: 1(-1,-1.525) 2(-0.5,-1.525) 3(0,-1.525) 4(0.5,-1.525) 5(1,-1.525) 9(1,1.525) 10(0.5,1.525) 11(0,1.525) 12(-0.5,1.525) 13(-1,1.525)
  rect 0.94x0.305 smd: 6(1.525,-0.5) 7(1.525,0) 8(1.525,0.5) 14(-1.525,0.5) 15(-1.525,0) 16(-1.525,-0.5)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
NGFF-NASE0-S6701-TS40-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASM0-S6701-TSH4-KM-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
POWER-3X3-65-5P
  rect 0.508x0.406 smd: 1(1.5,-0.975) 2(1.5,-0.325) 3(1.5,0.325) 4(1.5,0.975)
  custom 0.588x0.588 smd: 5(0,0)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
PWQFN20-4X4-5-26P-0_8H
  rect 0.279x0.991 smd: 1(-1,-1.9) 2(-0.5,-1.9) 3(0,-1.9) 4(0.5,-1.9) 5(1,-1.9) 11(1,1.9) 12(0.5,1.9) 13(0,1.9) 14(-0.5,1.9) 15(-1,1.9)
  rect 0.991x0.279 smd: 6(1.9,-1) 7(1.9,-0.5) 8(1.9,0) 9(1.9,0.5) 10(1.9,1) 16(-1.9,1) 17(-1.9,0.5) 18(-1.9,0) 19(-1.9,-0.5) 20(-1.9,-1)
  rect 2.159x2.159 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.75,-0.75) 23(0.75,-0.75) 24(0.75,0.75) 25(-0.75,0.75) 26(0,0)
QFN12-3X3-45-0_6H
  rect 0.229x0.787 smd: 1(-0.619,-1.5) 6(-0.619,1.5)
  rect 0.229x1.346 smd: 2(0.101,-1.225) 3(1.001,-1.225)
  rect 0.229x2.286 smd: 4(0.551,0.76)
  rect 0.229x2.261 smd: 5(-0.169,0.76)
  rect 0.787x0.229 smd: 7(-1.5,1.125) 8(-1.5,0.675) 9(-1.5,0.225) 10(-1.5,-0.225) 11(-1.5,-0.675) 12(-1.5,-1.125)
QFN16-3X3-5-17P-TPS2546RTER
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN18-2X2-4-19P-0_4H-SMT
  custom 0.05x0.05 smd: 1(-0.8,-1.178) 5(0.8,-1.178) 6(1.178,-0.6) 9(1.178,0.6) 10(0.8,1.178) 14(-0.8,1.178) 15(-1.178,0.6) 18(-1.178,-0.6)
  rect 0.203x0.864 smd: 2(-0.4,-1.178) 3(0,-1.178) 4(0.4,-1.178) 11(0.4,1.178) 12(0,1.178) 13(-0.4,1.178)
  rect 0.864x0.203 smd: 7(1.178,-0.2) 8(1.178,0.2) 16(-1.178,0.2) 17(-1.178,-0.2)
  rect 0.889x0.889 smd: 19(0,0)
QFN18-3X3-5
  custom 0.145x0.145 smd: 1(-1.25,-1.24) 6(1.25,-1.24) 10(1.25,1.24) 15(-1.25,1.24)
  custom 0.062x0.062 smd: 2(-0.75,-1.4) 3(-0.25,-1.4) 4(0.25,-1.4) 5(0.75,-1.4) 11(0.75,1.4) 12(0.25,1.4) 13(-0.25,1.4) 14(-0.75,1.4)
  custom 0.05x0.05 smd: 7(0.58,-0.45) 8(1.349,0) 9(0.58,0.45) 16(-1.405,0.65) 17(-0.583,0) 18(-1.405,-0.65)
QFN20-4X3-5-27P
  rect 0.203x0.61 smd: 1(-1.25,-1.4) 2(-0.75,-1.4) 3(-0.25,-1.4) 4(0.25,-1.4) 5(0.75,-1.4) 6(1.25,-1.4) 11(1.25,1.4) 12(0.75,1.4) 13(0.25,1.4) 14(-0.25,1.4) 15(-0.75,1.4) 16(-1.25,1.4)
  rect 0.61x0.203 smd: 7(1.9,-0.75) 8(1.9,-0.25) 9(1.9,0.25) 10(1.9,0.75) 17(-1.9,0.75) 18(-1.9,0.25) 19(-1.9,-0.25) 20(-1.9,-0.75)
  rect 2.591x1.6 smd: 21(0,0)
  round 0.508 hole 0.254: 22(-1,-0.5) 23(0,-0.5) 24(1,-0.5) 25(1,0.5) 26(0,0.5) 27(-1,0.5)
QFN23-4X4-5-25P
  rect 0.254x0.787 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 12(1.25,2) 13(0.75,2) 14(0.25,2) 15(-0.25,2) 16(-0.75,2) 17(-1.25,2)
  rect 0.787x0.254 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.75) 11(2,1.25) 18(-2,1.25) 19(-2,0.75) 20(-2,0.25) 21(-2,-0.25) 22(-2,-0.75) 23(-2,-1.25)
  rect 2.591x1.295 smd: 24(0,-0.65)
  rect 2.591x0.889 smd: 25(0,0.85)
QFN24-4X4-5-25P-RT8813D
  custom 0.075x0.075 smd: 1(-1.25,-1.975) 6(1.25,-1.975) 7(1.975,-1.25) 12(1.975,1.25) 13(1.25,1.975) 18(-1.25,1.975) 19(-1.975,1.25) 24(-1.975,-1.25)
  rect 0.305x0.838 smd: 2(-0.75,-1.975) 3(-0.25,-1.975) 4(0.25,-1.975) 5(0.75,-1.975) 14(0.75,1.975) 15(0.25,1.975) 16(-0.25,1.975) 17(-0.75,1.975)
  rect 0.838x0.305 smd: 8(1.975,-0.75) 9(1.975,-0.25) 10(1.975,0.25) 11(1.975,0.75) 20(-1.975,0.75) 21(-1.975,0.25) 22(-1.975,-0.25) 23(-1.975,-0.75)
  rect 2.54x2.54 smd: 25(0,0)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-4X4-4-33P-RT8171B
  rect 0.203x0.94 smd: 1(-1.4,-2.125) 2(-1,-2.125) 3(-0.6,-2.125) 4(-0.2,-2.125) 5(0.2,-2.125) 6(0.6,-2.125) 7(1,-2.125) 8(1.4,-2.125) 17(1.4,2.125) 18(1,2.125) 19(0.6,2.125) 20(0.2,2.125) 21(-0.2,2.125) 22(-0.6,2.125) 23(-1,2.125) 24(-1.4,2.125)
  rect 0.94x0.203 smd: 9(2.125,-1.4) 10(2.125,-1) 11(2.125,-0.6) 12(2.125,-0.2) 13(2.125,0.2) 14(2.125,0.6) 15(2.125,1) 16(2.125,1.4) 25(-2.125,1.4) 26(-2.125,1) 27(-2.125,0.6) 28(-2.125,0.2) 29(-2.125,-0.2) 30(-2.125,-0.6) 31(-2.125,-1) 32(-2.125,-1.4)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-5X5-5-33P-0_85H
  rect 0.305x0.991 smd: 1(-1.75,-2.6) 2(-1.25,-2.6) 3(-0.75,-2.6) 4(-0.25,-2.6) 5(0.25,-2.6) 6(0.75,-2.6) 7(1.25,-2.6) 8(1.75,-2.6) 17(1.75,2.6) 18(1.25,2.6) 19(0.75,2.6) 20(0.25,2.6) 21(-0.25,2.6) 22(-0.75,2.6) 23(-1.25,2.6) 24(-1.75,2.6)
  rect 0.991x0.305 smd: 9(2.6,-1.75) 10(2.6,-1.25) 11(2.6,-0.75) 12(2.6,-0.25) 13(2.6,0.25) 14(2.6,0.75) 15(2.6,1.25) 16(2.6,1.75) 25(-2.6,1.75) 26(-2.6,1.25) 27(-2.6,0.75) 28(-2.6,0.25) 29(-2.6,-0.25) 30(-2.6,-0.75) 31(-2.6,-1.25) 32(-2.6,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN32-5X5-5-37P-0_85H
  rect 0.279x0.838 smd: 1(-1.75,-2.55) 2(-1.25,-2.55) 3(-0.75,-2.55) 4(-0.25,-2.55) 5(0.25,-2.55) 6(0.75,-2.55) 7(1.25,-2.55) 8(1.75,-2.55) 17(1.75,2.55) 18(1.25,2.55) 19(0.75,2.55) 20(0.25,2.55) 21(-0.25,2.55) 22(-0.75,2.55) 23(-1.25,2.55) 24(-1.75,2.55)
  rect 0.838x0.279 smd: 9(2.55,-1.75) 10(2.55,-1.25) 11(2.55,-0.75) 12(2.55,-0.25) 13(2.55,0.25) 14(2.55,0.75) 15(2.55,1.25) 16(2.55,1.75) 25(-2.55,1.75) 26(-2.55,1.25) 27(-2.55,0.75) 28(-2.55,0.25) 29(-2.55,-0.25) 30(-2.55,-0.75) 31(-2.55,-1.25) 32(-2.55,-1.75)
  rect 3.759x3.759 smd: 33(0,0)
  round 0.508 hole 0.254: 34(-0.6,-0.6) 35(0.6,-0.6) 36(0.6,0.6) 37(-0.6,0.6)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RJ45-2RJ1622-001111F-8P
  round 1.295 hole 0.889: 1(3.57,2.3) 2(2.55,3.4) 3(1.53,2.3) 4(0.51,3.4) 5(-0.51,2.3) 6(-1.53,3.4) 7(-2.55,2.3) 8(-3.57,3.4)
  oval 1.803x2.616 hole 0.787x1.6: 9(8.4,-7.8) 10(8.4,0) 11(-8.4,-7.8) 12(-8.4,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-5P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,-0.65)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SON10-2_5X1-5-0_55H
  rect 0.305x0.559 smd: 1(-1,-0.385) 2(-0.5,-0.385) 4(0.5,-0.385) 5(1,-0.385) 6(1,0.385) 7(0.5,0.385) 9(-0.5,0.385) 10(-1,0.385)
  rect 0.33x0.559 smd: 3(0,-0.385) 8(0,0.385)
SOT23-1_7-65-3P
  rect 0.711x0.432 smd: 1(0.85,0.65) 2(0.85,-0.65) 3(-0.85,0)
SOT23-1_38-5-3P
  rect 0.533x0.381 smd: 1(0.69,0.5) 2(0.69,-0.5) 3(-0.69,0)
SOT23-2-95-3P
  rect 0.711x0.559 smd: 1(1,0.95) 2(1,-0.95) 3(-1,0)
SOT23-2_8-95-5P-EM5213AJ
  rect 0.991x0.711 smd: 1(1.3,-0.95) 2(1.3,0) 3(1.3,0.95) 4(-1.3,0.95) 5(-1.3,-0.95)
SOT23-2_8-95-5P-LP2985-50DBVT
  rect 1.041x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,-0.95)
SOT23-2_8-95-6P-1_1H
  rect 1.092x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,0) 6(-1.35,-0.95)
SOT23-2_38-95-3P
  rect 0.787x0.533 smd: 1(1.19,0.95) 2(1.19,-0.95) 3(-1.19,0)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT353-2_1-65-5P
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SPAD-C315NP
  round 8.001 smd: 1(0,0)
SPAD-C354NP
  round 8.992 smd: 1(0,0)
SPAD-DAVIDOFF-1
  custom 1.275x1.275 smd: 1(0,0)
SPAD-RE138X197
  rect 3.505x5.004 smd: 1(0,0)
SPAD-RE209X315NP
  rect 5.309x8.001 smd: 1(0,0)
SW-NDT016-G1A-KKKT-4P
  round 1.041 hole 1.041 unplated: (0,-1.5)
  oval 0.838x0.94 hole 0.838x0.94 unplated: (0,1)
  rect 0.787x1.194 smd: 1(-2.15,-1.2) 2(-2.15,1.2) 3(2.15,-1.2) 4(2.15,1.2)
SW-T3AL-23-Q-TR-4P
  rect 0.66x0.711 smd: 1(-1.475,0.95) 2(1.475,0.95) 3(-1.475,-0.95) 4(1.475,-0.95)
SW-TME-532-V-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2050
  round 0.508 smd: 1(0,0)
TRF-N1010G-25P
  rect 0.635x1.778 smd: 1(-5.5,-4.54) 2(-4.5,-4.54) 3(-3.5,-4.54) 4(-2.5,-4.54) 5(-1.5,-4.54) 6(-0.5,-4.54) 7(0.5,-4.54) 8(1.5,-4.54) 9(2.5,-4.54) 10(3.5,-4.54) 11(4.5,-4.54) 12(5.5,-4.54) 13(5.5,4.45) 14(4.5,4.45) 15(3.5,4.45) 16(2.5,4.45) 17(1.5,4.45) 18(0.5,4.45) 19(-0.5,4.45) 20(-1.5,4.45) 21(-2.5,4.45) 22(-3.5,4.45) 23(-4.5,4.45) 24(-5.5,4.45)
  rect 0.889x0.787 smd: 25(-6.82,0)
TSOT23-6-2_8-95-6P-1H
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
UB3-USB-097-1R09HG-9P
  round 1.295 hole 0.813: 1(3.5,7.2) 2(1,7.2) 3(-1,7.2) 4(-3.5,7.2) 5(-4,5.7) 6(-2,5.7) 7(0,5.7) 8(2,5.7) 9(4,5.7)
  oval 1.295x2.896 hole 0.711x2.311: 10(6.4,6.45) 11(-6.4,6.45)
  oval 1.295x2.108 hole 0.711x1.499: 12(-7.85,0) 13(7.85,-3)
UB31-UCF3M-01N01-0P53-24P
  round 0.813 hole 0.813 unplated: (-3.45,0)
  oval 0.813x0.762 hole 0.813x0.762 unplated: (3.45,0)
  oval 0.991x1.6 hole 0.508x1.092: 5(-4.475,0.4) 6(4.475,0.4)
  oval 0.991x2.007 hole 0.508x1.499: 7(-6.075,-1.935) 8(6.075,-1.935) 9(-6.075,-5.8) 10(6.075,-5.8)
  custom 0.064x0.064 smd: A1(-2.75,-0.06) A12(2.75,-0.06)
  rect 0.254x0.61 smd: A2(-2.25,-0.06) A3(-1.75,-0.06) A4(-1.25,-0.06) A5(-0.75,-0.06) A6(-0.25,-0.06) A7(0.25,-0.06) A8(0.75,-0.06) A9(1.25,-0.06) A10(1.75,-0.06) A11(2.25,-0.06)
  oval 1.143x0.66 hole 0.889x0.406: B1(3.2,-1.135) B12(-3.2,-1.135)
  round 0.61 hole 0.457: B2(2.5,-2.035) B3(1.7,-2.035) B4(1.3,-1.135) B5(0.85,-2.035) B6(0.4,-1.135) B7(-0.4,-1.135) B8(-0.85,-2.035) B9(-1.3,-1.135) B10(-1.7,-2.035) B11(-2.5,-2.035)
unnamed#2
  round 1.016 smd: 1(0,0)
WQFN20-3X3-4-21P
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.702x1.702 smd: 21(0,0)
WTB-50278-00401-V01-4P-L
  rect 0.787x1.905 smd: 1(-1.875,4.925) 2(-0.625,4.925) 3(0.625,4.925) 4(1.875,4.925)
  rect 1.295x3.353 smd: 5(-4.725,0) 6(4.725,0)
WTB-50458-00801-V02-8P-L
  rect 0.559x1.295 smd: 1(-7,5.025) 2(-5,5.025) 3(-3,5.025) 4(-1,5.025) 5(1,5.025) 6(3,5.025) 7(5,5.025) 8(7,5.025)
  rect 1.295x2.057 smd: 9(-10.1,0) 10(10.1,0)
XTL-2_05X1_65-1_4X1_1-0_6H
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-2X1_6-1_35X1_05
  rect 0.838x0.762 smd: 1(-0.675,-0.525) 2(0.675,-0.525) 3(0.675,0.525) 4(-0.675,0.525)
XTL-3_2X1_5-2_5-SMT
  rect 0.991x1.6 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7-0_8H
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1V8_AON_S: PC35.1 PC36.1 PR35.1 PU3.8 PU3.9
1V8_MAIN_EN: PD1.1(CATHODE) PQ1.2 PR4.1 PR11.2 PR36.1 R60.1 R61.1
1V8_MAIN_EN_N17: R61.2 U22.F9
5V_HSMBCK: D5.1 R163.1
5V_HSMBDT: D5.2 R164.1
8813VID: PR20.2 PR22.2 PU2.5
8813VOUT1: PC26.1 PC27.1 PR26.1 PU2.11(VSNS)
8813VREF: PC21.1 PR140.1 PR142.2 PU2.8
+1.2V_VCCPLL_OC: L8.2 R221.1 R332.1
+1.2V_VCCPLL_OC_S2: C369.1 C376.1 C380.2 L8.1 Q14.1(S)
+1.2VSUS: C144.1 C145.2 C146.2 C171.1 C178.1 C184.1 C188.2 C191.1 C199.1 C204.1 C213.1 C214.1 C216.2 C219.2 C223.2 C224.1 C225.2 C226.2 C227.1 C228.1 C231.2 C235.1 C236.2 C238.1 C241.2 C246.1 C247.2 C251.1 C252.1 C257.1 C260.1 C261.1 C262.2 C266.2 C267.2 C268.1 C274.2 C281.1 C303.1 C320.1 C321.1 C322.2 C324.1 C330.2 C346.1 C348.1 C350.1 C354.2 C355.1 C356.1 C357.2 C361.1 C552.2 C553.2 C573.1 C574.1 C575.2 C577.1 C579.1 C581.1 C584.2 C594.1 C596.2 EC1.2 EC2.2 JDIM1.12 JDIM1.33 JDIM1.54 JDIM1.75 JDIM1.96 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 JDIM1.129 JDIM1.130 JDIM1.135 JDIM1.136 JDIM1.141 JDIM1.142 JDIM1.147 JDIM1.148 JDIM1.153 JDIM1.154 JDIM1.159 JDIM1.160 JDIM1.163 JDIM1.178 JDIM1.199 JDIM1.220 JDIM1.241 PC7.1 PC130.1 PC131.1 PC132.1 PC133.1 PC137.1 PC159.1 PC160.1 PL2.2 PQ19.5 PR6.1 PR7.1 Q14.3 R65.1 R112.2 R149.1 R201.1 R203.1 R205.2 R206.1 R207.1 R208.2 R212.1 R213.1 R214.1 R215.1 R216.1 R220.1 R278.1 R615.1 U2.A1 U2.A9 U2.B3 U2.B9 U2.C1 U2.D1 U2.D9 U2.E2 U2.E7 U2.F2 U2.F8 U2.G1 U2.G7 U2.G9 U2.J1 U2.J2 U2.J8 U2.J9 U2.L1 U2.L9 U2.R1 U2.T9 U4.A1 U4.A9 U4.B3 U4.B9 U4.C1 U4.D1 U4.D9 U4.E2 U4.E7 U4.F2 U4.F8 U4.G1 U4.G7 U4.G9 U4.J1 U4.J2 U4.J8 U4.J9 U4.L1 U4.L9 U4.R1 U4.T9 U6.A1 U6.A9 U6.B3 U6.B9 U6.C1 U6.D1 U6.D9 U6.E2 U6.E7 U6.F2 U6.F8 U6.G1 U6.G7 U6.G9 U6.J1 U6.J2 U6.J8 U6.J9 U6.L1 U6.L9 U6.R1 U6.T9 U8.A1 U8.A9 U8.B3 U8.B9 U8.C1 U8.D1 U8.D9 U8.E2 U8.E7 U8.F2 U8.F8 U8.G1 U8.G7 U8.G9 U8.J1 U8.J2 U8.J8 U8.J9 U8.L1 U8.L9 U8.R1 U8.T9 U24.AA37 U24.AA49 U24.AB36 U24.AC35 U24.AC37 U24.AD35 U24.AD36 U24.AE36 U24.AF49 U24.AG36 U24.AJ36 U24.AL36 U24.AL49 U24.AN36 U24.AP37 U24.AR36 U24.AR37 U24.AT36 U24.AT49 U24.AV36 U24.AW37 U24.AY36 U24.BA37 U24.BA49 U24.BB36 U24.BD36 U24.BE37 U24.BF36 U24.BF37 U24.BF49 U24.BG36 U24.BJ36 U24.BL37 U24.BM49 U24.BN37 U24.BP38 U24.BP39 U24.BR37 U24.BT38 U24.BU37 U24.BU49 U24.CA39 U24.CB49 U24.L38 U24.L49 U24.N36 U24.T49
+1.5V: PC107.1 PC259.1 PC260.1 PL12.2 PR272.2 Q45.2 R373.2 R690.1
+1.05V_EXT: R277.1 U24.DJ15
+1.05V_LAN: C39.1 C45.1 C58.1 C64.1 C65.1 C93.1 R4.2 U1.3 U1.8 U1.22 U1.30
+1.05V_LAN_REGOUT: C22.1 R4.1 U1.24
+1.8V: PQ10.1(S) PR238.1 R313.1 R360.2 R808.1 R818.1
+1.8V_DEEP_SUS: C339.2 C341.2 R219.2 R266.1 R269.1 R274.1 R353.1 R747.1 R748.2 R750.1 R786.1 R799.1 U12.5(VCC) U14.5(VCC) U24.DD35 U24.DF15 U24.DF17 U24.DF18 U24.DF20 U24.DF34 U24.DG17 U24.DG18 U24.DG20
+1.8V_S5: PC37.1 PC38.1 PJ3.2 PQ10.3 PU3.1 PU3.2 PU3.6 PU3.7 R274.2 R773.1 R803.1 R809.1
+1.8V_SW: C690.1 C691.1 C692.1 EC8.1 R773.2 R775.2 R781.2 R818.2 R822.2 R824.2 U34.12(VDD)
+1.35V_GFX: C15.1 C16.2 C18.2 C19.1 C20.1 C21.2 C26.2 C27.2 C47.1 C49.2 C52.2 C63.2 C69.2 C75.2 C78.2 C79.2 C80.2 C81.1 C87.2 C111.2 C118.2 C126.2 C134.2 C138.1 C151.1 C157.2 C158.2 C160.2 C163.2 C165.1 C166.2 C168.1 C172.2 C174.2 C175.2 C502.1 C518.1 C521.1 C524.1 C543.2 C544.2 C546.1 C547.1 C548.1 C563.1 C564.1 C565.2 C566.2 PJ8.1 PR39.1 R36.1 R45.1 R46.1 R59.1 R84.1 R525.2 R527.1 U22.B26 U22.C25 U22.E23 U22.E26 U22.F14 U22.F21 U22.G13 U22.G14 U22.G15 U22.G16 U22.G18 U22.G19 U22.G20 U22.G21 U22.H24 U22.H26 U22.J21 U22.K21 U22.L22 U22.L24 U22.L26 U22.M21 U22.N21 U22.R21 U22.T21 U22.V21 U22.W21 VRAM1.B1 VRAM1.B3 VRAM1.B12 VRAM1.B14 VRAM1.C5 VRAM1.C10 VRAM1.D1 VRAM1.D3 VRAM1.D11 VRAM1.D12 VRAM1.D14 VRAM1.E5 VRAM1.E10 VRAM1.F1 VRAM1.F3 VRAM1.F12 VRAM1.F14 VRAM1.G1 VRAM1.G2 VRAM1.G4 VRAM1.G11 VRAM1.G13 VRAM1.G14 VRAM1.H3 VRAM1.H12 VRAM1.K3 VRAM1.K12 VRAM1.L1 VRAM1.L2 VRAM1.L4 VRAM1.L11 VRAM1.L13 VRAM1.L14 VRAM1.M1 VRAM1.M3 VRAM1.M12 VRAM1.M14 VRAM1.N5 VRAM1.N10 VRAM1.P1 VRAM1.P3 VRAM1.P11 VRAM1.P12 VRAM1.P14 VRAM1.R5 VRAM1.R10 VRAM1.T1 VRAM1.T3 VRAM1.T12 VRAM1.T14 VRAM2.B1 VRAM2.B3 VRAM2.B12 VRAM2.B14 VRAM2.C5 VRAM2.C10 VRAM2.D1 VRAM2.D3 VRAM2.D11 VRAM2.D12 VRAM2.D14 VRAM2.E5 VRAM2.E10 VRAM2.F1 VRAM2.F3 VRAM2.F12 VRAM2.F14 VRAM2.G1 VRAM2.G2 VRAM2.G4 VRAM2.G11 VRAM2.G13 VRAM2.G14 VRAM2.H3 VRAM2.H12 VRAM2.K3 VRAM2.K12 VRAM2.L1 VRAM2.L2 VRAM2.L4 VRAM2.L11 VRAM2.L13 VRAM2.L14 VRAM2.M1 VRAM2.M3 VRAM2.M12 VRAM2.M14 VRAM2.N5 VRAM2.N10 VRAM2.P1 VRAM2.P3 VRAM2.P11 VRAM2.P12 VRAM2.P14 VRAM2.R5 VRAM2.R10 VRAM2.T1 VRAM2.T3 VRAM2.T12 VRAM2.T14
+1V8_AON: C128.1 C129.1 C143.1 C501.2 PR14.1 PR35.2 PR148.2 Q15.2 Q15.5 Q25.2 R2.2 R50.2 R56.2 R60.2 R340.2 R341.2 R479.2 R529.2 R533.2 R537.2 R538.2 R540.2 R544.2 R546.2 R548.2 R550.2 R555.2 R556.2 R557.2 R562.2 R564.2 R568.2 R569.1 U19.5(VCC) U22.G10 U22.G12
+1V8_GFX_MAIN: C34.1 C35.1 C46.1 C50.1 C89.1 C115.1 C116.1 C117.1 C514.2 C515.2 C516.2 C520.2 C523.2 L1.1 L2.1 L3.1 L4.1 L5.1 PR5.1 PR17.1 PR34.1 R17.2 U22.AA10 U22.AA12 U22.AA13 U22.AA16 U22.AA18 U22.AA19 U22.AA20 U22.AA21 U22.AB22 U22.AC23 U22.AD24 U22.AE25 U22.AF26 U22.AF27 U22.G8 U22.G9
+1V8_MAIN_EN_G: PQ1.3 PQ2.2 PR1.2 PR3.1
+1V_S5_ON: PR215.1 R674.2 U13.95
+2.5V_SUS: C140.1 C141.1 C147.2 C148.1 C149.1 C161.1 C164.1 C192.2 C193.1 C194.1 C195.1 C217.2 C220.1 C309.2 C312.1 C314.1 C358.1 C359.1 C360.2 JDIM1.257 JDIM1.259 PR127.2 U2.B1 U2.R9 U4.B1 U4.R9 U6.B1 U6.R9 U8.B1 U8.R9
+3V: C153.1 C159.1 C180.1 C181.1 C182.1 C186.2 C205.2 C210.1 C212.1 C222.1 C495.2 C542.2 C545.2 C558.1 C560.1 CN6.29 CN6.30 CN6.31 EC4.1 EC5.1 JDIM1.255 PR32.1 PR55.1 PR101.1 PR102.1 PR107.2 PR131.2 PR151.1 PR158.1 PR225.1 PR232.1 Q6.2 Q10.2 Q13.2 Q13.5 Q34.2 Q41.2 Q41.5 R3.2 R12.1 R13.2 R18.2 R21.1 R31.2 R39.1 R52.2 R55.2 R57.1 R63.1 R83.2 R96.2 R100.2 R103.2 R106.1 R107.1 R244.1 R253.1 R258.2 R261.1 R299.1 R306.1 R325.2 R327.2 R342.2 R365.2 R369.2 R371.1 R374.2 R377.2 R390.2 R391.2 R409.1 R414.2 R420.1 R431.1 R453.2 R463.2 R480.2 R488.2 R500.2 R514.2 R518.1 R605.1 R655.1 R658.2 R659.1 R660.1 R661.1 R664.1 R671.1 R673.1 R729.2 R733.2 R734.2 R737.2 R738.2 R742.2 R752.2 R756.2 R757.2 R758.2 R762.1 R765.2 R772.2 R780.1 R788.2 R791.2 R794.1 R800.2 R806.2 U3.1 U3.18(VDD#2) U3.22 U20.5 U23.4 U23.5
+3V3_TPM: C391.1 C392.1 C413.1 C432.1 R420.2 R432.2 U15.8 U15.22
+3V3_TPM_VSB: C445.2 C446.2 R452.1 R453.1 U15.1(VSB)
+3V_CCD_PWR1_C: CN2.32 CN2.33 R518.2
+3V_DEEP_SUS: C640.2 R241.2 R279.1 R283.1 R304.1 R346.1 R347.1 R356.2 R357.2 R358.1 R361.2 R367.2 R383.1 R415.1 R663.1 R677.1 R705.1 R710.2 R719.1 R721.2 R735.1 R739.1 R753.2 R760.2 R771.2 R779.2 R801.2 U24.DF26 U31.1(VOUT)
+3V_DMIC: CN1.4 R514.1
+3V_EC: C679.1 R794.2 R803.2 U13.11
+3V_LAN: C23.1 C24.2 C25.2 C29.2 C30.1 C31.1 C42.1 C51.1 Q2.3 R7.1 U1.11 U1.23(VDDREG) U1.32
+3V_LDO_EC: D13.1(CATHODE) PR68.2 R331.1 R333.2 R362.2 R399.2 R401.1 R805.2 R811.2
+3V_RTC: C722.1 D42.3(CATHODE) R37.1 R712.1 R770.2 R853.1 R854.1
+3V_RTC_0: CN19.1 R855.1
+3V_RTC_1: D42.1 R855.2
+3V_RTC_2: D42.2 R841.1 R842.2
+3V_S5: C347.1 C362.1 C603.2 C606.2 C634.1 C655.2 C682.1 CN12.1 PC85.1 PC89.1 PC257.1 PR110.1 PR211.1 PU5.3(VIN) PU14.4(VIN) Q21.2 Q21.5 Q42.2 Q43.2 R7.2 R268.2 R272.1 R276.1 R314.2 R315.2 R330.1 R344.1 R378.2 R389.2 R392.2 R397.2 R406.2 R413.1 R424.2 R429.2 R434.2 R469.2 R478.2 R573.2 R629.2 R631.2 R634.2 R639.2 R644.2 R647.2 R650.2 R652.2 R654.2 R667.2 R678.1 R688.2 R714.1 R719.2 R731.2 R763.2 R766.2 R767.2 R768.1 R769.2 R784.1 R787.1 R795.2 R797.2 R814.1 R815.1 R821.1 R826.1 R829.1 R838.1 R840.1 U9.5(VCC) U10.5(VCC) U26.5 U27.5(VCC) U29.5(VCC) U31.4 U31.5
+3V_SSD: C489.2 C490.2 C491.2 CN18.2 CN18.4 CN18.12 CN18.14 CN18.16 CN18.18 CN18.70 CN18.72 CN18.74 EC3.2 R492.1 R500.1
+3V_WLAN_P: C644.1 C645.1 C646.1 C707.1 C715.1 C716.1 C717.1 C718.1 C719.2 CN9.2 CN9.4 CN9.72 CN9.74 Q18.2 Q46.2 R738.1 R769.1 R816.1 R825.2 R828.2 R833.2
+3VLCD_CON: C549.1 C550.1 C551.1 R38.1 U23.1(VOUT)
+3VLCD_CON_R: C539.2 C540.1 CN2.34 CN2.35 CN2.36 R34.1 R38.2
+3VLCD_CON_R_C: CN2.37 R34.2
+3VPCU: C28.2 C382.2 C712.1 CN6.32 PC88.1 PC90.1 PJ2.1 PR90.2 PR98.2 PR234.1 PR264.2 PR265.2 PU7.1 PU7.2 PU7.6 PU7.7 Q2.1(S) R5.1 R23.1 R24.2 R309.2 R407.2 R422.1 R474.2 R507.1 R574.2 R580.2 R628.2 R697.2 R842.1
+3VPCU_EC: C364.1 C365.1 C386.1 C442.1 C443.1 C477.1 C478.1 L6.2 L10.1 R401.2 U13.26 U13.50 U13.92 U13.114 U13.121
+3VPCU_ECPLL: C372.1 L6.1 U13.127
+3VSPI: C370.1 C374.2 R324.1 R351.2 R358.2 R411.2 R432.1 R448.2 R452.2 U32.8 U33.8(VCC)
+5V: C106.1 C113.1 C378.1 C379.2 C454.1 C461.1 C465.1 C705.2 CN17.6 FAN1.1 HD1.2 HD1.3 HD1.4 L7.1 L14.1 PR87.2 PR256.1 Q33.3 Q47.1(S) R41.1 R370.1 R810.1 R827.1
+5V_HDMIC: C559.1 CN4.18 D5.3(COMMON ANODE) D24.2 Q33.1(VOUT)
+5V_KB: C713.2 C714.2 CN16.2 CN16.4 Q47.3
+5V_PVDD: C637.1 C641.1 C647.1 C650.1 L14.2 U30.41 U30.46
+5V_S5: C441.1 C448.1 C458.1 C459.1 C597.1 C610.1 C698.1 C704.1 C708.1 C710.1 PR2.2 PR31.1 PR40.1 PR43.2 PR66.1 PR111.1 PR143.1 PR145.1 PR155.1 PR186.2 PR207.2 PR216.2 R387.1 R447.2 R454.2 R613.1 R621.2 R624.1 R836.1 U18.5 U25.5 U28.5 U35.5 U36.2 U36.3 U36.4 U36.5(VAUX)
+5VA: C366.1 C375.2 C623.1 C627.1 L7.2 U30.26
+5VODD: C683.1 C685.1 C686.2 C687.2 C688.2 C689.2 CN15.9 CN15.10 CN15.11 CN15.12 CN15.13 CN15.14 CN15.15 R810.2
+5VPCU: C328.1 PC82.1 PC101.1 PC151.1 PJ4.1 PR37.1 PR93.2 PR260.1 PU6.1 PU6.2 PU6.6 PU6.7 PU8.1(VCC) R222.1 R225.1 R694.2 U7.1
+A3VPCU: C433.1 C434.2 L10.2 U13.74
+V3A_LX: PC229.2 PL10.1 PR258.1 PU11.2 PU11.3
+V3A_LX_R: PC247.1 PR258.2
+V3A_OUT: PC66.1 PC67.1 PC69.1 PC72.1 PC224.1 PC225.1 PC226.1 PJ2.2 PL10.2 PR236.1
+V5P5A_LX: PC116.2 PL13.1 PR114.1 PU15.2 PU15.3
+V5P5A_LX_R: PC115.1 PR114.2
+V5P5A_OUT: PC113.1 PC114.1 PC119.1 PC120.1 PC121.1 PC268.1 PC269.1 PJ4.2 PL13.2 PR277.2
+VCC1.05_OUT_FET: C582.1 C583.1 Q36.3 Q37.3 R300.2 R623.1
+VCC1.05_OUT_PCH: U24.DF29 U24.DF31 U24.DG29 U24.DG31
+VCC1.05_OUT_SFR: R626.2 U24.CD1
+VCC1.05_OUT_SFR_R: C595.1 C598.2 R626.1 U24.CD2
+VCC_V3A: PC234.1 PU11.9
+VCC_V5P5A: PC265.1 PU15.11
+VCCDPHY_1P24: C653.1 U24.DW32
+VCCDSW_1P05: C338.2 U24.DD34
+VCCFPGM: C215.2 R178.1 U24.AB34 U24.R35 U24.T34 U24.U35 U24.V34
+VCCIN: C177.1 C179.1 C185.1 C202.1 C207.1 C218.1 C221.1 C229.1 C230.1 C232.1 C233.1 C234.1 C271.1 C279.1 C286.1 C290.1 C292.1 C296.1 C298.1 C300.1 C301.1 C306.1 C307.1 C556.1 C557.1 PC50.1 PC52.1 PC54.1 PC162.1 PC163.1 PC164.1 PC165.1 PC166.1 PC201.1 PC203.1 PL7.2 PL8.2 PR159.1 PR164.1 PR182.1 U24.A19 U24.A21 U24.A23 U24.A24 U24.A27 U24.A29 U24.AA12 U24.AB1 U24.AB13 U24.AC12 U24.B19 U24.B23 U24.B27 U24.B29 U24.BN10 U24.BP9 U24.BP11 U24.BR10 U24.BT9 U24.BT11 U24.BU10 U24.BV9 U24.BV36 U24.BW9 U24.BW10 U24.BW36 U24.BY10 U24.C19 U24.C23 U24.C27 U24.C29 U24.CA9 U24.CA36 U24.CB10 U24.CC9 U24.CC11 U24.CC36 U24.CD10 U24.CE11 U24.CE34 U24.CE35 U24.CF10 U24.CF33 U24.CG11 U24.CG34 U24.CG35 U24.CH10 U24.CJ11 U24.CJ34 U24.CJ35 U24.CK10 U24.CL34 U24.CL35 U24.CN34 U24.CN35 U24.CP33 U24.CR34 U24.CR35 U24.CT33 U24.CT34 U24.CT35 U24.CU33 U24.D19 U24.D21 U24.D23 U24.D24 U24.D27 U24.D29 U24.F19 U24.F21 U24.F23 U24.F24 U24.F27 U24.F29 U24.G1 U24.G19 U24.G23 U24.G27 U24.G29 U24.H19 U24.H23 U24.H27 U24.H29 U24.J18 U24.J20 U24.J22 U24.J23 U24.J26 U24.J28 U24.J30 U24.J32 U24.K17 U24.K19 U24.K21 U24.K23 U24.K24 U24.K27 U24.K29 U24.K31 U24.M1 U24.U1 U24.V13 U24.W12 U24.Y13
+VCCIN_AUX: C237.2 C240.1 C242.2 C243.2 C244.2 C245.2 C248.2 C250.2 C253.2 C254.2 C255.2 C256.2 C263.2 C264.2 C265.2 C269.2 C273.1 C275.2 C276.1 C283.1 C284.2 C285.1 C288.2 C289.1 C291.1 C294.2 C297.2 C299.2 C302.2 C305.2 C308.2 C311.2 C313.2 C315.2 C325.2 C331.2 C335.2 C336.2 C337.2 C576.1 C602.2 PC63.1 PC64.1 PC65.1 PC176.1 PC179.1 PC208.1 PC212.1 PC218.1 PC219.1 PC231.1 PL9.2 PR241.2 U24.AH1 U24.AJ1 U24.AL1 U24.AM1 U24.AN1 U24.AT9 U24.AT11 U24.AU10 U24.AV9 U24.AW10 U24.AY9 U24.AY11 U24.BA10 U24.BB9 U24.CH1 U24.CK11 U24.CL10 U24.CM11 U24.CN1 U24.CN10 U24.CP11 U24.CR10 U24.CT11 U24.CU10 U24.CV1 U24.CV11 U24.CW10 U24.CY11 U24.DC1 U24.DC11 U24.DE12 U24.DF12 U24.P13 U24.R12 U24.T13 U24.U12
+VCCIO_OUT: R126.1 R127.1 R133.1 R134.1 R135.1 R136.1 R141.1 R147.1 R152.1 R162.1 R167.1 R169.1 R172.1 R176.1 R179.1 R180.1 R182.1 R183.1 R184.1 R185.1 U24.AD7
+VCCLDOSTD_OUT_0P85: C652.2 U24.DW37
+VCCPFUSE_3P3: R279.2 U24.DC33
+VCCPLL_OC: C316.1 C317.2 R214.2 R215.2 R221.2 U24.CG38 U24.CG41 U24.CG42 U24.CG49
+VCCPRIM_3P3: C633.2 C636.2 R710.1 U24.DF23 U24.DG26 U24.DG28
+VCCRTC: C662.2 C664.2 C665.2 R770.1 U24.DG33
+VCCST: C591.1 C592.2 PC242.1 PR200.1 PR252.2 Q12.3 R196.2 R584.2 R585.2 R588.2 R591.2 R616.2 R619.1 R620.1 R633.1 R638.1 U24.CB1
+VCCST_S2: C578.2 C580.1 C587.1 Q37.1(S) R619.2
+VCCSTG: C585.1 C586.2 C588.1 C589.2 C590.1 Q36.1(S) R611.1 R616.1 U24.BY1
+VCCSTG_OUT_FUSE: R178.2 U24.F33 U24.G33
+VCCSTG_OUT_LGC: R596.2 U24.E5
+VCCSTG_TERM: R129.2 R582.2 R594.2 R596.1 R597.2 R599.2 R607.2
+VDDQ: PR9.2 R47.1
+VDDQ_BOOT1: PC139.1 PR132.1
+VDDQ_SR: PC136.1 PR129.2
+VDDQ_VTT: C119.1 C120.1 C121.1 C122.1 C123.1 C124.1 C142.1 C150.1 C152.1 C154.1 C155.1 C156.1 C162.1 C167.1 C169.1 C170.1 C173.1 JDIM1.258(VTT) PR130.2 R66.1 R67.1 R68.1 R69.1 R70.1 R71.1 R72.1 R73.1 R74.1 R75.1 R76.1 R77.1 R78.1 R79.1 R80.1 R85.1 R87.1 R88.1 R89.1 R90.1 R91.1 R92.1 R101.1 R108.1 R109.1 R139.1
+VIN: C17.1 PC4.1 PC5.1 PC10.1 PC11.1 PC12.1 PC13.1 PC47.1 PC48.1 PC86.1 PC117.1 PC118.1 PC124.1 PC127.1 PC134.1 PC138.2 PC140.1 PC148.1 PC149.1 PC152.1 PC153.1 PC154.1 PC173.1 PC174.1 PC177.1 PC180.1 PC181.1 PC182.2 PC184.1 PC185.1 PC189.1 PC190.2 PC193.1 PC196.1 PC197.1 PC202.1 PC204.1 PC205.1 PC207.1 PC221.2 PC233.1 PC239.1 PC240.1 PC244.2 PC245.1 PC261.2 PC262.1 PC263.2 PC264.1 PC270.1 PJ10.2 PQ11.5 PQ14.3 PQ14.4 PQ14.9 PQ16.3 PQ16.4 PQ16.9 PQ20.3 PQ20.4 PQ20.9 PQ21.3 PQ21.4 PQ21.9 PQ26.5 PR1.1 PR12.2 PR16.1 PR19.1 PR64.1 PR67.1 PR168.2 PR172.1 PU1.7 PU9.8 PU9.9 PU9.22 PU9.24 PU11.5 PU15.5 R515.1
+VIN_BLIGHT: C526.1 C527.1 CN2.39 CN2.40 R515.2
+VIN_VCCIN_AUX: PC215.1 PC216.1 PC222.1 PC223.1 PC228.1 PC230.2 PC232.1 PJ10.1 PQ24.5 PR220.2
AVDD2: C619.1 L13.2 U30.40
DVDD_IO: C385.1 C661.1 R373.1 R374.1 U30.9
