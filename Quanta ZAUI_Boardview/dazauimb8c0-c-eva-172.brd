# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RT6543_EN: length 8.2
  BOTTOM w0.178: PR213.2 143.92,46.78 PR215.2 143.1,46.78 142.91,46.59 141.77,46.59 141.71,46.65 141.08,46.65 140.91,46.82 PR214.2 140.86,47.1 140.36,46.6 140.36,46.33 139.81,45.78 PC209.2 139.81,45.37 139.3,44.87 138.56,44.87 138.36,44.66 PU10.19
RT6543_FB: length 6.1
  BOTTOM w0.178: 141.1,39.08 PR229.2 ; PC217.2 140.56,39.08 140.56,39.07 PR231.1
  BOTTOM w0.203: PC217.2 141.1,39.08 141.49,38.69 141.49,38.68 141.83,38.34 PC220.1 ; PU10.6 138.76,40.55 138.91,40.4 139.66,40.4 v1(139.89,40.17) 140.11,39.94 PR231.1
RT6543_FSWSEL: length 5.7
  TOP w0.203: PR65.2 137.56,40.25 v1(137.56,39.79) 137.56,39.73 138.11,39.18 139.74,39.18 v1(139.85,39.29) 139.97,39.41 139.97,40.11 PR66.2
  BOTTOM w0.203: PU10.9 v1(137.56,39.79)
RT6543_ISN: length 2.3
  BOTTOM w0.203: PR226.2 141.51,41.84 141.1,41.84 140.4,42.54 PU10.3
RT6543_ISP: length 2.2
  BOTTOM w0.203: PR226.1 141.51,42.62 141.1,42.62 140.78,42.94 PU10.2
RT6543_LG: length 6.9
  IN3 w0.61: v4(129.61,42.86) 134.94,42.86 v4(135.25,42.54)
  BOTTOM w0.203: v4(135.25,42.54) PU10.13
RT6543_PG: length 4.1
  BOTTOM w0.203: PU10.4 140.27,42.14 141.1,41.31 142.05,41.31 142.36,41.62 PR227.2 142.36,42.47 PR225.2
RT6543_PH: length 10.7
  IN3 w0.61: v4(135.2,41.67) 134.99,41.67 134.61,42.05 129.08,42.05 v4(127.95,43.18)
  BOTTOM w0.203: v4(135.2,41.67) 135.68,42.14 PU10.12
  BOTTOM w0.305: PC214.1 134.58,40.72 135.1,41.23 135.1,41.56 v4(135.2,41.67)
RT6543_RGND: length 28.8
  IN2 w0.089: v1(115.99,36.31) 115.88,36.41 115.88,36.54 116,36.65 117.39,36.65 117.87,37.13 118.12,37.13 118.49,37.5 118.49,37.75 120.49,39.75 136.24,39.75 137.16,40.66 138.49,40.66 138.77,40.38 138.77,39.97 v1(138.59,39.79)
  BOTTOM w0.203: PU10.7 138.36,40.3 138.59,40.06 v1(138.59,39.79) ; v1(115.99,36.31) 115.42,35.74 PR242.1 115.97,35.5 PR240.1
RT6543_UG: length 8.1
  IN3 w0.61: v4(128.37,41.54) 128.68,41.24 134.12,41.24 134.55,40.8 135.62,40.8 v4(136,41.18)
RT6543_VCC:
  vias: v1(135.99,44.03)
RT6543_VID0: length 2
  BOTTOM w0.178: PR222.2 138.41,45.74 138.41,45.14 137.96,44.69 PU10.18
RT6543_VID1: length 2
  BOTTOM w0.178: PR221.2 138.03,45.21 137.56,44.74 PU10.17
RT6543_VOUT: length 3.2
  BOTTOM w0.203: PR233.2 138.06,38.3 137.86,38.51 137.86,39.36 138.04,39.54 138.04,40.17 137.96,40.25 PU10.8
RT6543_VSYS: length 6.3
  BOTTOM w0.203: PU10.20 v1(140,44.14) 141.23,44.14 PC211.2 141.49,44.54 141.49,45.29 142.16,45.96 PR220.1
  BOTTOM w0.305: PR223.1 143.47,45.96 PR220.1
RTC_RST#: length 114.1
  TOP w0.102: Q28.3 14.74,7.46 14.74,6.77 14.64,6.67 13.7,6.67 13.07,6.03 12.3,6.03 12.23,6.11 v1(11.85,6.11)
  IN1 w0.089: v1(38.29,5.55) 38.39,5.55 41.59,8.75 43.73,8.75 48.97,13.99 53.54,13.99 54.29,14.74 54.29,16.92 52.85,18.35 51.95,18.35 50.73,19.57 50.73,22.64 v2(50.51,22.87)
  IN2 w0.089: v1(38.29,5.55) 38.16,5.42 32.62,5.42 32.45,5.6 29.27,5.6 28.15,4.48 24.83,4.48 24.55,4.76 22.69,4.76 21.35,6.11 19.85,6.11 18.25,4.51 15.48,4.51 14.77,3.8 13.9,3.8 12.84,4.86 11.67,4.86 11.47,5.07 11.47,5.73 v1(11.85,6.11)
  BOTTOM w0.079: U24.DT47 75.15,34.34 74.77,34.34 74.52,34.09 74.24,34.09 73.66,33.51 73.44,33.51
  BOTTOM w0.102: v1(11.85,6.11) 11.97,6.23 11.97,8.44 12.37,8.84 J1.1 12.48,10.02 12.76,9.74 14.26,9.74 14.38,9.86 C721.1 R854.2 ; v2(50.51,22.87) 50.48,22.9 50.48,26.91 50.94,27.37 52.06,27.37 52.67,26.76 52.67,25.79 52.54,25.67 52.54,24.54 53.4,23.68 55.75,23.68 55.85,23.79 55.85,23.96 56.76,24.88 57.8,24.88 58.08,25.16 59.83,25.16 60.95,24.04 61.25,24.04 62.22,25.01 63.51,25.01 v1(64.04,24.47) 64.58,23.94 66.76,23.94 68.69,25.87 68.69,28.89 70.65,30.85 71.99,30.85 73.26,32.12 73.26,33.34 73.44,33.51
RTC_X1: length 7.9
  BOTTOM w0.102: R689.1 67.39,36.57 72.95,36.57 73.27,36.89 73.98,36.89 74.18,37.09 74.6,37.09 74.87,36.82 U24.DL48
RTC_X1_R: length 4.3
  BOTTOM w0.102: R689.2 66.96,37.04 66.91,36.99 66.91,36.1 66.73,35.92 R693.1 66.41,36.23 66.48,36.31 C626.2 65.93,36.68 65.82,36.8 Y3.1
RTC_X2: length 7.3
  BOTTOM w0.102: U24.DL49 74.2,36.7 73.35,36.7 72.96,36.31 70.42,36.31 70.14,36.03 v1(68.75,36.03) R692.1
RTC_X2_R: length 2.5
  BOTTOM w0.102: R696.1 R693.2 66.56,35.47 C632.2 67.37,34.92 R692.2
S5_ON: length 227.2
  TOP w0.102: U13.100 196.05,30.93 195.74,31.23 195.74,33.06 195.26,33.54 v2(195.26,33.9) ; v2(149.29,18.76) 149.16,18.88 149.16,20.11 148.24,21.03 147.8,21.03 147.46,21.37 147.46,22.16 148.89,23.59 148.89,24.64 148.65,24.88 148.65,26.07 148.73,26.15 148.73,26.83 148.35,27.21 v2(148.35,28.84) 148.25,28.94 v1(148.25,31.26) 148.25,33.57 147.8,34.02 147.52,34.02 147.36,34.19 v2(147.28,34.19) ; v2(180.99,30.62) 180.63,30.62 180.35,30.9 R333.1 ; PR94.2 37.81,27.29 38.13,26.96 v1(38.22,26.96) ; PR100.1 28.33,26.63 28.71,27.02 v1(28.71,27.06)
  IN2 w0.089: v2(149.29,18.76) 148.86,19.18 146.37,19.18 146.14,18.96 137.44,18.96 137.1,19.29 126.57,19.29 126.35,19.07 124.4,19.07 123.78,19.7 122.13,19.7 120.33,17.9 113.79,17.9 113.33,18.36 112.9,18.36 112.76,18.22 112.76,17.81 112.15,17.21 111.46,17.21 111.03,17.64 109.28,17.64 107.81,16.17 102.26,16.17 101.37,17.05 92.95,17.05 90.85,14.96 90.85,13.73 88.08,10.96 84.59,10.96 84.36,11.19 84.06,11.19 81.65,13.6 81.65,14.82 80.15,16.32 74.11,16.32 73.35,15.56 70.82,15.56 70.77,15.51 64.07,15.51 60.54,19.04 58.15,19.04 57.29,19.9 55.3,19.9 54.04,18.64 48.67,18.64 46.25,21.06 46.25,22.21 45.77,22.69 40.85,22.69 40.19,23.35 40.19,24.99 v1(38.22,26.96) 36.95,25.7 29.88,25.7 28.71,26.86 v1(28.71,27.06)
  IN3 w0.089: v2(147.28,34.19) 147.38,34.19 148.06,33.51 154.62,33.51 155.82,32.31 158.23,32.31 159.1,31.45 167.76,31.45 168.12,31.81 175.07,31.81 176,30.88 180.07,30.88 180.33,30.62 v2(180.99,30.62) 182.64,30.62 183.5,31.48 183.93,31.48 184.46,32.02 186.9,32.02 188,33.11 189.04,33.11 189.18,33.25 189.73,33.25 190.23,32.75 192.21,32.75 193.61,31.36 194.88,31.36 195.6,32.08 195.6,33.39 195.26,33.73 v2(195.26,33.9)
  BOTTOM w0.102: v2(148.35,28.84) 148.78,28.41 153.43,28.41 154.11,29.09 PR257.2
SATA_LED#: length 9.1
  BOTTOM w0.079: U24.DU16 90.27,33.82 89.96,33.5 89.96,33.05 89.85,32.75 89.85,32.47 89.81,32.42 89.81,32.31
  BOTTOM w0.102: 89.81,32.31 89.81,31.13 89.59,30.91 88.72,30.91 88,30.19 88,29.92 87.82,29.74 87.82,28.48 88.09,28.22 88.09,27.15 88.33,26.91 TP91.1
SATA_RXN0_C: length 12
  TOP w0.102: C473.2 210.88,11.47 v1(210.81,11.39) ; R426.2 210.3,20.68 v1(210.3,21.09)
  IN1 w0.089: v1(210.3,21.09) 209.82,20.61 209.82,20.03 209.99,19.86 209.99,17.86 209.43,17.3 209.43,15.44 210.39,14.48 210.39,11.48 210.48,11.39 v1(210.81,11.39)
SATA_RXN0_CN: length 8.8
  TOP w0.102: v1(210.5,10.27) 210.35,10.42 210.35,12.02 210.23,12.14 210.23,12.26 210.31,12.33 C469.1
  BOTTOM w0.102: v1(210.5,10.27) 210.48,10.27 210.21,10.54 210.21,10.82 210.34,10.95 210.34,11.89 210.67,12.22 212.06,12.22 212.57,12.72 212.89,12.72 213.22,13.05 213.33,13.05 213.57,12.82 HD1.8
SATA_RXN0_HDD: length 142.3
  TOP w0.102: C429.2 209.74,20.15 209.69,20.2 209.69,20.33 209.85,20.48 209.85,21.95 210.25,22.35 v1(210.42,22.35)
  IN1 w0.089: v1(210.42,22.35) 210.42,22.54 209.79,23.18 209.13,23.18 208.22,24.08 207.26,24.08 206.72,24.62 205.42,24.62 205.24,24.8 204.62,24.8 203.87,25.54 203.1,25.54 202.09,26.55 199.59,26.55 199.21,26.93 198.02,26.93 197.34,27.6 197.34,27.83 196.73,28.44 196.73,28.92 196.26,29.4 196.07,29.4 193.1,32.37 191.93,32.37 191.22,33.08 190.06,33.08 189.88,33.26 188.13,33.26 186.84,31.96 182.25,31.96 182.03,31.74 179.83,31.74 179.51,31.43 175.24,31.43 174.27,30.47 164.64,30.47 164.08,31.02 163.64,31.02 163.46,31.2 159.48,31.2 158.98,31.71 156.36,31.71 156.03,32.04 145.71,32.04 144.85,32.91 144.85,33.84 144.28,34.4 143.62,34.4 143.57,34.35 136.28,34.35 136.1,34.53 134.17,34.53 133.92,34.78 127.16,34.78 126.15,33.77 119.34,33.77 117.87,32.29 111.96,32.29 109.87,34.38 109.44,34.38 109.37,34.45 106.97,34.45 106.7,34.72 103.2,34.72 102.9,35.03 102.11,35.03 100.65,36.49 100.65,36.79 99.83,37.6 99.83,39.53 99.48,39.89 97.76,39.89 97.19,40.46 97.19,42.25 96.18,43.27 96.18,43.57 96.33,43.72 96.33,45.2 95.95,45.58 95.44,45.58 95.25,45.39 94.26,45.39 94.02,45.63 94.02,46.19 93.74,46.47 93.74,47.59 93.94,47.79 94.37,47.79 94.42,47.74 v2(94.42,47.48)
  BOTTOM w0.102: U24.CK7 94.42,47.37 v2(94.42,47.48)
SATA_RXN0_IN: length 2.1
  TOP w0.102: U17.4 210.38,18.76 210.1,19.04 210.1,19.19 209.88,19.4 209.88,19.61 209.97,19.7 C429.1
SATA_RXN1A_C: length 3.7
  BOTTOM w0.102: C697.1 134.23,20.43 134.23,19.13 134.71,18.66 134.71,18.26 134.85,18.12 CN15.5
SATA_RXN1A_ODD: length 113
  IN1 w0.089: v2(158.2,33.23) 157.96,33.48 157.96,33.86 157.67,34.15 156.88,34.15 156.45,33.72 147.21,33.72 146.87,34.06 146.87,34.33 145.15,36.05 144.07,36.05 143.06,37.07 142.81,37.07 142.39,37.49 142.39,37.73 141.73,38.39 137.44,38.39 136.6,37.55 127.65,37.55 125.49,35.39 118.35,35.39 117.03,34.07 114.34,34.07 113.38,35.04 111.67,35.04 110.37,36.33 109.85,36.33 108.48,37.71 107.45,37.71 106.4,36.66 103.06,36.66 101.94,37.78 101.94,40.07 101.38,40.63 101.38,42.23 101.18,42.43 101.18,44.01 100.7,44.49 98.6,44.49 98.16,44.93 98.16,46.21 96.38,47.99 95.45,47.99 95.36,48.08 95.36,48.24 v2(95.58,48.45)
  BOTTOM w0.102: v2(158.2,33.23) 158.02,33.06 158.02,30.09 157.48,29.54 157.48,26.47 156.59,25.58 154.91,25.58 154.24,24.9 154.24,23.91 153.3,22.97 144.71,22.97 144.41,23.28 136.97,23.28 136.1,22.41 134.61,22.41 134.24,22.05 134.24,21.74 134.39,21.58 C697.2 ; U24.CJ6 95.58,48.18 v2(95.58,48.45)
SATA_RXN_OUT: length 2.2
  TOP w0.102: U17.12 210.38,13.84 210.32,13.78 210.32,12.9 210.44,12.78 C469.2
SATA_RXP0_C: length 12.1
  TOP w0.102: C472.2 209.61,11.47 v1(209.69,11.39) ; R425.2 209.1,21.03 v1(209.17,21.09)
  IN1 w0.089: v1(209.69,11.39) 210.09,11.39 210.18,11.48 210.18,14.4 209.23,15.35 209.23,17.39 209.79,17.94 209.79,19.77 209.61,19.95 209.61,20.66 209.19,21.09 v1(209.17,21.09)
SATA_RXP0_CN: length 8.8
  TOP w0.102: C468.1 209.94,12.33 210.02,12.25 210.02,12.05 210.14,11.93 210.14,10.55 v1(209.87,10.27)
  BOTTOM w0.102: v1(209.87,10.27) 209.99,10.4 209.99,10.91 210.12,11.04 210.12,11.98 210.58,12.43 211.97,12.43 212.48,12.94 212.8,12.94 213.13,13.27 213.47,13.27 213.52,13.32 HD1.7
SATA_RXP0_HDD: length 142.5
  TOP w0.102: v1(209.82,22.57) 209.82,22.22 209.63,22.04 209.63,20.57 209.47,20.41 209.47,20.29 209.33,20.15 R425.1
  IN1 w0.089: v1(209.82,22.57) 209.82,22.86 209.71,22.97 209.05,22.97 208.14,23.88 207.17,23.88 206.63,24.42 205.34,24.42 205.16,24.6 204.53,24.6 203.79,25.34 203.02,25.34 202.01,26.35 199.5,26.35 199.13,26.73 197.93,26.73 197.14,27.52 197.14,27.75 196.53,28.36 196.53,28.84 196.18,29.2 195.99,29.2 193.02,32.17 191.85,32.17 191.14,32.88 189.98,32.88 189.8,33.06 188.22,33.06 186.92,31.76 182.33,31.76 182.11,31.54 179.91,31.54 179.6,31.23 175.32,31.23 174.36,30.26 164.55,30.26 163.99,30.82 163.55,30.82 163.38,31 159.4,31 158.89,31.51 156.27,31.51 155.94,31.84 145.63,31.84 144.64,32.82 144.64,33.75 144.2,34.2 143.71,34.2 143.66,34.15 136.2,34.15 136.02,34.33 134.09,34.33 133.84,34.58 127.25,34.58 126.23,33.56 119.42,33.56 117.95,32.09 111.87,32.09 109.79,34.17 109.36,34.17 109.28,34.25 106.89,34.25 106.62,34.52 103.12,34.52 102.81,34.82 102.03,34.82 100.44,36.41 100.44,36.71 99.63,37.52 99.63,39.45 99.39,39.69 97.67,39.69 96.99,40.37 96.99,42.17 95.97,43.18 95.97,43.66 96.12,43.81 96.12,45.11 95.86,45.38 95.52,45.38 95.33,45.19 94.17,45.19 93.81,45.55 93.81,46.1 93.53,46.38 93.53,47.67 93.86,47.99 94.57,47.99 v2(95.06,47.5)
  BOTTOM w0.102: v2(95.06,47.5) 95.38,47.18 U24.CK6
SATA_RXP0_IN: length 2
  TOP w0.102: C428.1 209.53,19.7 209.66,19.57 209.66,19.31 209.88,19.1 U17.5
SATA_RXP1A_C: length 3.7
  BOTTOM w0.102: CN15.6 134.35,18.12 134.49,18.26 134.49,18.57 134.02,19.04 134.02,20.43 C696.1
SATA_RXP1A_ODD: length 113
  IN1 w0.089: v2(94.97,48.45) 95.16,48.26 95.16,47.99 95.36,47.79 96.29,47.79 97.95,46.13 97.95,44.84 98.51,44.28 100.62,44.28 100.98,43.93 100.98,42.35 101.18,42.14 101.18,40.54 101.74,39.98 101.74,37.7 102.97,36.46 106.49,36.46 107.53,37.5 108.39,37.5 109.76,36.13 110.29,36.13 111.59,34.83 113.3,34.83 114.26,33.87 117.11,33.87 118.43,35.19 125.57,35.19 127.73,37.35 136.69,37.35 137.53,38.19 141.64,38.19 142.19,37.64 142.19,37.41 142.73,36.87 142.97,36.87 143.99,35.85 145.06,35.85 146.67,34.24 146.67,33.97 147.13,33.51 156.53,33.51 156.97,33.95 157.58,33.95 157.76,33.77 157.76,33.37 v2(157.62,33.23)
  BOTTOM w0.102: C696.2 133.88,21.58 134.02,21.73 134.02,22.14 134.52,22.63 136.01,22.63 136.88,23.49 144.5,23.49 144.8,23.19 153.21,23.19 154.02,24 154.02,24.99 154.82,25.79 156.5,25.79 157.26,26.56 157.26,29.63 157.81,30.18 157.81,33.04 v2(157.62,33.23) ; v2(94.97,48.45) 94.97,48.22 U24.CJ7
SATA_RXP_OUT: length 2.2
  TOP w0.102: U17.11 209.88,13.81 210.11,13.59 210.11,12.91 209.98,12.78 C468.2
SATA_TXN0_C: length 11.7
  TOP w0.102: v1(211.64,11.39) 211.77,11.52 C474.2 ; R427.2 211.14,21.02 v1(211.06,21.09)
  IN1 w0.089: v1(211.64,11.39) 212.22,11.96 212.22,13.38 211.9,13.7 211.9,15.1 212.13,15.33 212.13,18.17 211.52,18.78 211.52,20.64 v1(211.06,21.09)
SATA_TXN0_CN: length 6.3
  TOP w0.102: v1(211.9,10.2) 212.19,10.49 212.19,12.18 212.04,12.33 C470.1
  BOTTOM w0.102: HD1.10 213.57,11.82 213.55,11.8 213.42,11.8 213.17,12.05 212.53,12.05 212.17,11.69 212.17,10.47 v1(211.9,10.2)
SATA_TXN0_HDD: length 159.6
  TOP w0.102: v1(211.19,22.34) 211.29,22.34 211.56,22.08 211.56,20.77 211.87,20.46 211.87,20.23 211.79,20.15 R427.1
  IN3 w0.089: v1(104.33,34.1) 104.58,34.35 104.58,34.55 104.42,34.71 103.49,34.71 103.06,34.28 103.06,31.94 103.57,31.42 103.57,28.6 105.73,26.44 105.73,22.54 112.01,16.27 113.51,16.27 113.89,15.89 117.62,15.89 118.34,15.17 182.13,15.17 184.98,12.32 184.98,12.2 185.64,11.54 186.65,11.54 187.03,11.92 187.03,12.51 187.89,13.37 189.11,13.37 189.98,12.51 189.98,12.23 190.62,11.59 191.85,11.59 192.13,11.31 203.69,11.31 204.48,12.1 205.95,12.1 206.48,12.64 206.73,12.64 207.25,13.15 207.73,13.15 209.35,14.77 211.46,14.77 212.11,15.42 212.11,17.67 211.49,18.29 211.49,22.24 211.39,22.34 v1(211.19,22.34)
  BOTTOM w0.079: 101.92,43.24 101.9,43.24 101.87,43.27 101.46,43.27 100.74,42.54 98.75,42.54 98.68,42.47 97.76,42.47 97.47,42.76 U24.CW2
  BOTTOM w0.102: 101.92,43.24 105.5,43.24 106.4,42.34 106.4,36.59 106.04,36.23 106.04,35.66 105.75,35.37 105.6,35.37 v1(104.33,34.1)
SATA_TXN0_IN: length 2.1
  TOP w0.102: U17.2 211.38,18.77 211.52,18.92 211.52,19.19 211.72,19.38 211.72,19.59 211.62,19.7 C430.1
SATA_TXN1A_C: length 4.4
  BOTTOM w0.102: C694.1 136.73,20.56 136.73,20.47 137.23,19.96 137.23,19.28 136.7,18.74 136.37,18.74 136.21,18.58 136.21,18.09 136.35,17.95 CN15.2
SATA_TXN1A_ODD: length 85.8
  IN3 w0.089: v1(104.81,32.57) 104.63,32.4 104.63,32.02 104.37,31.76 104.37,29.92 105.98,28.32 105.98,27.34 106.53,26.79 106.53,22.88 112.34,17.08 120.57,17.08 121.66,15.99 140.35,15.99 140.86,16.5 140.86,16.63 v2(140.68,16.82)
  BOTTOM w0.079: U24.CW5 96.42,43.07 96.95,43.07 97.25,43.19 97.51,43.19 97.64,43.16 97.82,43.16 97.96,43.19 98.17,43.19 98.54,43.04 100.48,43.04 101.24,43.8 101.24,43.84 101.26,43.85
  BOTTOM w0.102: v2(140.68,16.82) 140.83,16.97 140.83,17.49 142.58,19.24 142.58,20.91 140.88,22.62 137.3,22.62 136.64,21.96 136.64,21.8 136.73,21.71 C694.2 ; 101.26,43.85 101.7,44.3 105.92,44.3 107.44,42.77 107.44,36.12 107.08,35.76 107.08,34.59 105.79,33.3 104.81,33.3 104.61,33.09 104.61,32.68 104.71,32.57 v1(104.81,32.57)
SATA_TXN_OUT: length 2.6
  TOP w0.102: C470.2 212.12,12.78 212.28,12.94 212.28,13.14 212.06,13.36 211.77,13.36 211.55,13.59 211.55,13.8 211.38,13.96 U17.14
SATA_TXP0_C: length 11.7
  TOP w0.102: C475.2 213.04,11.54 v1(212.89,11.39) ; R428.2 212.51,20.76 v1(212.2,21.07)
  IN1 w0.089: v1(212.89,11.39) 212.42,11.86 212.42,13.47 212.1,13.79 212.1,15.01 212.33,15.24 212.33,18.26 211.72,18.87 211.72,20.59 v1(212.2,21.07)
SATA_TXP0_CN: length 6.3
  TOP w0.102: v1(212.66,10.17) 212.41,10.43 212.41,12.18 212.56,12.33 C471.1
  BOTTOM w0.102: v1(212.66,10.17) 212.39,10.45 212.39,11.6 212.62,11.84 213.08,11.84 213.37,11.54 213.42,11.54 213.64,11.32 HD1.11
SATA_TXP0_HDD: length 159.7
  TOP w0.102: v1(211.9,22.34) 211.77,22.21 211.77,20.86 212.09,20.55 212.09,20.32 212.26,20.15 R428.1
  IN3 w0.089: v1(211.9,22.34) 211.69,22.13 211.69,18.38 212.31,17.76 212.31,15.34 211.54,14.57 209.44,14.57 207.82,12.94 207.33,12.94 206.82,12.43 206.56,12.43 206.03,11.9 204.57,11.9 203.78,11.11 192.04,11.11 191.76,11.39 190.53,11.39 189.77,12.15 189.77,12.42 189.03,13.17 187.97,13.17 187.23,12.43 187.23,11.83 186.73,11.34 185.56,11.34 184.78,12.12 184.78,12.23 182.04,14.97 118.25,14.97 117.54,15.68 113.81,15.68 113.43,16.06 111.92,16.06 105.53,22.46 105.53,26.36 103.37,28.52 103.37,31.34 102.86,31.85 102.86,34.36 103.41,34.91 104.51,34.91 104.79,34.63 104.79,34.28 v1(104.96,34.1)
  BOTTOM w0.079: U24.CW1 98.18,42.63 98.61,42.63 98.69,42.71 100.67,42.71 101.4,43.43 101.87,43.43 101.9,43.46 101.92,43.46
  BOTTOM w0.102: v1(104.96,34.1) 104.96,34.43 105.69,35.15 105.84,35.15 106.26,35.57 106.26,36.14 106.61,36.5 106.61,42.43 105.59,43.46 101.92,43.46
SATA_TXP0_IN: length 2.1
  TOP w0.102: U17.1 211.88,18.8 211.74,18.94 211.74,19.1 211.94,19.29 211.94,19.57 212.06,19.7 C431.1
SATA_TXP1A_C: length 4.5
  BOTTOM w0.102: CN15.3 135.85,17.92 135.99,18.06 135.99,18.67 136.28,18.96 136.61,18.96 137.02,19.37 137.02,19.87 136.51,20.38 136.51,20.55 C693.1
SATA_TXP1A_ODD: length 85.9
  IN3 w0.089: v2(141.29,16.82) 141.07,16.6 141.07,16.42 140.43,15.78 121.58,15.78 120.48,16.88 112.25,16.88 106.33,22.8 106.33,26.7 105.78,27.26 105.78,28.23 104.17,29.84 104.17,31.84 104.43,32.1 104.43,32.32 v1(104.18,32.57)
  BOTTOM w0.079: U24.CW3 96.85,42.85 97.28,43.02 97.49,43.02 97.61,42.99 97.84,42.99 97.98,43.03 98.14,43.03 98.5,42.87 100.55,42.87 101.36,43.68 101.39,43.68 101.41,43.7
  BOTTOM w0.102: C693.2 136.27,21.71 136.42,21.87 136.42,22.05 137.21,22.83 140.97,22.83 142.8,21 142.8,19.15 141.04,17.4 141.04,17.06 v2(141.29,16.82) ; v1(104.18,32.57) 104.39,32.79 104.39,33.18 104.72,33.51 105.7,33.51 106.87,34.68 106.87,35.85 107.22,36.21 107.22,42.68 105.83,44.08 101.79,44.08 101.41,43.7
SATA_TXP_OUT: length 2.6
  TOP w0.102: C471.2 212.69,12.78 212.49,12.98 212.49,13.23 212.15,13.58 211.86,13.58 211.76,13.68 211.76,13.82 211.88,13.94 U17.15
SATAGP0: length 5
  BOTTOM w0.079: 93.23,30.9 93.23,30.26 94.03,29.46 94.03,29.2 ; 92.77,31.36 92.77,31.38 92.47,31.68 92.47,32.19 92.27,32.39 92.27,32.93 U24.DW12
  BOTTOM w0.102: R741.1 94.03,29.2 ; 93.23,30.9 92.77,31.36
SATAGP1: length 1.1
  TOP w0.102: v2(77.81,45.43) 78.15,45.09 R250.1
  BOTTOM w0.102: U24.CR42 78,45.24 v2(77.81,45.43)
SD3_RCOMP: length 3.7
  TOP w0.254: v2(80.08,48.33) 80.08,48.56 R226.1
  BOTTOM w0.203: U24.CJ43 77.4,47.73 77.98,48.31 80.01,48.31 80.05,48.26 80.06,48.26 80.08,48.29 v2(80.08,48.33)
SDVO_CLK: length 173.4
  TOP w0.102: R195.1 25.97,63.23 27.19,64.45 27.19,65.51 25.25,67.45 24.8,67.45 24.68,67.57 24.68,67.68 24.67,67.68 24.67,67.69 v1(24.66,67.7) ; U3.7 20.02,81.7 19.37,82.36 v1(19.37,82.69) 19.24,82.69 18.73,83.2 R106.2
  IN1 w0.089: v1(24.66,67.7) 24.55,67.82 24.55,72.03 23.31,73.27 23.31,74.46 22.87,74.9 22.87,79.93 21.17,81.63 20.4,81.63 19.37,82.66 v1(19.37,82.69) 19.79,83.11 19.79,86.38 22.12,88.71 24.65,88.71 25,89.06 25,94.02 26.02,95.03 27.29,95.03 27.69,95.43 27.69,97.77 28.47,98.55 29.51,98.55 31.34,96.72 44.93,96.72 45.26,96.39 49.39,96.39 51.03,98.03 51.7,98.03 52.76,99.08 56.33,99.08 56.84,98.57 56.84,97.86 57.01,97.69 61.63,97.69 62.04,98.09 66.22,98.09 66.66,97.66 77.99,97.66 79.04,96.61 80.05,96.61 82.03,94.63 v1(82.03,94.14)
  IN2 w0.089: v1(82.03,94.14) 82.03,93.32 80.94,92.23 80.94,87.05 81.96,86.03 81.96,81.79 82.37,81.38 83.46,81.38 84.14,80.71 84.14,76.39 85.41,75.12 85.41,65.29 85.74,64.96 85.74,57.42 85.3,56.98 85.3,54.9 84.78,54.38 84.78,45.74 83.91,44.87 82.92,44.87 82.38,44.33 82.38,42.43 82.08,42.12 80.35,42.12 79.13,40.91 79.13,40.68 78.5,40.04 78.5,39.18 79.11,38.56 79.11,37.44 v2(79.49,37.07)
  BOTTOM w0.102: v2(79.49,37.07) 79.32,37.07 U24.DL40
SDVO_DATA: length 171.6
  TOP w0.102: v1(24.66,67.03) 25.09,67.03 26.78,65.34 26.78,64.62 26.28,64.11 R194.1 ; U3.6 20.52,82.01 20,82.53 v1(20,82.66) 19.75,82.92 R107.2
  IN1 w0.089: v1(81.39,94.14) 81.39,94.71 79.92,96.18 78.91,96.18 77.83,97.26 66.49,97.26 66.06,97.7 62.2,97.7 61.79,97.29 56.85,97.29 56.45,97.69 56.45,98.41 56.17,98.69 52.92,98.69 51.87,97.64 51.19,97.64 49.55,96 44.97,96 44.64,96.33 31.18,96.33 29.35,98.16 28.64,98.16 28.08,97.6 28.08,95.19 27.53,94.64 26.18,94.64 25.4,93.85 25.4,88.9 24.8,88.3 22.27,88.3 20.19,86.22 20.19,82.85 v1(20,82.66) 20,82.59 20.56,82.03 21.33,82.03 23.29,80.07 23.29,75.04 23.7,74.63 23.7,73.43 24.95,72.18 24.95,68.23 25.07,68.11 25.07,67.44 v1(24.66,67.03)
  IN2 w0.089: v1(81.39,94.14) 81.41,94.13 81.41,93.26 80.53,92.38 80.53,86.9 81.57,85.86 81.57,81.62 82.21,80.99 83.3,80.99 83.74,80.54 83.74,76.22 85.01,74.95 85.01,64.9 85.33,64.58 85.33,57.73 84.9,57.3 84.9,55.05 84.39,54.55 84.39,45.91 83.75,45.27 82.76,45.27 81.99,44.5 81.99,42.59 81.72,42.33 80.28,42.33 78.93,40.98 78.93,40.78 78.27,40.12 78.27,39.1 78.92,38.45 78.92,36.05 v2(78.6,35.74)
  BOTTOM w0.102: v2(78.6,35.74) 78.37,35.74 U24.DP42
SEL: length 4.5
  BOTTOM w0.102: U34.6 18.7,20.77 18.81,20.66 v1(19.47,20.66) 19.47,20.23 19.36,20.12 R813.2 19.36,19.43 19.49,19.29 20.05,19.29 R823.2 R822.1
SENSEA: length 4
  TOP w0.381: v1(200.21,30.03) R360.1
  BOTTOM w0.203: U30.13 200.6,30.43 v1(200.21,30.03)
  BOTTOM w0.381: R734.1 200.7,29.55 v1(200.21,30.03) 200.01,30.24 200.01,30.53 R715.1
SERIRQ: length 3.8
  TOP w0.102: TP42.1 179.82,26.5 182.31,26.5 182.38,26.58 U13.5
SET1_1: length 0.5
  BOTTOM w0.178: PR209.1 PR208.2
SET1_2: length 1
  BOTTOM w0.178: PR196.1 141.09,51.65 140.96,51.77 PR189.2
SET2_1: length 0.5
  BOTTOM w0.178: PR202.1 PR201.2
SET2_2: length 0.5
  BOTTOM w0.178: PR193.1 PR198.1
SET3_1: length 0.5
  BOTTOM w0.178: PR199.2 PR194.1
SET3_2: length 0.5
  BOTTOM w0.178: PR192.1 PR197.2
SIO_EXT_SCI#: length 114.3
  TOP w0.102: v2(188.12,22.97) 188.12,21.71 186.18,19.77 184.31,19.77 183.92,19.38 U13.23
  IN2 w0.089: v2(91.96,22.72) 94.47,22.72 95.31,21.88 111.61,21.88 112.68,22.95 114.77,22.95 116.11,24.29 118.68,24.29 118.94,24.56 121.41,24.56 121.72,24.87 122.12,24.87 122.72,24.27 126.41,24.27 127.44,25.3 134.59,25.3 134.77,25.47 137.44,25.47 137.87,25.04 142,25.04 143.75,23.3 154.98,23.3 155.37,23.68 157.33,23.68 157.44,23.57 160.21,23.57 160.22,23.58 164.83,23.58 165.64,22.77 167.43,22.77 167.47,22.73 169.92,22.73 170.29,23.1 175.34,23.1 175.39,23.05 176.64,23.05 176.98,22.71 179.01,22.71 179.25,22.95 182.28,22.95 182.97,22.26 186.31,22.26 187.03,22.97 v2(188.12,22.97)
  BOTTOM w0.102: R764.2 94.03,26.27 94.07,26.3 R765.1 94.68,26.17 94.35,25.84 93.81,25.84 93.74,25.77 93.74,25.34 93.3,24.9 92.8,24.9 91.96,24.07 v2(91.96,22.72)
SKTOCC#: length 6.6
  BOTTOM w0.102: U24.C5 96.12,80.33 95.66,80.78 95.25,80.78 94.99,81.05 94.58,81.05 94.1,81.53 94.1,81.66 93.29,82.47 93.29,83.35 92.39,84.24 R578.1
SLEEVE: length 21.9
  IN3 w1.016: 214.29,43.52 213.83,43.06 210.27,43.06 209.84,42.63 209.84,42.05 209.34,41.54 207.68,41.54 205.29,39.16 205.29,37.15 204.91,36.77 204.91,36.38 204.3,35.77 202.37,35.77 201.18,34.58 201.18,33.69 200.85,33.36
  BOTTOM w0.203: U30.18 200.87,32.43 200.59,32.7 v1(200.37,32.7)
  BOTTOM w0.381: v1(199.73,32.73) 199.78,32.73 199.81,32.7 v1(200.37,32.7)
  vias: v1(214.69,42.81) v1(215.1,43.32)
SLP_S5#: length 1.3
  TOP w0.102: TP31.1 77.15,39.89 v2(76.79,39.53)
  BOTTOM w0.102: U24.DF45 76.6,39.34 v2(76.79,39.53)
SM_VREF: length 30.9
  TOP w0.508: v2(76.48,79.83) 75.79,79.83 75.25,80.38 75.25,81.42 72.86,83.81 69.28,83.81 67.88,85.2 67.17,85.2 66.33,86.04 v1(66.08,86.04) ; R159.1 62,73.68 62.43,73.26 C211.1 63.93,73.26 64.58,73.9 v1(64.58,74.18)
  BOTTOM w0.254: U24.C44 76.85,80.21 v2(76.48,79.83)
  BOTTOM w0.508: v1(64.58,74.18) 64.58,75.3 64.07,75.81 64.07,83.04 v1(65.07,84.05) 66.08,85.05 v1(66.08,86.04)
SMB_ML0_CLK: length 11.3
  TOP w0.079: 88.87,34.47 88.69,34.65 88.44,34.65 87.67,35.42 87.21,35.42 86.39,36.24 86.39,36.68 86.06,37.02 v2(85.91,37.02)
  TOP w0.102: 88.87,34.47 89.05,34.29 89.05,33.81 90.28,32.58 v1(90.28,32.09) 90.28,31.43 90.66,31.05 90.66,29.4 R361.1
  BOTTOM w0.079: v2(85.91,37.02) 85.94,37.02 U24.DK24
SMB_ML0_DAT: length 16.8
  TOP w0.079: v2(84.01,37.71) 84.14,37.58 86.04,37.58 86.29,37.32 86.29,37.02 86.56,36.75 86.56,36.31 87.28,35.58 87.75,35.58 88.5,34.83 88.61,34.83
  TOP w0.102: 88.61,34.83 88.78,34.83 89.24,34.37 89.24,33.89 90.71,32.41 90.71,31.5 91.1,31.12 91.1,30.49 v1(91.15,30.44) 91.02,30.31 91.02,29.26 90.53,28.77 90.53,28.51 R367.1
  BOTTOM w0.079: v2(84.01,37.71) 85.98,37.71 U24.DJ24
SMB_ML1_CLK: length 13.5
  TOP w0.079: 88.87,35.01 88.56,35.01 87.83,35.75 87.83,36.09 v2(87.64,36.28)
  TOP w0.102: R379.2 R380.2 90.61,27.15 v1(90.78,27.32) 90.78,27.35 92.01,28.58 R356.1 92.01,30.25 91.58,30.68 91.58,31.8 91.33,32.04 91.33,32.1 89.47,33.96 89.47,34.41 88.87,35.01
  BOTTOM w0.079: U24.DN22 87.42,36.28 v2(87.64,36.28)
SMB_ML1_DAT: length 13.5
  TOP w0.079: 89.06,35.14 88.94,35.27 88.55,35.27 88,35.82 88,36.51 87.64,36.87 v2(87.64,36.89)
  TOP w0.102: 89.06,35.14 89.7,34.5 89.7,34 92.01,31.69 v1(92.01,31.43) 92.01,30.57 92.34,30.25 92.34,29.76 92.55,29.55 R357.1 92.55,28.79 91.37,27.62 R381.2
  BOTTOM w0.079: U24.DL22 87.47,36.72 v2(87.64,36.89)
SMB_PCH_CLK: length 24.2
  TOP w0.102: v1(83.12,24.24) 83.25,24.12 85.84,24.12 86.64,24.92 87.43,24.92 87.84,25.34 87.84,26.02 88.1,26.28 88.1,28.43 v1(87.95,28.59) 88.1,28.74 88.1,32.24 87.56,32.78 87.56,33.91 87.21,34.26 87.16,34.26 86.73,34.7 85.72,34.7 85.5,34.92 85.5,36.51 v2(84.94,37.07)
  BOTTOM w0.102: v1(83.12,24.24) 83.3,24.07 83.4,24.07 83.5,23.96 83.5,23.1 83.15,22.75 R792.1 R801.1 83.47,22.18 83.87,22.58 Q41.6 ; v2(84.94,37.07) 85.08,37.07 U24.DK27
SMB_PCH_DAT: length 18.9
  TOP w0.102: 88.53,29.85 88.53,29.83 88.45,29.76 88.45,26.13 88.2,25.87 88.2,25.16 87.52,24.48 86.91,24.48 v2(86.68,24.24) ; 88.53,29.85 v1(88.53,29.87) ; 88.53,29.85 88.53,29.85 88.48,29.85 88.45,29.87 88.45,32.39 87.82,33.03 87.82,33.92 87.29,34.45 87.24,34.45 86.62,35.08 v2(85.92,35.08)
  BOTTOM w0.102: v2(86.68,24.24) 86.68,24.48 86.55,24.61 86.55,25 86.39,25.16 R779.1 R790.1 85.94,23.45 85.17,24.23 Q41.3 ; v2(85.92,35.08) 86.26,35.42 U24.DP24
SMB_RUN_CLK: length 138.4
  TOP w0.102: R484.1 66.36,12.05 66.61,11.8 69.25,11.8 69.61,12.15 69.61,12.89 70.04,13.32 70.8,13.32 71.33,12.79 72.3,12.79 72.63,13.12 72.63,13.6 72.88,13.85 73.24,13.85 73.52,14.13 73.52,14.82 75.43,16.73 76.28,16.73 76.39,16.84 76.39,17.57 R450.2 75.93,18.25 76.34,18.66 v2(76.34,19.04)
  IN1 w0.089: v1(52,94.68) 51.75,94.68 50.21,93.14 50.21,54.8 49.53,54.11 49.53,40.23 48.03,38.73 48.03,37.56 47.14,36.67 47.14,35.29 49.9,32.54 49.9,30.42 52.08,28.23 52.08,26.91 v2(51.98,26.81)
  BOTTOM w0.102: Q41.1 83.03,24.79 82.48,24.24 82.48,23.99 82.2,23.71 R788.1 82.61,23.61 82.87,23.35 R792.2 82.61,23.2 82.13,22.72 81.09,22.72 80.77,23.04 80.26,23.04 79.94,22.72 79.94,19.65 79.44,19.14 76.44,19.14 v2(76.34,19.04) 75.88,18.58 72.5,18.58 71.87,17.94 71.87,17.56 71.69,17.39 71.03,17.39 70.9,17.51 70.9,18.1 70.7,18.3 69.25,18.3 68.56,18.99 65.9,18.99 65.47,18.55 62.9,18.55 62.16,19.28 62.16,22.14 59.63,24.67 58.36,24.67 57.65,23.96 57.14,23.96 56.53,23.35 56.15,23.35 56,23.2 53.2,23.2 51.88,24.52 51.88,26.71 v2(51.98,26.81) ; v1(52,94.68) 51.95,94.68 51.73,94.45 JDIM1.253
SMB_RUN_DAT: length 133.4
  TOP w0.102: R475.1 69.92,14.21 70.25,14.54 70.25,16.05 70.34,16.14 70.34,17.72 v1(70.47,17.84) 70.26,18.05 R437.2
  IN1 w0.089: v1(52.64,94.65) 52.18,95.11 51.67,95.11 49.87,93.31 49.87,54.94 49.19,54.26 49.19,40.37 47.69,38.87 47.69,37.71 46.8,36.82 46.8,35.15 49.55,32.39 49.55,30.27 51.74,28.09 51.74,27.13 v2(51.39,26.78)
  BOTTOM w0.102: v2(51.39,26.78) 51.52,26.65 51.52,24.38 53.05,22.85 56.15,22.85 56.3,23 56.67,23 57.28,23.61 57.85,23.61 58.56,24.32 59.48,24.32 61.81,21.99 61.81,19.14 62.75,18.2 65.62,18.2 66.05,18.63 68.41,18.63 69.1,17.94 70.37,17.94 v1(70.47,17.84) 70.47,17.39 70.83,17.03 71.84,17.03 72.22,17.42 72.22,17.8 72.65,18.22 76.16,18.22 76.72,18.78 79.58,18.78 81.62,20.81 84.52,20.81 85.63,21.93 85.63,22.31 85.73,22.41 R800.1 R790.2 85.45,23 85.27,23.19 Q41.4 ; v1(52.64,94.65) 53.2,94.09 53.86,94.09 54.88,95.11 57.04,95.11 57.44,94.7 JDIM1.254
SMDDR_VREF_DQ1_M3: length 42
  TOP w0.508: v1(53.06,98.12) C125.1 52.46,99.17 52.21,98.92 R51.1 ; v1(67.09,96.25) v1(67.09,94.42) 67.09,87.77 69.91,84.95 74.2,84.95 76.39,82.76 76.39,81.04 v2(76.42,81.01)
  IN2 w0.508: v1(67.09,96.25) 66.64,95.79 65.01,95.79 64.07,94.86 62.29,94.86 60.74,96.4 59.04,96.4 58.15,95.52 55.28,95.52 54.9,95.9 53.86,95.9 53.06,96.69 v1(53.06,98.12)
  BOTTOM w0.254: U24.B45 76.23,80.83 v2(76.42,81.01)
SNDW_RCOMP: length 1.2
  TOP w0.254: R259.1 80.91,43.5 80.47,43.5 v2(80.38,43.58)
  BOTTOM w0.254: U24.CV38 v2(80.38,43.58)
SP_PLLVDD: length 23.3
  TOP w0.254: C90.2 C96.2 99.22,102.37 99.19,102.41 R42.2 98.01,102.41 v2(97.95,102.47) 97.69,102.73 97.04,102.73 94.93,104.84 93.92,104.84 91.71,107.05 89.72,107.05 89.46,107.31 C59.1 88.72,107.56 L1.2 88.46,107.55 88.2,107.81 87.26,107.81 87.05,107.6 87.05,105.74 v1(88.05,104.74) 88.05,102.7 87.56,102.22 C103.1
  BOTTOM w0.254: U22.M6 98.33,102.09 v2(97.95,102.47)
SPI_TPM_CS#: length 76.4
  TOP w0.102: v2(120.58,19.85) 120.18,20.26 120.18,21.37 119.8,21.75 v1(119.8,22.59) 120.12,22.92 R411.1 R412.1
  IN1 w0.089: v2(79.69,40.93) 79.67,40.93 79.59,41.01 78.85,41.01 78.52,41.34 77.46,41.34 77.28,41.16 76.72,41.16 76.07,40.51 75.47,40.51 74.36,39.4 74.34,39.4 73.93,38.99 73.42,38.99 72.88,38.45 72.88,36.48 72.6,36.2 72.6,33.94 72.17,33.51 72.17,32.09 72.45,31.81 73.07,31.81 75.89,28.99 75.89,26.87 76.7,26.06 77.3,26.06 78.59,24.77 86.69,24.77 87.18,24.28 90.04,24.28 90.22,24.1 92.05,24.1 92.73,23.42 94.76,23.42 98.6,19.57 103.53,19.57 104.59,20.64 119.24,20.64 119.73,20.14 120.29,20.14 v2(120.58,19.85)
  BOTTOM w0.102: v2(79.69,40.93) 79.67,40.93 79.59,41.01 79.06,41.01 78.74,41.32 U24.DB41
SRTC_RST#: length 118
  TOP w0.102: v1(65.09,24.75) 64.48,24.15 v1(64.48,24.11) 64.48,23.77 63.71,23 57.19,23 56.96,23.23 56.96,24.5 56.53,24.93 55.61,24.93 54.85,24.18 54.85,23.38 55.79,22.45 55.79,21.01 57.42,19.38 57.42,18.71 v2(57.14,18.43) ; Q29.3 17.94,6.49 v1(17.74,6.29)
  IN1 w0.089: v1(65.09,24.75) 64.48,25.35 64.48,26.47 63.82,27.14 63.82,28.28 62.69,29.41 62.69,30.48 63.37,31.16 66.16,31.16 68.58,33.58 69.21,33.58 71.56,35.93 71.56,36.69 72.26,37.39 v2(72.26,37.62) ; v2(57.14,18.43) 58.15,18.43 58.56,18.02 58.56,17.84 59.14,17.26 59.14,14.69 v1(60.21,13.63)
  IN2 w0.089: v1(60.21,13.63) 59.94,13.35 55.64,13.35 55.04,13.96 53.81,13.96 53.71,13.85 47.92,13.85 45.38,11.31 44.89,11.31 42.58,9 40.45,9 37.4,5.96 34.86,5.96 34.78,5.88 33.01,5.88 32.75,6.13 29.23,6.13 27.99,4.89 24.98,4.89 24.7,5.17 23.12,5.17 21.27,7.02 20.13,7.02 19.67,6.56 18.02,6.56 v1(17.74,6.29) 17.59,6.29 16.2,4.9 15.32,4.9 14.67,4.25 14,4.25 12.79,5.47 v1(11.87,5.47)
  BOTTOM w0.079: U24.DK46 75.86,37.48 75.46,37.87 74.86,37.87 74.76,37.94 74.55,37.94 74.43,37.87 74.18,37.87 74.1,37.96 72.58,37.96 72.26,37.64 v2(72.26,37.62)
  BOTTOM w0.102: v1(11.87,5.47) 11.77,5.47 11.39,5.85 11.39,8.83 11.03,9.18 11.03,10.3 12.23,11.49 13.83,11.49 14.38,10.94 C720.1 R853.2
STRAP0: length 6.8
  BOTTOM w0.102: R533.1 88.59,96.32 89.24,95.67 90.42,95.67 R534.2 91.41,96.13 91.93,95.6 93.89,95.6 94.06,95.43 U22.D1
STRAP1: length 7.3
  BOTTOM w0.102: R538.1 88.94,95.62 89.11,95.44 89.42,95.44 89.88,94.98 R539.2 90.59,95.48 91.73,95.48 91.83,95.38 93.72,95.38 94.04,95.06 94.5,95.06 94.87,95.43 U22.D2
STRAP2: length 10.3
  BOTTOM w0.102: U22.E4 96.27,95.82 95.77,95.82 95.54,95.59 95.54,95.31 95.29,95.06 95.01,95.06 94.73,94.78 94.73,94.4 94.55,94.22 94.19,94.22 94.09,94.32 92.97,94.32 91.6,92.95 R545.2 90.37,93.46 89.88,93.46 89.75,93.59 R544.1
STRAP3: length 8.8
  BOTTOM w0.102: R529.1 88.59,97.39 89.22,96.76 89.47,96.76 89.6,96.63 90.37,96.63 R532.2 91.27,97.14 92.57,95.85 95.29,95.85 95.72,96.28 U22.E3
STRAP4: length 9.9
  BOTTOM w0.102: R546.1 88.96,92.57 89.01,92.52 90.29,92.52 R547.2 91.5,92.56 93.8,92.56 94.19,92.95 94.19,93.08 94.34,93.23 94.58,93.23 94.8,93.46 95.31,93.46 95.54,93.69 95.54,94.83 95.93,95.22 U22.D3
STRAP5: length 6.3
  BOTTOM w0.102: R540.1 88.96,94.6 89.01,94.55 90.29,94.55 R543.2 91.93,93.97 92.52,94.55 94.25,94.55 U22.C1
SUSB#: length 175.6
  TOP w0.102: U13.119 188.45,29.03 188.2,28.79 188.2,28.23 187.87,27.9 v2(187.62,27.9) ; R339.2 66.23,29.52 66.53,29.83 C724.2 66.86,30.54 66.93,30.54 68.39,32 68.39,33.83 70.72,36.16 70.72,37.88 72.1,39.25 73.13,39.25 73.34,39.47 v2(73.34,39.57)
  IN1 w0.089: v1(104.79,49.64) 105.01,49.87 105.98,49.87 106.89,50.79 107.76,50.79 108.91,49.63 v1(109.85,49.63) ; v2(187.62,27.9) 187.41,27.7 186.55,27.7 185.99,28.26 183.78,28.26 183.01,27.49 177.41,27.49 177.28,27.62 174.1,27.62 173.95,27.77 170.6,27.77 169.48,28.89 162.74,28.89 162.31,29.32 155.78,29.32 155.61,29.49 153.64,29.49 153.31,29.82 151.13,29.82 150.48,30.47 145.04,30.47 143.98,31.53 141.75,31.53 141.39,31.89 137.12,31.89 137.03,31.8 132.76,31.8 131.82,32.74 130.07,32.74 129.37,32.04 125.84,32.04 122.99,29.18 112.84,29.18 110.1,31.93 109.17,31.93 108.85,32.24 108.07,32.24 108.02,32.2 107.65,32.2 v1(107.25,32.6) 107.2,32.65 106.41,32.65 105.9,32.14 102,32.14 101.81,32.33 98.13,32.33 97.07,33.39 93.88,33.39 93.57,33.71 93.57,33.72 93.01,34.28 91.98,34.28 91.61,34.64 90.21,34.64 90.05,34.48 86.9,34.48 86.87,34.51 85.42,34.51 84.88,33.98 83.85,33.98 83.17,34.66 82.7,34.66 82.61,34.57 81.94,34.57 81.69,34.82 81.69,35.33 81.25,35.76 81.25,38.91 80.53,39.63 80.53,41.97 79.65,42.85 78.93,42.85 78.39,42.31 77.56,42.31 77.45,42.2 76.36,42.2 75.14,40.98 75.14,40.74 73.97,39.57 v2(73.34,39.57)
  IN3 w0.089: v1(107.25,32.6) 107.25,32.98 107.39,33.12 107.39,36.71 106.28,37.83 106.28,42.02 105.27,43.03 105.27,46.62 104.79,47.1 v1(104.79,49.64)
  BOTTOM w0.079: v2(73.34,39.57) 75.29,39.57 75.52,39.34 U24.DF47
  BOTTOM w0.102: U27.1 104.99,49.16 104.79,49.37 v1(104.79,49.64) ; v1(109.85,49.63) 110.32,49.16 D43.1
SUSC#: length 215.4
  TOP w0.102: v2(73.93,40.18) 73.73,40.37 73.34,40.37 73.02,40.69 72.65,40.69 70.17,38.21 70.17,36.64 68.72,35.19 C723.2 66.51,34.63 R291.2 67.03,34.11 67.03,33.6 65.44,32.01 65.44,30.64 64.87,30.06 64.87,29.22 64.58,28.94 64.58,28.72 63.61,27.76 63.61,25.69 63.18,25.26 62.47,25.26 61.33,24.12 60.59,24.12 v1(59.58,25.12) 59.29,25.41 55.41,25.41 54.37,24.38 54.37,23.18 55.31,22.25 55.31,20.81 56.7,19.42 56.7,19.04 56.27,18.6 56.27,17.69 56.45,17.51 56.72,17.51 56.84,17.39 56.84,16.64 57.42,16.06 57.42,15.87 57.21,15.66 R467.1 ; v1(107.25,48.47) 107.33,48.4 107.9,48.4 D6.2 ; v2(185.99,22.99) 185.99,22.92 184.9,21.83 184.39,21.83 183.94,21.38 U13.18
  IN1 w0.089: v2(73.93,40.18) 74.03,40.18 76.97,43.12 77.51,43.12 77.56,43.17 78.55,43.17 78.67,43.04 80.45,43.04 80.71,43.29 81.65,43.29 81.95,42.99 81.95,38.91 81.44,38.4 81.44,35.84 81.94,35.34 82.75,35.34 83.93,34.17 84.81,34.17 85.34,34.7 86.95,34.7 86.97,34.69 88.01,34.69 88.02,34.67 89.97,34.67 90.93,35.63 90.93,35.87 91.3,36.24 91.55,36.24 91.72,36.08 91.72,34.81 92.06,34.47 93.09,34.47 93.97,33.58 97.22,33.58 97.62,33.98 99.49,33.98 100.95,32.52 101.64,32.52 102.14,33.03 107.45,33.03 v1(107.88,32.6) 108.05,32.43 108.93,32.43 109.25,32.12 110.18,32.12 112.92,29.37 122.91,29.37 125.76,32.23 129.29,32.23 129.99,32.93 131.9,32.93 132.84,31.99 135.46,31.99 136.16,32.69 137.27,32.69 137.88,32.08 142.23,32.08 142.59,31.72 144.06,31.72 145.12,30.66 150.56,30.66 151.08,30.14 153.26,30.14 153.72,29.68 157.54,29.68 157.71,29.51 162.39,29.51 162.82,29.08 169.72,29.08 170.83,27.98 174.13,27.98 174.28,27.82 177.46,27.82 177.6,27.68 182.69,27.68 183.46,28.45 186.08,28.45 186.64,27.89 187.07,27.89 187.49,28.31 187.74,28.31 188,28.05 188,27.75 187.76,27.51 186.73,27.51 186.54,27.32 185.76,27.32 185.48,27.04 185.48,26.02 185.23,25.77 185.23,23.76 185.99,23 v2(185.99,22.99)
  IN3 w0.089: v1(107.25,48.47) 106.8,48.02 106.8,45.41 106.25,44.86 106.25,43.84 107.81,42.28 108.06,42.28 108.82,41.52 108.82,37.97 109.68,37.1 109.68,35.92 110.17,35.43 110.17,34.66 110.03,34.52 110.03,31.58 109.18,30.73 108.14,30.73 107.63,31.24 107.63,31.74 107.88,31.99 v1(107.88,32.6)
  BOTTOM w0.079: v2(73.93,40.18) 74.29,40.18 74.71,40.6 U24.DC48
SUSCLK_32K: length 142.7
  IN1 w0.089: v2(194.55,21.88) 194.55,21.91 194.41,22.05 194.41,22.15 193.46,23.1 193.46,25.34 193.25,25.54 191.04,25.54 190.69,25.89 187.41,25.89 187.01,25.49 187.01,23.13 186.23,22.35 184.73,22.35 183.93,23.15 183.93,24.65 182.09,26.49 179.15,26.49 178.76,26.11 176.68,26.11 176.32,26.47 175.71,26.47 175.12,25.88 174.01,25.88 173.45,26.44 170.36,26.44 168.78,28.02 162.38,28.02 161.95,28.45 156.19,28.45 155.72,27.99 154,27.99 153.62,28.37 147.5,28.37 146.27,29.6 144.68,29.6 143.62,30.66 140.12,30.66 139.94,30.48 138.95,30.48 138.41,31.02 137.48,31.02 136.82,30.36 132.8,30.36 131.99,31.18 126.23,31.18 123.33,28.28 111.44,28.28 111.06,28.66 111.06,29.74 110.27,30.53 108.91,30.53 108.16,31.28 101.64,31.28 101.45,31.47 97.77,31.47 96.71,32.53 93.53,32.53 92.83,33.22 87.95,33.22 87.62,33.55 86.65,33.55 86.21,33.11 82.29,33.11 81.14,34.26 81.14,34.43 80.88,34.69 80.88,35.17 80.35,35.7 80.2,35.7 79.94,35.95 79.94,39.1 79.61,39.44 78.34,39.44 78.04,39.14 77.29,39.14 76.99,38.84 v2(76.35,38.84)
  BOTTOM w0.079: U24.DF49 74.44,39.34 74.74,39.04 76.15,39.04 v2(76.35,38.84)
  BOTTOM w0.102: R802.2 194.45,21.78 v2(194.55,21.88)
SUSCLK_32KHZ: length 4.3
  BOTTOM w0.102: CN9.50 191.47,18.88 191.73,19.13 191.73,20.27 193.14,21.68 R802.1
SUSLED#: length 54.2
  TOP w0.102: U13.28 183.93,17.38 184.14,17.59 184.14,18.48 184.62,18.96 187.17,18.96 188.26,20.05 190.33,20.05 v2(191.93,21.65) ; v2(206.08,25.11) 206.87,25.11 208.57,23.4 212.51,23.4 214.74,25.64 215.1,25.64 215.61,26.15 216.83,26.15 217.21,26.53 217.21,30.62 216.98,30.85 v1(216.98,31.23)
  IN2 w0.089: v2(191.93,21.65) 191.93,21.42 192.02,21.33 192.97,21.33 193.36,21.72 193.71,21.72 194.29,22.29 195.15,22.29 195.54,21.91 196.89,21.91 197.55,22.57 197.83,22.57 198.67,23.41 201.23,23.41 202.72,24.9 205.88,24.9 v2(206.08,25.11)
  BOTTOM w0.102: v1(216.98,31.23) 216.69,31.23 arc(216.61,31.26) 216.57,31.35 216.57,35.8 arc(216.57,35.8) 216.57,35.8 214.47,37.9 CN6.21
SUSON: length 261.2
  TOP w0.102: v2(178.34,32.85) 178.7,32.5 178.9,32.5 179.89,31.51 180.63,31.51 181.11,31.02 181.37,31.02 181.54,30.85 181.54,30.46 R348.1 181.62,29.95 182.11,30.44 183.86,30.44 184.24,30.06 184.24,28.99 184.56,28.67 184.95,28.67 185.35,28.27 185.35,27.67 185.69,27.34 186.04,27.34 186.35,27.65 186.79,27.65 187.27,28.13 187.27,28.18 188.05,28.96 U13.120 ; R265.1 108.49,41.85 108.65,42 110.55,42 110.61,42.06 v1(111.1,42.06) 111.56,42.06 112.28,41.34 v1(112.68,41.34)
  IN1 w0.089: v1(62.25,110.21) 62.67,110.63 62.95,110.63 63.28,110.96 63.28,117.49 62.42,118.35 61.78,118.35 61.66,118.48 61.66,119.11 62.8,120.26 62.8,120.64 63.43,121.27 63.43,121.65 63.82,122.03 65.09,122.03 66.01,122.96 v1(66.01,125.58)
  IN2 w0.089: v1(62.25,110.21) 62.25,110.13 62.67,109.71 64.24,109.71 66.15,107.81 66.15,106.9 70.51,102.54 73.4,102.54 73.58,102.35 74.51,102.35 75.68,101.18 78.95,101.18 83,97.13 83,96.51 83.47,96.03 83.47,91.33 83.88,90.92 83.88,86.93 84.03,86.78 86,86.78 87.81,84.97 90.36,84.97 94.72,80.62 95.58,80.62 98.87,77.33 98.87,76.35 99.01,76.21 100.8,76.21 103.62,73.39 103.62,63.1 104.09,62.63 104.09,61.53 103.07,60.51 103.07,57.13 104.91,55.29 106.8,55.29 111.85,50.24 v1(111.85,49.8) 112.41,49.24 112.75,49.24 114.32,47.67 120.64,47.67 122.68,45.64 125.98,45.64 128.59,48.25 132.99,48.25 134.14,47.1 135.78,47.1 136.92,45.96 143,45.96 143.75,45.21 143.75,43.65 v1(143.27,43.17) 143.75,42.68 143.75,39.97 146.91,36.81 146.91,36.28 147.33,35.86 147.82,35.86 148.41,35.27 153.01,35.27 153.26,35.02 156.01,35.02 156.59,35.6 159.03,35.6 159.34,35.28 161.88,35.28 162.71,34.45 163.61,34.45 163.97,34.09 164.11,34.09 164.89,33.3 166.01,33.3 166.22,33.1 167.03,33.1 167.26,33.33 176.55,33.33 176.77,33.11 176.77,32.67 176.89,32.56 178.27,32.56 178.34,32.63 v2(178.34,32.85)
  IN3 w0.089: v1(111.85,49.8) 111.85,49.55 111.24,48.94 111.24,46.69 113.17,44.76 113.17,41.85 112.68,41.36 v1(112.68,41.34) 112.68,40.69 113.37,40.01 113.37,36.53 114.2,35.7 116.8,35.7 117.55,34.95 117.55,33.99 116.94,33.37 115.13,33.37 112.7,30.95 112.7,30.71 109.79,27.8 108.32,27.8 v2(107.94,28.18)
  BOTTOM w0.102: R676.2 v1(112.68,41.34) ; v1(143.27,43.17) 143.65,43.55 143.95,43.55 144.71,44.31 v1(144.71,45.9) 144.71,47.48 144.43,47.77 PR213.1 ; U31.3 107.97,31.69 108.17,31.89 C639.2 108.77,31.74 108.65,31.61 108.65,31.43 109.1,30.97 R714.2 109.1,30.54 109,30.44 108.6,30.44 108.22,30.06 108.22,28.46 v2(107.94,28.18)
  BOTTOM w0.178: PR126.1 66.34,124.38 66.34,125.25 v1(66.01,125.58)
SYS_HWPG: length 171.5
  TOP w0.102: v2(168.36,31.13) 168.54,31.13 169.41,32 D9.1 ; v2(143.04,35.14) 142.4,35.14 141.46,34.2 141.46,32.97 139.99,31.5 139.99,29.17 139.94,29.12 v2(139.94,29.09) ; v2(186.4,31.23) 186.45,31.18 U13.124
  IN2 w0.089: v2(101.66,25.16) 102.09,24.73 102.54,24.73 102.69,24.88 110.27,24.88 113.38,27.99 124.92,27.99 125.61,28.68 127.99,28.68 128.94,27.72 134.73,27.72 136.21,29.2 138.75,29.2 138.85,29.09 v2(139.94,29.09) ; v1(73.06,13.35) 72.27,14.13 61.87,14.13 60.42,15.59 58.53,15.59 57.51,14.56 56.14,14.56 54.05,16.65 48.4,16.65 46.95,15.2 v1(46.65,15.2)
  IN3 w0.089: v2(186.4,31.23) 186.4,31.13 185.85,30.58 183.33,30.58 182.78,30.03 180.31,30.03 179.85,30.5 175.82,30.5 174.9,31.42 168.66,31.42 v2(168.36,31.13) 168.31,31.07 166.39,31.07 165.81,30.49 164.71,30.49 164.13,31.07 158.68,31.07 157.81,31.93 155.46,31.93 154.33,33.06 146.61,33.06 145.77,32.22 144.03,32.22 143.52,32.73 143.52,33.08 142.86,33.74 142.86,34.96 v2(143.04,35.14) ; v1(73.06,13.35) 74.13,13.35 74.75,12.72 79.8,12.72 82.6,9.93 89.18,9.93 94.25,15 95.65,15 100.19,19.55 100.19,22.4 101.15,23.36 101.15,24.62 101.66,25.13 v2(101.66,25.16)
  BOTTOM w0.102: v1(46.65,15.2) 46.95,15.51 46.95,16.12 46.67,16.4 PR273.2 ; v2(143.04,35.14) 143.06,35.17 143.06,35.54 PR237.2
SYS_PWROK: length 53.8
  TOP w0.079: 91.73,33.13 91.09,33.13 90.36,33.87 90.36,34.66 89.52,35.49 v2(89.52,35.65)
  TOP w0.102: v1(64.98,25.89) v1(64.98,26.61) 65.34,26.96 R372.2 ; 91.73,33.13 91.95,33.13 92.87,32.21 92.87,30.68 93.84,29.71 93.84,28.95 94.41,28.38 94.88,28.38 95.29,27.98 95.29,27.55 93.81,26.07 93.81,24.4 92.49,23.08 92.49,21.96 93.31,21.14 v1(93.91,21.14)
  IN1 w0.089: v1(93.91,21.14) 92.62,21.14 92.49,21.27 91.16,21.27 89.48,22.95 81.67,22.95 80.71,21.98 79.79,21.98 79.67,22.1 75.99,22.1 75.34,22.75 74.45,22.75 73.51,23.69 70.24,23.69 69.06,24.87 65.66,24.87 64.98,25.54 v1(64.98,25.89)
  BOTTOM w0.079: v2(89.52,35.65) 89.26,35.65 U24.DP19
SYS_RESET#: length 5.7
  TOP w0.079: v2(89.6,37.04) 89.6,36.9 89.96,36.54 89.96,35.95 90.05,35.87 90.05,35.47 90.98,34.53 91.02,34.53 91.15,34.4
  TOP w0.102: 91.15,34.4 91.53,34.02 R299.2
  BOTTOM w0.102: v2(89.6,37.04) 89.28,37.37 U24.DK19
SYS_SHDN#: length 248.6
  TOP w0.102: v2(103.29,23.86) 104.23,23.86 108.65,28.28 v1(108.65,28.38) ; v2(195.85,25.26) 196.56,24.55 197.72,24.55 197.98,24.29 197.98,23.94 198.14,23.78 U13.85 ; v2(143.95,26.2) 143.95,26.71 143.5,27.16 143.5,27.7 144.26,28.46 v1(144.64,28.46) 144.64,29.81 146.06,31.23 146.06,31.84 145.65,32.25 145.31,32.25 144.84,32.72 144.84,32.88 144.62,33.1 PR77.2 143.85,33.1 143.57,33.39 143.57,34.39 144.76,35.57 PR70.1 ; Q11.3 114.85,55.77 112.61,53.53 111.54,53.53 v1(110.88,52.87)
  IN2 w0.089: v2(103.29,23.86) 103.5,23.65 110.33,23.65 112.21,25.53 120.78,25.53 121.16,25.91 126.69,25.91 127.71,26.94 134.96,26.94 135.3,26.59 137.75,26.59 138.28,26.07 142.89,26.07 143.01,26.2 v2(143.95,26.2) 145.13,25.02 154.44,25.02 154.86,25.44 159.95,25.44 160.62,24.77 165.54,24.77 165.57,24.74 167.02,24.74 167.08,24.67 169.38,24.67 169.56,24.5 169.94,24.5 170.37,24.07 174.38,24.07 175.4,25.09 175.4,26.05 175.75,26.4 176.09,26.4 176.87,25.61 178.6,25.61 178.77,25.79 181.85,25.79 182.95,24.69 186.07,24.69 186.54,24.22 188.27,24.22 189.35,23.15 190.24,23.15 191.01,23.92 192.73,23.92 193.28,24.47 193.28,25.18 193.66,25.56 194.6,25.56 194.91,25.26 v2(195.85,25.26)
  IN3 w0.089: v1(110.88,52.87) 110.4,52.39 110.4,49.39 110.84,48.94 110.84,46.53 112.22,45.15 112.22,40.6 112.97,39.85 112.97,36.37 114.03,35.3 116.64,35.3 117.16,34.78 117.16,34.15 116.77,33.77 114.96,33.77 112.3,31.11 112.3,30.87 109.82,28.38 v1(108.65,28.38) ; v2(103.29,23.86) 103.19,23.76 103.19,19.81 101.03,17.66 99.65,17.66 96.15,14.16 94.47,14.16 89.34,9.03 82.31,9.03 79.69,11.64 74.66,11.64 74.05,12.25 71.46,12.25 70.75,12.97 69.76,12.97 68.86,12.06 61.87,12.06 61.77,11.96 60.97,11.96 60.26,12.67 58.68,12.67 58.11,13.24 55.87,13.24 54.93,12.31 v1(54.93,12.05)
  BOTTOM w0.102: PR276.2 47.58,14.01 48.09,13.5 48.09,12.31 48.8,11.59 54.82,11.59 54.93,11.7 v1(54.93,12.05) ; PR269.2 108.96,26.01 108.96,28.07 v1(108.65,28.38)
TBT_FORCE_PWR: length 2.2
  TOP w0.102: TP25.1 80.76,45.07 80.08,45.07 v2(79.64,45.52)
  BOTTOM w0.114: v2(79.64,45.52) 79.64,45.32 U24.CR39
TBTA_HPD: length 2.1
  TOP w0.102: TP26.1 79.31,43.83 v2(78.98,43.5)
  BOTTOM w0.114: v2(78.98,43.5) 78.98,43.34 79.17,43.15 U24.CV39
TBTB_HPD: length 2.2
  TOP w0.102: TP28.1 77.45,43.17 77.06,42.77 v2(77.06,42.62)
  BOTTOM w0.079: U24.CY43 77.35,42.33 v2(77.06,42.62)
TCRCOMP_DN: length 4.1
  BOTTOM w0.079: 98.46,62.06 98.44,62.09 97.84,62.09 97.74,61.99 97.74,61.9 97.78,61.86 U24.AY1
  BOTTOM w0.102: 98.46,62.06 99.49,62.06 99.86,62.43 100.76,62.43 100.92,62.27 R617.2
TCRCOMP_DP: length 4.1
  BOTTOM w0.079: 98.46,62.28 98.44,62.26 97.77,62.26 97.57,62.06 97.57,62.02 U24.AY2
  BOTTOM w0.102: R617.1 100.79,62.72 100.7,62.62 99.78,62.62 99.44,62.28 98.46,62.28
TEMP_MBAT#: length 115.5
  TOP w0.102: v2(101.41,20.18) 101.06,20.53 PR113.2 ; U13.73 198.13,18.98 197.84,18.7 197.41,18.7 197.22,18.89 197.22,19.41 196.98,19.64 196.56,19.64 195.92,20.28 195.92,21.72 193.25,24.39 193.25,25.57 192.91,25.92 189.6,25.92 189.19,25.51 v2(189.04,25.51)
  TOP w0.178: PR90.1 137.45,28.05 136.99,28.51 PR88.1 136.74,28.23 v2(136.59,28.08)
  IN2 w0.089: v2(102.68,23.86) 102.68,24.24 102.89,24.46 110.59,24.46 112.05,25.92 120.61,25.92 121,26.31 126.52,26.31 127.54,27.33 134.88,27.33 135.11,27.56 136.07,27.56 v2(136.59,28.08) 136.83,28.08 138.42,26.48 141.38,26.48 141.57,26.67 141.57,26.94 141.81,27.18 142.41,27.18 142.89,26.7 144.75,26.7 146.03,25.42 154.28,25.42 154.73,25.87 160.08,25.87 160.78,25.16 165.82,25.16 165.85,25.13 167.63,25.13 167.68,25.08 169.25,25.08 169.3,25.13 169.96,25.13 170.64,24.46 174.21,24.46 175.01,25.26 175.01,26.22 175.63,26.83 176.21,26.83 177.04,26.01 178.43,26.01 178.61,26.19 182.27,26.19 183.37,25.09 186.46,25.09 186.52,25.03 188.55,25.03 v2(189.04,25.51)
  IN3 w0.089: v2(101.41,20.18) 101.13,20.46 101.13,21.04 102.68,22.59 v2(102.68,23.86)
TESTMODE: length 7
  BOTTOM w0.102: R513.1 102.95,116.08 102.17,115.3 102.17,112.64 101.94,112.41 101.29,112.41 U22.AD9
THERM+: length 1.4
  TOP w0.152: TP5.1 102.97,96.63 v2(102.97,96.64)
  BOTTOM w0.102: U22.F12 103.39,97.05 v2(102.97,96.64)
THERM-: length 9.3
  TOP w0.102: v2(103.82,95.01) 103.82,94.09 103.34,93.61 103.34,93.2 103.59,92.95 104.2,92.95 104.61,92.54 104.61,91.86 107,89.47 TP11.1
  BOTTOM w0.102: U22.E12 103.82,95.8 v2(103.82,95.01)
TP_A47: length 4.3
  BOTTOM w0.102: TP60.1 74.48,85.05 74.48,82.73 75.43,81.78 U24.A47
TP_AT1: length 4.4
  BOTTOM w0.102: TP73.1 101.93,63.88 98.13,63.88 U24.AT1
TP_AT2: length 3.8
  BOTTOM w0.102: U24.AT2 97.7,64.1 100.83,64.1 TP72.1
TP_AU1: length 5.2
  BOTTOM w0.102: TP75.1 102.68,63.44 98.82,63.44 98.54,63.16 U24.AU1
TP_AU2: length 6.6
  BOTTOM w0.102: U24.AU2 97.41,63.16 97.75,63.49 98.49,63.49 98.65,63.65 102.95,63.65 TP74.1
TP_AV1: length 4.5
  BOTTOM w0.102: U24.AV1 98.18,62.63 98.78,62.63 99.15,63 101.51,63 101.97,62.55 TP76.1
TP_AV2: length 6.8
  BOTTOM w0.102: U24.AV2 97.76,62.86 98.63,62.86 98.98,63.22 101.93,63.22 103.26,61.89 TP77.1
TP_B47: length 7.6
  BOTTOM w0.102: TP58.1 75.35,86.52 74.81,85.99 74.81,82.67 75.76,81.72 75.76,81.08 75.6,80.92 U24.B47
TP_BW11: length 1.5
  TOP w0.102: TP19.1 92.1,52.4 v2(92.64,52.4)
  BOTTOM w0.102: v2(92.64,52.4) 93,52.4 U24.BW11
TP_C1: length 6.3
  BOTTOM w0.102: TP62.1 100.77,84.36 98.41,82 98.41,80.61 U24.C1
TP_CA11: length 2.4
  TOP w0.102: v2(92.65,51.82) 92.59,51.75 TP20.1
  BOTTOM w0.102: U24.CA11 92.93,51.87 92.7,51.87 v2(92.65,51.82)
TP_CM33: length 1.7
  TOP w0.102: TP21.1 82.61,46.34 v2(82.99,46.34)
  BOTTOM w0.102: v2(82.99,46.34) 82.89,46.34 82.88,46.36 U24.CM33
TP_CT32: length 3.2
  TOP w0.102: v2(83.4,43.97) 83.63,44.2 83.63,44.64 82.68,45.58 TP23.1
  BOTTOM w0.102: v2(83.4,43.97) 83.35,44.02 82.87,44.02 U24.CT32
TP_CV32: length 2.5
  TOP w0.102: v2(83.48,43.01) 83.4,43.01 82.51,43.9 TP27.1
  BOTTOM w0.102: v2(83.48,43.01) 83.36,43.13 82.85,43.13 U24.CV32
TP_DB10: length 13
  TOP w0.079: TP30.1 97.85,41.18
  TOP w0.102: 97.85,41.18 97.98,41.31 97.98,42.15 97.7,42.43 94.32,42.43 93.91,42.02 93.91,41.26 93.15,40.5 91.37,40.5 90.89,40.98 v2(90.89,41.11)
  BOTTOM w0.079: U24.DB10 93.45,41.29 93,41.29 92.85,41.44 91.91,41.44 91.58,41.11 v2(90.89,41.11)
TP_DH49: length 7.2
  BOTTOM w0.102: TP79.1 68.77,37.96 69.15,38.34 73.34,38.34 73.5,38.18 74.27,38.18 U24.DH49
TP_DL8: length 1.5
  TOP w0.102: v2(94.93,37.04) 94.93,37.02 TP33.1
  BOTTOM w0.102: v2(94.93,37.04) 94.6,36.72 U24.DL8
TP_DP1: length 6.9
  BOTTOM w0.102: TP80.1 103.01,35.17 102.37,34.53 101.41,34.53 101.26,34.38 98.91,34.38 98.05,35.23 U24.DP1
TP_DP2: length 6.3
  BOTTOM w0.102: TP81.1 102.83,34.3 101.56,34.3 101.43,34.17 98.84,34.17 98,35.01 97.73,35.01 U24.DP2
TP_DV3: length 9.6
  BOTTOM w0.079: U24.DV3 96.65,33.14 96.65,32.47 97.04,32.08 97.22,32.08
  BOTTOM w0.102: 97.22,32.08 99.23,32.08 100.88,30.43 100.88,29.7 101.58,28.99 102.35,28.99 102.91,29.55 TP84.1
TP_DV4: length 8
  BOTTOM w0.079: 97.34,31.69 96.96,31.69 96.37,32.28 96.25,32.28 95.91,32.62 95.91,33.31 96.19,33.59 U24.DV4
  BOTTOM w0.102: 97.34,31.69 98.98,31.69 100.42,30.24 100.42,29.17 TP87.1
TP_DV6: length 11.3
  BOTTOM w0.079: U24.DV6 95.62,33.18 95.31,32.88 95.31,32.5 95.46,32.35 95.71,32.35 96.11,31.95 96.23,31.95 96.95,31.23 96.96,31.23
  BOTTOM w0.102: TP93.1 100.57,26.73 100.57,27.98 99.96,28.59 99.96,30.05 98.79,31.23 96.96,31.23
