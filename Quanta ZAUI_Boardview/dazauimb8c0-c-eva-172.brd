# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IN_D0#_R: length 14
  TOP w0.102: R155.2 v1(26.94,74.92)
  BOTTOM w0.102: v1(26.94,74.92) 26.94,75.28 26.83,75.38 26.6,75.38 25.35,76.63 22.78,76.63 22.5,76.35 19.66,76.35 18.63,75.32 18.04,75.32 D32.2 17.44,75.32 17.28,75.32 16.71,74.74 15.89,74.74 15.78,74.64 C572.1
IN_D0_R: length 14
  TOP w0.102: R148.2 v1(26.94,76.06)
  BOTTOM w0.102: v1(26.94,76.06) 26.94,75.7 26.83,75.6 26.69,75.6 25.44,76.85 22.69,76.85 22.41,76.57 19.57,76.57 18.54,75.54 18.04,75.54 D31.2 17.44,75.54 17.19,75.54 16.62,74.96 15.9,74.96 15.78,75.08 C571.1
IN_D1: length 122.9
  TOP w0.102: C200.1 26,77.73 26.23,77.5 27.41,77.5 v1(27.62,77.71)
  IN3 w0.089: v1(27.62,77.71) 27.62,77.61 27.44,77.43 26.75,77.43 25.77,78.41 25.77,81.41 26.46,82.1 26.46,82.58 26.64,82.76 28.1,82.76 28.68,83.34 28.68,84.83 30.36,86.52 30.36,90.43 32.07,92.13 32.07,94.6 33.36,95.9 45.3,95.9 45.45,96.05 49.8,96.05 50.82,97.06 52.68,97.06 53.7,96.05 54.98,96.05 55.59,96.66 60.16,96.66 61.4,97.9 65.94,97.9 66.27,97.57 69.7,97.57 70.89,96.38 75.08,96.38 76.5,94.96 76.5,94.64 79.5,91.64 79.5,91.23 81.64,89.09 87.23,89.09 89.37,86.95 89.37,81.75 89.57,81.55 89.57,81.29 92.44,78.42 92.44,71.78 93.42,70.8 95.38,70.8 97.9,68.28 97.9,67.7 99.23,66.38 100.53,66.38 100.73,66.58 100.73,66.85 v2(100.93,67.04)
  BOTTOM w0.079: v2(100.93,67.04) 100.74,66.85 100.74,66.69 100.56,66.51 99.35,66.51 99.2,66.67 99.2,67.73 98.84,68.08 98.84,68.74 98.19,69.39 97.73,69.39 97.69,69.35 97.69,69.19 97.81,69.07 98.01,69.07 U24.AE1
IN_D1#: length 122.9
  TOP w0.102: v1(27.62,77.08) 27.41,77.28 26.15,77.28 26,77.13 R142.1
  IN3 w0.089: v2(100.34,67.04) 100.53,66.85 100.53,66.67 100.44,66.58 99.31,66.58 98.11,67.79 98.11,68.36 95.46,71 93.51,71 92.64,71.87 92.64,78.51 89.77,81.38 89.77,81.63 89.57,81.83 89.57,87.03 87.31,89.29 81.72,89.29 79.7,91.31 79.7,91.73 76.7,94.73 76.7,95.05 75.16,96.58 70.98,96.58 69.78,97.78 66.36,97.78 66.03,98.11 61.32,98.11 60.07,96.86 55.5,96.86 54.89,96.25 53.78,96.25 52.77,97.27 50.73,97.27 49.72,96.25 45.37,96.25 45.22,96.1 33.28,96.1 31.86,94.69 31.86,92.22 30.16,90.51 30.16,86.6 28.47,84.91 28.47,83.42 28.02,82.97 26.55,82.97 26.25,82.67 26.25,82.18 25.56,81.49 25.56,78.33 26.66,77.23 27.47,77.23 v1(27.62,77.08)
  BOTTOM w0.079: U24.AE2 97.52,69.24 97.52,69.42 97.66,69.56 98.26,69.56 99.01,68.81 99.01,68.15 99.37,67.8 99.37,66.74 99.42,66.68 100.49,66.68 100.57,66.76 100.57,66.81 v2(100.34,67.04)
IN_D1#_R: length 13
  TOP w0.102: R142.2 v1(26.94,76.82)
  BOTTOM w0.102: v1(26.94,76.82) 26.94,77.18 26.83,77.28 22.29,77.28 22.12,77.11 18.57,77.11 18.1,76.65 16.87,76.65 D30.2 16.27,76.65 15.89,76.65 15.78,76.54 C570.1
IN_D1_R: length 13
  TOP w0.102: R131.2 v1(26.94,77.96)
  BOTTOM w0.102: C569.1 15.78,76.97 15.88,76.87 16.27,76.87 D29.2 16.87,76.87 18.01,76.87 18.48,77.33 22.03,77.33 22.2,77.5 26.83,77.5 26.94,77.6 v1(26.94,77.96)
IN_D2: length 119.3
  TOP w0.102: v1(27.62,79.62) 27.62,79.49 27.54,79.41 26.1,79.41 26,79.51 C197.1
  IN3 w0.089: v1(27.62,79.62) 27.84,79.4 28.24,79.4 28.79,79.95 28.79,82.59 29.2,83 29.2,84.67 30.8,86.27 30.8,90.28 32.56,92.04 32.56,94.49 33.57,95.5 44.51,95.5 45.05,94.96 47.66,94.96 48.35,95.64 50.09,95.64 50.96,96.51 52.68,96.51 53.55,95.64 57.33,95.64 57.94,96.25 61.5,96.25 62.39,97.14 63.56,97.14 63.99,96.71 64.95,96.71 65.26,97.01 69.28,97.01 70.3,95.99 74.92,95.99 75.96,94.95 75.96,94.61 78.71,91.86 78.71,91.46 81.49,88.68 86.45,88.68 88.91,86.22 88.91,81.6 89.17,81.35 89.17,81.06 91.88,78.35 91.88,69.58 94.14,67.32 97.32,67.32 99.3,65.34 100.37,65.34 100.51,65.48 100.51,65.61 v2(100.32,65.8)
  BOTTOM w0.079: U24.AE5 96.4,68.83 97,68.83 97.25,68.68 97.58,68.68 97.65,68.73 97.8,68.73 97.9,68.68 98.34,68.68 98.5,68.53 98.5,67.89 98.84,67.54 98.84,66.53 99.2,66.16 100.47,66.16 100.52,66.11 100.52,66 v2(100.32,65.8)
IN_D2#: length 119.3
  TOP w0.102: C198.1 26,79.03 26.15,79.19 27.41,79.19 v1(27.62,78.98)
  IN3 w0.089: v2(100.9,65.8) 100.71,65.61 100.71,65.4 100.45,65.14 99.22,65.14 97.23,67.12 94.06,67.12 91.68,69.5 91.68,78.26 88.96,80.98 88.96,81.27 88.71,81.52 88.71,86.13 86.36,88.48 81.4,88.48 78.51,91.38 78.51,91.77 75.75,94.52 75.75,94.86 74.83,95.78 70.22,95.78 69.19,96.81 65.34,96.81 65.04,96.51 63.91,96.51 63.48,96.94 62.47,96.94 61.58,96.05 58.03,96.05 57.42,95.44 53.46,95.44 52.6,96.3 51.04,96.3 50.18,95.44 48.43,95.44 47.75,94.75 44.97,94.75 44.42,95.3 33.65,95.3 32.76,94.41 32.76,91.96 31,90.2 31,86.19 29.4,84.59 29.4,82.92 28.99,82.51 28.99,79.86 28.33,79.2 27.84,79.2 v1(27.62,78.98)
  BOTTOM w0.079: U24.AE3 96.9,69.26 96.96,69.26 97.07,69.15 97.07,69.01 97.13,68.95 97.3,68.85 97.53,68.85 97.6,68.9 97.84,68.9 97.94,68.85 98.41,68.85 98.66,68.6 98.66,67.96 99.01,67.61 99.01,66.59 99.27,66.33 100.54,66.33 100.69,66.18 100.69,66.01 v2(100.9,65.8)
IN_D2#_R: length 13.5
  TOP w0.102: R123.2 v1(26.94,78.73)
  BOTTOM w0.102: v1(26.94,78.73) 26.94,79.09 26.83,79.19 23.3,79.19 22.66,79.82 20.21,79.82 18.94,78.55 18.04,78.55 D28.2 17.44,78.55 15.88,78.55 15.78,78.45 C568.1
IN_D2_R: length 13.5
  TOP w0.102: R119.2 v1(26.94,79.87)
  BOTTOM w0.102: v1(26.94,79.87) 26.94,79.51 26.83,79.41 23.39,79.41 22.75,80.04 20.12,80.04 18.85,78.77 18.04,78.77 D27.2 17.44,78.77 15.88,78.77 15.78,78.87 C567.1
INPUT3VSEL: length 5.9
  BOTTOM w0.079: 71.57,33.51 71.58,33.51 73.63,35.57 74.1,35.57 74.23,35.7 U24.DN49
  BOTTOM w0.102: 71.57,33.51 70.83,32.78 R706.2 R705.2
INT_AMIC-VREFO: length 3.4
  BOTTOM w0.102: U30.27 203.26,37 v1(203.08,37.17) 203.08,37.55 203.16,37.63 R686.2 C620.1
INT_EDP_AUXN: length 68.7
  TOP w0.102: v2(64.6,102.94) 64.4,103.14 64.4,103.33 63.84,103.9 63.84,106.59 63.77,106.67 63.77,108.72 63.52,108.96 63.31,108.96 63.11,109.16 C43.2
  IN3 w0.089: v2(64.6,102.94) 64.86,102.68 65.29,102.68 65.59,102.98 66.6,102.98 67.74,101.84 71.34,101.84 73.04,100.14 77.25,100.14 78.03,99.36 78.07,99.36 79.69,97.74 79.69,97.5 81.6,95.59 81.6,95.29 82.07,94.82 82.27,94.82 82.79,94.3 85.18,94.3 85.89,93.59 89.55,93.59 92.72,90.41 92.72,89.38 94.65,87.45 94.65,82.72 97.93,79.45 97.93,78.28 98.44,77.77 98.44,73.44 99.38,72.5 100.5,72.5 100.71,72.29 100.71,72.08 v2(100.9,71.89)
  BOTTOM w0.079: U24.W4 96.62,72.16 96.91,72.45 97.2,72.45 97.41,72.24 98.5,72.24 98.68,72.43 100.54,72.43 100.72,72.25 100.72,72.07 v2(100.9,71.89)
INT_EDP_AUXN_C: length 10.6
  TOP w0.102: R18.1 61.27,109.01 v1(61.73,109.01) 61.89,108.85 62.08,108.85 62.33,109.1 C43.1
  BOTTOM w0.102: v1(61.73,109.01) 61.62,108.9 60.95,108.9 60.81,109.04 55.22,109.04 54.35,108.17 CN2.22
INT_EDP_AUXP: length 68.7
  TOP w0.102: C53.2 63.11,108.61 63.26,108.75 63.43,108.75 63.55,108.63 63.55,106.58 63.63,106.5 63.63,103.81 64.18,103.25 64.18,103.1 v2(64.02,102.94)
  IN3 w0.089: v2(64.02,102.94) 64.48,102.48 65.37,102.48 65.68,102.78 66.52,102.78 67.66,101.64 71.26,101.64 72.96,99.94 77.16,99.94 77.95,99.15 77.99,99.15 79.49,97.66 79.49,97.41 81.39,95.51 81.39,95.2 81.98,94.61 82.18,94.61 82.71,94.09 85.09,94.09 85.8,93.38 89.46,93.38 92.52,90.33 92.52,89.29 94.45,87.36 94.45,82.64 97.72,79.36 97.72,78.19 98.23,77.68 98.23,73.36 99.29,72.3 100.42,72.3 100.51,72.21 100.51,72.08 v2(100.32,71.89)
  BOTTOM w0.079: U24.W3 96.94,72.16 96.86,72.08 96.86,71.94 96.96,71.84 97.22,71.84 97.45,72.08 98.57,72.08 98.75,72.26 100.47,72.26 100.55,72.18 100.55,72.01 100.44,71.89 v2(100.32,71.89)
INT_EDP_AUXP_C: length 11
  TOP w0.102: R22.1 61.11,108.44 61.24,108.57 61.51,108.57 v1(61.71,108.37) 61.88,108.54 62.08,108.54 62.33,108.29 C53.1
  BOTTOM w0.102: v1(61.71,108.37) 61.71,108.43 61.45,108.69 60.86,108.69 60.72,108.83 55.31,108.83 54.57,108.08 54.57,107.86 54.63,107.8 54.76,107.8 54.85,107.71 CN2.23
INT_EDP_TXN0: length 78.7
  IN3 w0.089: v1(63.82,101.09) 64.03,101.31 64.16,101.31 64.22,101.24 64.22,100.67 64.53,100.37 70.79,100.37 72.9,98.26 75.84,98.26 77.29,96.81 78.37,96.81 78.93,96.25 78.93,94.9 81.72,92.1 81.72,91.68 82.38,91.02 88.27,91.02 88.5,90.79 89.92,90.79 90.92,89.79 90.92,88.8 92.26,87.46 92.26,82.71 94.89,80.08 94.89,79.67 95.68,78.89 95.68,78.23 97.01,76.9 97.01,72.8 98.05,71.76 98.05,70.78 98.55,70.28 100.4,70.28 100.51,70.18 100.51,70.06 v2(100.32,69.87)
  BOTTOM w0.079: v2(100.32,69.87) 100.33,69.87 100.52,70.06 100.52,70.23 100.45,70.3 99.29,70.3 99.1,70.5 99.1,71.15 98.85,71.4 98.49,71.4 98.25,71.15 97.9,71.15 97.82,71.19 97.69,71.19 97.59,71.16 97.31,71.16 97.16,71.21 97.03,71.21 97.03,71.21 96.81,71.12 96.54,71.12 96.35,71.3 96.35,71.52 96.28,71.6 U24.Y5
  BOTTOM w0.102: C537.2 54.41,103.77 54.41,103.55 54.81,103.15 55.47,103.15 58,100.62 61.33,100.62 61.7,100.99 61.7,102.53 61.87,102.7 63.08,102.7 63.31,102.47 63.31,101.6 v1(63.82,101.09)
INT_EDP_TXN0_C: length 3.5
  BOTTOM w0.102: C537.1 54.4,104.77 54.56,104.93 54.56,105.2 54.49,105.27 54.24,105.27 53.07,106.44 53.07,106.57 52.85,106.79 CN2.19
INT_EDP_TXN1: length 76.3
  IN3 w0.089: v2(100.32,70.88) 100.39,70.88 100.51,70.99 100.51,71.19 100.42,71.28 99.45,71.28 97.62,73.1 97.62,77.18 97.09,77.71 97.09,78.85 96.71,79.23 96.71,79.51 93.76,82.46 93.76,84.81 92.98,85.6 92.98,87.76 91.73,89 91.73,90 90.3,91.43 88.9,91.43 88.52,91.81 82.87,91.81 80.25,94.42 80.25,95.79 78.6,97.45 77.57,97.45 77.07,97.95 77.07,98.5 77.2,98.62 77.2,99.05 76.93,99.32 72.68,99.32 71,101 66.96,101 66.28,101.67 65.52,101.67 65.14,101.29 v1(65.14,101.24)
  BOTTOM w0.079: v2(100.32,70.88) 100.44,70.88 100.54,70.98 100.54,71.21 100.39,71.36 99.39,71.36 99.01,71.74 98.2,71.74 U24.Y1
  BOTTOM w0.102: C535.2 52.39,104.18 52.67,104.18 52.78,104.06 52.78,103.02 53.27,102.53 55.14,102.53 57.69,99.97 62.89,99.97 63.3,100.38 64.26,100.38 64.5,100.62 64.5,101.1 64.83,101.43 64.95,101.43 v1(65.14,101.24)
INT_EDP_TXN1_C: length 3.5
  BOTTOM w0.102: CN2.16 51.35,106.69 51.53,106.5 51.53,105.59 51.92,105.21 52.5,105.21 52.6,105.1 52.6,104.93 52.45,104.77 C535.1
INT_EDP_TXN2: length 82.9
  IN3 w0.089: v1(65.73,104.33) 65.96,104.1 67.02,104.1 67.14,104.23 68.06,104.23 69.73,102.55 71.49,102.55 73.26,100.77 77.46,100.77 78.28,99.95 78.32,99.95 79.81,98.47 80.77,98.47 82.33,96.91 82.33,96.05 83.07,95.31 84.64,95.31 84.81,95.49 85.28,95.49 86.12,94.65 89.63,94.65 93.46,90.82 93.46,89.52 95.34,87.64 95.34,82.93 99.88,78.38 99.88,77.78 99.22,77.12 99.22,74.08 99.57,73.73 100.49,73.73 100.73,73.49 100.73,73.33 v2(100.93,73.14)
  BOTTOM w0.079: v2(100.93,73.14) 100.74,72.95 100.74,72.8 100.54,72.6 98.6,72.6 98.4,72.41 97.92,72.41 97.61,72.72 U24.V2
  BOTTOM w0.102: v1(65.73,104.33) 65.73,103.73 65.84,103.63 65.84,102.21 66.33,101.71 66.33,100.75 65.18,99.59 63.52,99.59 63.27,99.34 57.44,99.34 55.42,101.36 51.98,101.36 51.03,102.31 51.03,103.19 C533.2
INT_EDP_TXN2_C: length 3
  BOTTOM w0.102: CN2.13 49.85,106.67 49.98,106.54 49.98,106.15 50.61,105.52 50.61,104.91 50.47,104.77 C533.1
INT_EDP_TXN3: length 86.2
  IN3 w0.089: v1(48.65,104.23) 48.76,104.23 48.88,104.35 48.88,104.55 48.8,104.63 47.81,104.63 47.43,104.25 47.43,103.62 48.4,102.65 48.4,101.64 48.88,101.15 51.32,101.15 53.07,102.91 61.83,102.91 64.45,105.52 67.61,105.52 69.81,103.32 71.96,103.32 73.42,101.87 74.59,101.87 75.07,101.38 77.74,101.38 80.05,99.07 81.1,99.07 83.02,97.15 83.02,96.26 83.36,95.92 84.28,95.92 84.56,96.2 88.56,96.2 89.14,95.62 89.6,95.62 96.33,88.89 96.33,84.82 97.01,84.14 97.01,83.03 100.71,79.33 100.71,78.48 101.26,77.94 101.26,76.62 100.95,76.31 100.95,75.35 100.71,75.11 100.71,74.32 v2(100.9,74.13)
  BOTTOM w0.079: v2(100.9,74.13) 100.54,73.77 100.36,73.77 100.18,73.6 99.66,73.6 99.42,73.36 99.42,73.29 99.1,72.96 98.34,72.96 98.26,73.05 98.02,73.05 97.81,72.93 97.59,72.93 97.51,72.98 97.5,72.98 97.3,72.98 97.15,72.91 96.93,72.89 U24.V3
  BOTTOM w0.102: C530.2 48.43,105.14 48.65,105.14 48.78,105.02 48.78,104.36 v1(48.65,104.23)
INT_EDP_TXN3_C: length 1.7
  BOTTOM w0.102: C530.1 48.6,106.08 48.6,106.29 48.51,106.38 48.51,106.54 48.35,106.7 CN2.10
INT_EDP_TXP0: length 78.7
  IN3 w0.089: v1(63.82,101.73) 64.03,101.51 64.24,101.51 64.43,101.33 64.43,100.76 64.61,100.57 70.88,100.57 72.99,98.46 75.93,98.46 77.38,97.01 78.45,97.01 79.13,96.34 79.13,94.98 81.93,92.19 81.93,91.76 82.47,91.22 88.35,91.22 88.58,90.99 90,90.99 91.12,89.88 91.12,88.89 92.47,87.54 92.47,82.79 95.09,80.17 95.09,79.76 95.88,78.97 95.88,78.32 97.22,76.98 97.22,72.88 98.25,71.85 98.25,70.87 98.64,70.48 100.49,70.48 100.71,70.26 100.71,70.06 v2(100.9,69.87)
  BOTTOM w0.079: v2(100.9,69.87) 100.89,69.87 100.69,70.07 100.69,70.3 100.52,70.47 99.36,70.47 99.26,70.57 99.26,71.22 98.92,71.56 98.42,71.56 98.18,71.32 97.94,71.32 97.86,71.36 97.65,71.36 97.56,71.33 97.34,71.33 97.19,71.38 97,71.38 96.77,71.29 96.6,71.29 96.52,71.37 96.52,71.51 96.61,71.6 U24.Y3
  BOTTOM w0.102: C538.2 54.75,103.99 54.63,103.87 54.63,103.64 54.9,103.36 55.56,103.36 58.09,100.84 61.24,100.84 61.48,101.08 61.48,102.62 61.78,102.92 63.17,102.92 63.52,102.56 63.52,102.02 v1(63.82,101.73)
INT_EDP_TXP0_C: length 3.5
  BOTTOM w0.102: C538.1 54.93,104.77 54.78,104.93 54.78,105.29 54.58,105.48 54.33,105.48 53.28,106.53 53.28,106.67 53.35,106.74 CN2.20
INT_EDP_TXP1: length 76.3
  IN3 w0.089: v2(100.9,70.88) 100.71,71.07 100.71,71.28 100.5,71.49 99.53,71.49 97.83,73.19 97.83,77.26 97.29,77.79 97.29,78.94 96.91,79.32 96.91,79.6 93.97,82.54 93.97,84.9 93.18,85.69 93.18,87.84 91.93,89.09 91.93,90.08 90.38,91.63 88.99,91.63 88.61,92.01 82.95,92.01 80.45,94.51 80.45,95.88 78.68,97.65 77.66,97.65 77.28,98.03 77.28,98.41 77.4,98.54 77.4,99.14 77.02,99.52 72.77,99.52 71.09,101.21 67.04,101.21 66.37,101.88 v1(65.14,101.88)
  BOTTOM w0.079: U24.Y2 97.72,71.91 99.08,71.91 99.46,71.53 100.46,71.53 100.71,71.28 100.71,71.07 v2(100.9,70.88)
  BOTTOM w0.102: v1(65.14,101.88) 64.9,101.64 64.74,101.64 64.29,101.19 64.29,100.71 64.17,100.6 63.21,100.6 62.8,100.19 57.78,100.19 55.23,102.74 53.36,102.74 53,103.1 53,103.76 C536.2
INT_EDP_TXP1_C: length 3.5
  BOTTOM w0.102: C536.1 52.97,104.77 52.82,104.92 52.82,105.19 52.59,105.42 52.01,105.42 51.75,105.68 51.75,106.56 51.85,106.66 CN2.17
INT_EDP_TXP2: length 82.8
  IN3 w0.089: v2(100.34,73.14) 100.42,73.14 100.53,73.25 100.53,73.4 100.4,73.53 99.48,73.53 99.02,73.99 99.02,77.2 99.68,77.86 99.68,78.29 95.13,82.84 95.13,87.56 93.25,89.44 93.25,90.74 89.55,94.45 86.03,94.45 85.19,95.29 84.9,95.29 84.72,95.11 82.98,95.11 82.13,95.96 82.13,96.83 80.69,98.27 79.72,98.27 78.24,99.75 78.19,99.75 77.37,100.57 73.18,100.57 71.4,102.35 69.65,102.35 67.97,104.02 67.23,104.02 67.1,103.9 65.52,103.9 v1(65.09,104.33)
  BOTTOM w0.079: v2(100.34,73.14) 100.43,73.14 100.57,73 100.57,72.87 100.47,72.77 98.53,72.77 98.33,72.58 98.13,72.58 98.05,72.66 U24.V1
  BOTTOM w0.102: v1(65.09,104.33) 65.52,103.9 65.52,103.64 65.62,103.54 65.62,102.12 66.11,101.62 66.11,100.84 65.09,99.81 63.43,99.81 63.18,99.55 57.53,99.55 55.51,101.57 52.07,101.57 51.24,102.4 51.24,103.28 50.66,103.86 50.66,104.18 50.79,104.3 50.93,104.3 C534.2
INT_EDP_TXP2_C: length 3
  BOTTOM w0.102: C534.1 51,104.77 50.82,104.95 50.82,105.61 50.19,106.24 50.19,106.51 50.35,106.67 CN2.14
INT_EDP_TXP3: length 86.3
  IN3 w0.089: v1(49.29,104.23) 49.08,104.44 49.08,104.63 48.88,104.84 47.73,104.84 47.23,104.34 47.23,103.53 48.19,102.57 48.19,101.55 48.8,100.95 51.4,100.95 53.16,102.7 61.92,102.7 64.54,105.32 67.52,105.32 69.73,103.12 71.88,103.12 73.33,101.66 74.5,101.66 74.98,101.18 77.65,101.18 79.97,98.86 81.02,98.86 82.82,97.06 82.82,96.18 83.27,95.72 84.36,95.72 84.64,96 88.47,96 89.06,95.41 89.51,95.41 96.12,88.8 96.12,84.74 96.81,84.05 96.81,82.94 100.51,79.25 100.51,78.4 101.05,77.85 101.05,76.7 100.75,76.4 100.75,75.43 100.51,75.19 100.51,74.32 v2(100.32,74.13)
  BOTTOM w0.079: U24.V5 96.48,73.03 97.1,73.08 97.26,73.15 97.54,73.15 97.61,73.11 97.63,73.1 97.77,73.1 97.98,73.21 98.33,73.21 98.41,73.13 99.03,73.13 99.26,73.36 99.26,73.43 99.59,73.76 100.11,73.76 100.32,73.97 v2(100.32,74.13)
  BOTTOM w0.102: v1(49.29,104.23) 49,104.52 49,104.69 C531.2
INT_EDP_TXP3_C: length 1.7
  BOTTOM w0.102: C531.1 48.81,106.08 48.81,106.38 48.72,106.47 48.72,106.61 48.85,106.74 CN2.11
INT_HDMICLK+_OUT: length 3.6
  TOP w0.102: U3.10 18.12,79.72 17.98,79.86 17.67,79.86 17.07,80.46 15.94,80.46 15.78,80.3 R118.1
INT_HDMICLK-_OUT: length 3.6
  TOP w0.102: R115.1 15.78,80.83 15.94,80.68 17.16,80.68 17.76,80.08 17.98,80.08 18.12,80.22 U3.9
INT_HDMITX0N_OUT: length 4.7
  TOP w0.102: R150.1 15.78,75.08 15.88,74.98 16.07,74.98 16.51,75.41 16.51,76.2 17.09,76.78 17.45,76.78 17.75,77.08 17.98,77.08 18.12,77.22 U3.15
INT_HDMITX0P_OUT: length 4.8
  TOP w0.102: U3.16 18.12,76.72 17.98,76.86 17.84,76.86 17.54,76.57 17.18,76.57 16.72,76.11 16.72,75.32 16.16,74.76 15.9,74.76 15.78,74.64 R160.1
INT_HDMITX1N_OUT: length 3.9
  TOP w0.102: U3.13 18.12,78.22 17.98,78.08 17.73,78.08 17.22,77.57 16.77,77.57 16.06,76.87 15.88,76.87 15.78,76.97 R137.1
INT_HDMITX1P_OUT: length 3.9
  TOP w0.102: U3.14 18.12,77.72 17.98,77.86 17.82,77.86 17.31,77.36 16.86,77.36 16.15,76.65 15.89,76.65 15.78,76.54 R145.1
INT_HDMITX2N_OUT: length 3.6
  TOP w0.102: R122.1 15.78,78.88 15.89,78.77 16.62,78.77 16.93,79.08 17.98,79.08 18.12,79.22 U3.11
INT_HDMITX2P_OUT: length 3.6
  TOP w0.102: U3.12 18.12,78.72 17.98,78.86 17.02,78.86 16.71,78.55 15.89,78.55 15.78,78.44 R130.1
INTRUDER#: length 8.1
  BOTTOM w0.102: U24.DR47 75.48,34.9 75.26,34.9 75.08,34.73 74.17,34.73 74.05,34.61 73.19,34.61 72.4,33.82 72.4,32.47 71.51,31.58 R713.1 C642.2 R712.2
ISEN1N: length 33.2
  TOP w0.178: v1(139.97,59.57) 139.99,59.57 140.26,59.3 PR49.1 139.85,58.78 139.68,58.94 139.45,58.94 PC51.1 138.85,59.09 PR48.2
  IN3 w0.102: v1(139.97,59.57) 139.61,59.21 139.45,59.21 139.09,59.57 139.09,60.38 136.95,62.52 133.59,62.52 125.21,70.9 120.89,70.9 120.58,70.6 120.58,68.59 120.84,68.34 v1(120.84,68.01)
  BOTTOM w0.178: v1(120.84,68.01) 120.84,67.47 120.41,67.04 PR164.2
  BOTTOM w0.381: PC186.1 140.75,60.04 140.28,59.57 v1(139.97,59.57)
ISEN1P: length 31.8
  IN3 w0.102: v1(140.95,58.44) 140.51,58.44 139.95,59.01 139.36,59.01 138.89,59.48 138.89,60.3 136.89,62.3 133.5,62.3 125.1,70.7 120.97,70.7 120.79,70.51 120.79,68.68 121.46,68.01 v1(121.47,68.01)
  BOTTOM w0.178: PR171.2 142.65,59.22 142.15,58.71 141.22,58.71 v1(140.95,58.44) ; v1(121.47,68.01) 121.39,67.93 PR165.2
ISEN1P_1: length 1.7
  BOTTOM w0.178: PR171.1 141.68,59.04 141.37,59.04 141.35,59.02 140.81,59.02 140.63,58.84 PR174.2
ISEN2N: length 59.9
  TOP w0.178: 141.22,59.5 141.3,59.5 141.54,59.26 PR50.1 141.91,58.7 142.08,58.87 PR51.2 ; 141.22,59.5 141.36,59.64 141.74,59.64 141.92,59.83 PC49.1 ; 141.22,59.5 v1(141.16,59.5)
  IN3 w0.102: v1(141.16,59.5) 140.94,59.72 140.94,60.55 140.35,61.15 139.67,61.15 137.32,63.49 134.04,63.49 121.96,75.58 115.5,75.58 114.74,74.81 114.74,67.78 115.55,66.98 115.55,59.12 118.08,56.59 119.65,56.59 119.9,56.35 119.9,56.34 v1(119.87,56.32)
  BOTTOM w0.178: PR182.2 119.91,56.28 v1(119.87,56.32)
  BOTTOM w0.381: v1(141.16,59.5) 141.22,59.5 141.71,59.99 PC187.1
ISEN2P: length 59.2
  IN3 w0.089: 137.27,63.26 137.23,63.3 133.91,63.3 133.64,63.56
  IN3 w0.102: v1(141.13,57.46) 141.57,57.9 141.57,58.66 141.17,59.06 140.98,59.06 140.74,59.3 140.74,60.47 140.26,60.95 139.59,60.95 137.27,63.26 ; v1(120.59,56.32) 120.61,56.34 120.61,56.35 120.12,56.83 118.22,56.83 115.81,59.24 115.81,67 114.95,67.87 114.95,74.73 115.59,75.37 121.83,75.37 133.64,63.56
  BOTTOM w0.178: v1(141.13,57.46) 141.58,57.91 PR175.2 ; PR183.2 120.64,56.27 v1(120.59,56.32)
ISEN2P_1: length 2.1
  BOTTOM w0.102: v1(143.44,58.48) 143.2,58.24 PR175.1
  BOTTOM w0.178: PR175.1 142.36,57.74 142.35,57.73 PR176.2
ISOLATEB: length 5.9
  TOP w0.102: U1.20 47.51,105.2 47.64,105.32 49.11,105.32 R30.2 49.37,105.14 49.85,105.62 50.64,105.62 R31.1 51.14,105.65 v1(51.37,105.88)
IST_TP_0: length 2.2
  TOP w0.102: v1(93.48,58.83) 92.71,58.83 v2(92.62,58.91) 92.31,58.61 R199.2
  BOTTOM w0.114: v2(92.62,58.91) 92.72,59.02 93.1,59.02 U24.BF11
IST_TP_1: length 1.4
  TOP w0.102: v2(92.52,60.06) 92.52,59.9 92.24,59.62 R197.1
  BOTTOM w0.114: U24.BD11 93.07,59.96 92.62,59.96 v2(92.52,60.06)
IST_TRIG_0: length 1.7
  TOP w0.102: v2(92.8,59.52) 92.62,59.52 92.27,59.17 R197.2
  BOTTOM w0.114: U24.BE10 93.51,59.52 v2(92.8,59.52)
IST_TRIG_1: length 2.5
  TOP w0.102: v1(93.13,57.59) 93.13,57.67 v2(92.62,58.18) 92.6,58.16 R199.1
  BOTTOM w0.114: U24.BF10 92.94,58.5 v2(92.62,58.18)
JTAG_TCK: length 6.3
  BOTTOM w0.102: U22.AE5 97.1,113.31 97.1,114.65 96.77,114.98 96.77,115.7 95.72,116.75 TP51.1
JTAG_TDI: length 6.1
  BOTTOM w0.102: U22.AE6 97.95,113.31 97.95,113.83 97.75,114.03 97.75,115.25 96.99,116.01 96.99,117.89 97.01,117.92 TP52.1
JTAG_TDO: length 6
  BOTTOM w0.102: U22.AF6 98.43,113.83 97.98,114.29 97.98,115.35 97.47,115.86 97.47,117.84 97.72,118.1 98.36,118.1 TP53.1
JTAG_TMS: length 8.9
  BOTTOM w0.102: U22.AD6 98.43,112.06 98.08,112.41 96.56,112.41 96.33,112.64 96.33,114.67 96.04,114.96 96.04,115.64 94.45,117.23 TP50.1
JTAG_TRST#: length 5.7
  BOTTOM w0.102: R508.1 94.67,118.87 94.88,118.65 94.88,117.16 96.44,115.59 96.44,114.93 96.73,114.65 U22.AG4
KB_BL_LED: length 19.3
  TOP w0.102: U13.113 190.85,29.09 190.64,28.89 190.38,28.89 189.65,28.15 188.77,28.15 188,27.38 188,26.76 187.72,26.48 187.44,26.48 186.93,25.97 186.93,25.06 187.35,24.65 189.17,24.65 189.33,24.48 189.68,24.48 190.58,23.58 192.77,23.58 193.61,22.74 193.61,21.35 v2(193.86,21.09)
  BOTTOM w0.102: v2(193.86,21.09) 193.94,21.09 194.65,20.38 v1(194.99,20.38) 196.06,20.38 Q44.2
KL_NO_EC: length 180.4
  TOP w0.102: v1(48.45,7.86) 47.99,8.32 v1(47.99,9.15) 47.99,9.28 47.28,10 PR122.2 ; PR96.2 142.18,27.16 142.48,27.16 142.96,26.68 142.96,26.25 144.77,24.45 144.77,24.04 144.97,23.84 144.97,23.44 145.16,23.24 145.16,19.48 143.95,18.27 v2(143.72,18.27) ; U13.70 198.01,17.78 197.55,18.24 196.97,18.24 196.73,18.48 v2(196.4,18.48)
  IN2 w0.089: v2(196.4,18.48) 196.12,18.76 193.66,18.76 192.91,18.02 191.63,18.02 190.45,19.2 188.1,19.2 187.52,18.62 186.69,18.62 186.03,19.28 180.91,19.28 180.47,19.72 179.23,19.72 178.78,19.27 176.19,19.27 175.6,19.86 173.6,19.86 173.4,19.66 170.88,19.66 170.5,19.28 170.22,19.28 170.15,19.21 170.15,18.93 169.64,18.41 161,18.41 160.75,18.67 155.05,18.67 154.58,19.14 151.26,19.14 150.14,18.02 143.98,18.02 v2(143.72,18.27) 143.72,18.38 143.6,18.5 137.35,18.5 136.97,18.88 126.77,18.88 126.49,18.6 122.36,18.6 122.21,18.76 121.73,18.76 120.49,17.52 114.22,17.52 112.35,15.66 110.32,15.66 109.67,15 92.9,15 91.84,13.95 91.84,13.57 88.32,10.04 87.92,10.04 87.82,9.94 84.17,9.94 81.12,13 75.54,13 74.84,13.7 v1(74.84,13.75)
  IN3 w0.089: v1(48.45,7.86) 48.07,8.24 48.07,8.88 48.8,9.61 48.8,11.52 49,11.71 52.7,11.71 53.79,12.79 54.43,12.79 55.27,13.64 58.28,13.64 58.85,13.07 60.41,13.07 61.24,13.89 69.98,13.89 70.25,14.16 74.38,14.16 74.79,13.75 v1(74.84,13.75)
L_SPK+: length 109.9
  IN2 w1.016: 114.67,14.44 115.58,15.35 181.19,15.35 181.41,15.14 182.42,15.14 183.94,13.61 189.24,13.61 189.99,12.86 199.63,12.86 200.87,14.11 202.4,14.11 203.41,15.12 203.41,18.15 204.48,19.21 204.48,21.42 205.95,22.9 206.99,22.9 209.21,25.12 209.21,27.7 208.11,28.79 208.11,30.16 207.86,30.42
  vias: v1(114.41,16.04) v1(114.68,13.78) v1(115.31,13.78) v1(209.1,32.93) v1(209.74,32.93)
L_SPK+_1:
  vias: v1(115.07,20.23) v1(115.71,20.23)
L_SPK-: length 113.6
  IN2 w1.016: 116.52,14.03 180.68,14.03 180.91,13.8 181.89,13.8 185.57,10.12 203.29,10.12 204.74,11.57 204.74,17.59 205.8,18.66 205.8,20.18 206.77,21.14 207.66,21.14 208.29,21.78 208.29,22.29 211.34,25.34 211.34,28.03 210.75,28.61 210.75,31.23
  vias: v1(116.04,13.78) v1(116.27,16.04) v1(116.67,13.78) v1(208.81,32.34) v1(209.44,32.32)
L_SPK-_1:
  vias: v1(116.75,19.59) v1(116.8,20.23)
LAD0_R: length 2.6
  BOTTOM w0.102: R830.2 193,16.95 192.7,17.26 191.85,17.26 191.47,16.88 CN9.58
LAD1: length 3
  BOTTOM w0.102: R836.2 192.85,13.58 191.54,14.88 CN9.66
LAD2: length 5
  BOTTOM w0.102: CN9.68 191.51,14.38 192.57,13.32 192.79,13.32 193.04,13.07 194.37,13.07 TP101.1
LAD3: length 3.6
  BOTTOM w0.102: TP100.1 193.36,12.43 192.72,13.07 192.47,13.07 191.65,13.88 CN9.70
LAN_AMBLED#: length 1.6
  TOP w0.102: U1.27 45.24,108.21 45.68,108.65 TP4.1
LAN_LED1: length 3.5
  TOP w0.102: TP2.1 46.35,110.13 46.35,108.45 46.09,108.19 45.78,108.19 45.64,108.05 U1.26
LAN_LED2: length 2.3
  TOP w0.102: U1.25 46.04,107.81 46.59,108.37 46.59,109 46.8,109.21 TP3.1
LAN_MCTG0: length 4.4
  TOP w0.102: v1(37.53,109.56) 37.93,109.16 v1(38.21,109.16)
  TOP w0.508: R11.2 v1(37.53,109.56)
  BOTTOM w0.508: U21.24 37.9,110.77 37.53,110.4 v1(37.53,109.56)
LAN_MCTG1: length 5.1
  TOP w0.508: R10.2 34.73,110.1 35.11,109.71 v1(35.11,108.85)
  BOTTOM w0.508: v1(35.11,108.85) 35.11,109.71 34.9,109.93 U21.21
LAN_MCTG2: length 4.3
  TOP w0.102: v1(31.9,108.9) v1(31.9,109.64)
  TOP w0.508: v1(31.9,109.64) 31.9,110.27 31.68,110.48 R8.2
  BOTTOM w0.508: U21.18 v1(31.9,109.64)
LAN_MCTG3: length 3.4
  TOP w0.508: R9.2 28.76,110.48 28.9,110.35 v1(28.9,109.64)
  BOTTOM w0.508: v1(28.9,109.64) U21.15
LAN_XTAL1: length 4.3
  TOP w0.102: R16.1 45.78,111.22 C33.2 45.53,111.24 44.85,111.92 44.85,113.05 Y1.1
LANPWR#: length 216
  TOP w0.102: R14.1 R5.2 57.2,111.99 v1(56.7,111.49) ; U13.16 182.02,22.18 181.9,22.06 181.11,22.06 180.88,21.83 v2(180.88,21.8)
  IN2 w0.089: v1(111.15,52.21) 110.42,52.21 106.95,55.68 105.07,55.68 103.45,57.29 103.45,60.35 104.47,61.37 104.47,62.78 104,63.25 104,74.79 99.76,79.03 97.71,79.03 96.31,80.43 95.74,81 94.89,81 90.33,85.56 87.77,85.56 86.11,87.22 85.3,87.22 85.05,87.46 85.05,90.13 88.15,93.23 88.15,97.88 86.35,99.68 84.06,99.68 82.73,101.01 81.02,101.01 80.07,101.97 75.93,101.97 74.53,103.36 70.22,103.36 66.53,107.06 66.53,108.15 63.95,110.72 63.95,110.99 63.46,111.49 62.35,111.49 62.16,111.3 56.9,111.3 v1(56.7,111.49) ; v2(180.88,21.8) 180.83,21.75 180.83,21.6 180.49,21.26 179.55,21.26 179.21,21.6 177.25,21.6 177.03,21.38 172.88,21.38 172.77,21.26 170.33,21.26 169.98,20.92 167.91,20.92 167.73,20.74 163.2,20.74 162.83,21.12 155.05,21.12 154.85,20.92 139.62,20.92 138.66,21.88 126.59,21.88 126.27,22.2 121.27,22.2 121.08,22.39 120,22.39 118.79,21.18 116.37,21.18 115.92,20.74 114.29,20.74 v1(113.75,20.2)
  IN3 w0.089: v1(111.15,52.21) 111.15,51.36 112.25,50.25 112.25,49.58 111.43,48.75 111.43,46.77 113.36,44.84 113.36,40.29 113.6,40.04 113.6,37.83 114.36,37.07 116.05,37.07 118.05,35.07 118.05,33.95 116.84,32.74 114.76,32.74 112.89,30.87 112.89,23.91 v1(113.04,23.76)
  BOTTOM w0.102: v1(113.75,20.2) 113.7,20.26 v1(113.7,21.68) 113.7,23.1 v1(113.04,23.76)
LCD_PRIVACY_PCH: length 4.5
  TOP w0.102: TP29.1 78.95,40.52 78.55,40.12 78.55,39.71 79.06,39.2 79.06,38.14 v2(79.49,37.71)
  BOTTOM w0.102: U24.DK38 79.82,37.37 v2(79.49,37.71)
LFRAME#_R: length 2
  BOTTOM w0.102: R832.2 192.26,15.1 191.48,15.88 CN9.62
LID#: length 380
  TOP w0.102: HE1.1 34.35,123.94 34.81,123.48 34.81,122.54 v2(34.99,122.36) ; v1(54.16,112.89) 53.53,112.25 53.53,109.37 53.11,108.95 52.13,108.95 51.7,108.52 51.52,108.52 50.91,107.91 50.91,107.39 R23.2 51.82,106.49 52.73,106.49 52.98,106.24 53.34,106.24 53.45,106.13 53.45,105.77 53.55,105.67 D1.1 ; v2(178.7,26.71) 179.41,27.42 180.53,27.42 180.91,27.8 R368.2 ; v1(17.71,38.59) 18.1,38.59 20.61,41.11 22.3,41.11 24.05,42.86 24.05,44.3 24.41,44.65 25.36,44.65 25.54,44.83 25.54,45.78 26.86,47.1 26.86,54.95 v1(24.93,56.88)
  IN2 w0.089: v1(56.07,109.49) 55.97,109.49 55.03,108.55 55.03,107.91 53.53,106.41 53.53,106.16 53.22,105.85 53.22,105.76 50.86,103.39 50.86,102.51 49.36,101 49.36,100.77 47.69,99.1 44.45,99.1 43.53,98.18 31.6,98.18 29.29,95.87 29.29,94.66 26.71,92.08 26.71,89.76 24.14,87.19 24.14,84.84 24.84,84.14 25.43,84.14 25.81,83.76 25.81,82.56 24.83,81.58 24.83,73.95 25.09,73.69 25.09,62.37 24.79,62.07 24.79,61.3 25.23,60.85 25.23,57.19 v1(24.93,56.88) ; v2(178.7,26.71) 178.37,27.04 177.61,27.04 177.21,27.43 175.33,27.43 174.83,27.94 171.02,27.94 170.71,28.26 160.32,28.26 160.06,28.51 158.61,28.51 158.13,28.99 155.27,28.99 154.94,29.32 151.36,29.32 150.9,29.78 141.67,29.78 141.31,30.14 140.45,30.14 140.26,29.95 138.92,29.95 138.54,29.58 135.8,29.58 135.7,29.48 132.62,29.48 132.47,29.63 129.19,29.63 128.42,28.87 125.53,28.87 124.84,28.18 113.3,28.18 110.26,25.13 102.32,25.13 v2(102.3,25.16) ; v1(15.68,2.91) 16.04,3.26 18.98,3.26 19.21,3.5 19.21,4.79 20.06,5.64 21.13,5.64 22.49,4.28 24.22,4.28 24.5,4 28.36,4 29.45,5.09 32.19,5.09 32.35,4.94 38.44,4.94 38.8,5.29 38.8,5.77 41.39,8.37 42.84,8.37 45.12,10.65 45.45,10.65 48.12,13.33 51.49,13.33 51.96,12.86 60.88,12.86 61.17,12.56 v1(61.3,12.56)
  IN3 w0.089: v1(54.16,112.89) 54.16,111.39 v1(56.07,109.49) ; v2(102.3,25.16) 102.3,24.88 102.17,24.75 101.99,24.75 101.69,24.45 101.69,23.46 100.39,22.16 100.39,19.48 95.73,14.81 94.33,14.81 89.26,9.74 82.52,9.74 80.22,12.04 74.83,12.04 74.22,12.65 71.62,12.65 70.57,13.7 62.46,13.7 61.31,12.56 v1(61.3,12.56) ; v1(15.68,2.91) 15.23,3.36 15.23,10.46 17.75,12.98 17.75,14.26 16.92,15.1 15.56,15.1 13.97,16.69 13.97,18.19 13.09,19.07 12.22,19.07 11.01,20.28 11.01,23.35 14.69,27.03 15.04,27.03 15.49,27.48 15.49,36.37 v1(17.71,38.59)
  BOTTOM w0.102: v2(34.99,122.36) 36.33,122.36 36.74,122.77 37.68,122.77 38.32,122.12 D21.2 38.56,122.11 C498.1 39.82,122.11 40.02,122.31 40.02,122.52 40.3,122.8 42.91,122.8 42.91,122.8 v1(43.85,122.8) 46.16,122.8 46.29,122.67 46.29,122.03 46.01,121.75 46.01,117.87 47.05,116.83 51.12,116.83 51.88,116.06 51.88,113.4 52.13,113.14 53.91,113.14 v1(54.16,112.89)
LID#_C: length 12.5
  TOP w0.102: v1(180.1,28.1) 180.1,28.23 180.27,28.41 R368.1 181.77,28.41 182.31,28.94 C381.1 D10.1 183.62,29.19 184.36,28.45 184.86,28.45 185.13,28.18 185.13,27.57 185.58,27.11 186.72,27.11 187.02,27.42 187.71,27.42 188.43,28.14 188.43,28.68 188.85,29.09 U13.118
LINE1-L: length 16.9
  TOP w0.381: v1(210.75,42.15) 211.14,42.53 C333.1
  IN1 w0.381: v1(210.75,42.15) 209.79,42.15 209.5,41.86 206.86,41.86 203.9,38.9 203.9,38.6 202.62,37.32 201.76,37.32 200.59,36.16 v1(200.59,35.29)
  BOTTOM w0.203: U30.22 201,34.03 200.72,34.3 200.72,35.17 v1(200.59,35.29)
LINE1-R: length 17.6
  TOP w0.381: v1(208.98,42.4) 209.64,43.06 C334.1
  IN1 w0.381: v1(208.98,42.4) 208.37,43.01 206.76,43.01 203.01,39.27 203.01,38.96 202.26,38.21 201.31,38.21 199.6,36.51 199.6,35.02 v1(200.09,34.53)
  BOTTOM w0.203: v1(200.09,34.53) 200.09,34.51 200.97,33.63 U30.21
LINE1-VREFO-L: length 15.3
  TOP w0.381: 212.79,44.74 212.71,44.82 v1(212.13,44.82)
  IN1 w0.381: v2(204.46,37.5) 204.56,37.5 205.27,38.21 205.27,39.01 207.23,40.97 210.35,40.97 211.52,42.14 211.52,44.64 211.69,44.82 v1(212.13,44.82)
  BOTTOM w0.203: v2(204.46,37.5) 204.86,37.1 U30.31
LINE1-VREFO-R: length 17.2
  TOP w0.381: v2(203.92,37.2) 203.77,37.35 203.77,39.79 211.52,47.53 v1(211.52,47.59) 211.52,47.87 212.28,48.63 212.7,48.63
  BOTTOM w0.203: U30.30 204.46,36.82 204.08,37.2 v2(203.92,37.2)
M_A_A0: length 31.5
  TOP w0.127: v1(56.58,66.03) 57.29,66.74 57.68,66.74 57.8,66.62 57.8,66.15 57.92,66.03 58.08,66.03 58.2,66.15 58.2,66.62 58.32,66.74 58.49,66.74 58.61,66.62 58.61,66.15 58.73,66.03 58.9,66.03 59.02,66.15 59.02,66.62 59.14,66.74 59.3,66.74 59.42,66.62 59.42,66.15 59.54,66.03 59.71,66.03 59.83,66.15 59.83,66.62 59.95,66.74 60.12,66.74 60.24,66.62 60.24,66.15 60.35,66.03 60.52,66.03 60.64,66.15 60.64,66.62 60.76,66.74 60.93,66.74 61.05,66.62 61.05,66.15 61.17,66.03 61.34,66.03 61.45,66.15 61.45,66.62 61.57,66.74 62.23,66.74 63.28,65.7 65.86,65.7 67.21,64.35 67.91,64.35 68.26,63.99 68.26,63.36 68.57,63.05 69.27,63.05 69.45,62.88 70.45,62.88 72.04,61.28 72.04,60.79 71.59,60.34 v2(71.46,60.34)
  BOTTOM w0.079: U24.BB48 74.7,60.62 74.47,60.85 74.1,60.85 73.98,60.72 73.42,60.72 73.1,60.4 72.65,60.4 72.5,60.55 71.67,60.55 v2(71.46,60.34)
  BOTTOM w0.127: JDIM1.144 57.53,65.2 56.7,66.03 v1(56.58,66.03)
M_A_A1: length 36.4
  TOP w0.127: v1(51.62,62.46) 51.94,62.77 52.61,62.77 52.77,62.93 52.77,63.59 52.59,63.77 52.59,64.22 52.79,64.43 53.58,64.43 53.72,64.29 53.72,63.24 53.96,63 55.84,63 56.12,63.28 56.12,63.71 57.14,64.73 62.44,64.73 62.7,64.48 65.11,64.48 65.31,64.27 65.31,63 65.04,62.73 65.04,62.42 65.82,61.63 66.76,61.63 66.97,61.84 68.77,61.84 69.15,61.45 69.15,60.79 69.47,60.48 69.47,59.81 69.91,59.37 71.23,59.37 72.14,58.46 72.14,58.03 72.34,57.83 72.34,57.55 72.46,57.43 72.74,57.43 72.98,57.19 72.98,56.76 72.85,56.63 v2(72.07,56.63)
  BOTTOM w0.076: U24.BL49 74.23,56.75 72.2,56.75 v2(72.07,56.63)
  BOTTOM w0.127: JDIM1.133 v1(51.62,62.46)
M_A_A2: length 43.3
  TOP w0.089: 74,56.61 74.63,56.61 75.5,55.74 77.4,55.74 78.32,54.82 79.16,54.82 79.56,55.22 79.83,55.22 80.22,55.62 80.22,57.8 79.72,58.3 v2(79.72,58.47)
  TOP w0.127: 74,56.61 73.75,56.61 73.4,56.96 73.4,57.39 72.55,58.23 72.55,58.69 71.46,59.78 70.08,59.78 69.87,59.98 69.87,60.65 69.57,60.96 69.57,61.61 68.94,62.24 67.66,62.24 67.54,62.36 67.54,62.83 67.42,62.95 67.25,62.95 67.13,62.83 67.13,62.36 67.01,62.24 66.71,62.24 66.51,62.04 66.03,62.04 65.77,62.29 65.77,63.39 65.89,63.51 66.44,63.51 66.56,63.63 66.56,63.8 66.44,63.92 65.89,63.92 65.77,64.04 65.77,64.48 65.37,64.88 62.9,64.88 62.61,65.18 56.92,65.18 56.17,64.43 55.33,64.43 55.15,64.25 55.15,63.89 v1(55.56,63.49)
  BOTTOM w0.127: U24.BG38 79.92,58.04 79.72,58.24 v2(79.72,58.47) ; v1(55.56,63.49) 55.56,63.36 56.72,62.2 JDIM1.132
M_A_A3: length 39.7
  TOP w0.127: v2(71.82,57.16) 71.82,57.72 71.72,57.82 71.72,58.3 71.05,58.96 69.69,58.96 68.52,60.13 68.52,60.28 68.25,60.56 68.25,61.23 68.06,61.43 67.24,61.43 67.04,61.23 65.62,61.23 64.36,62.48 64.36,62.65 64.91,63.19 64.91,63.36 64.79,63.48 64.62,63.48 64.08,62.94 63.91,62.94 63.59,63.26 63.59,63.82 63.38,64.02 62.57,64.02 62.27,64.32 59.4,64.32 59.28,64.21 59.28,63.55 59.16,63.44 58.99,63.44 58.87,63.55 58.87,64.21 58.75,64.32 58.58,64.32 58.46,64.21 58.46,63.55 58.34,63.44 58.18,63.44 58.06,63.55 58.06,64.21 57.94,64.32 57.77,64.32 57.65,64.21 57.65,63.55 57.53,63.44 57.36,63.44 57.24,63.55 57.24,63.86 57.16,63.94 56.93,63.94 56.6,63.61 56.6,63.11 56.07,62.57 53.81,62.57 53.49,62.89 53.31,62.89 52.77,62.34 52.18,62.34 51.74,61.9 51.74,61.54 51.96,61.33 v1(52.13,61.33)
  BOTTOM w0.079: U24.BL45 75.97,57.16 74.24,57.16 74,56.92 72.67,56.92 72.43,57.16 v2(71.82,57.16)
  BOTTOM w0.127: v1(52.13,61.33) 51.5,61.95 JDIM1.131
M_A_A4: length 39.3
  TOP w0.127: v1(56.7,60.97) 56.58,61.1 56.58,61.28 56.99,61.69 57.17,61.69 57.29,61.56 57.29,61.04 57.41,60.92 57.58,60.92 57.7,61.04 57.7,62.02 57.82,62.14 57.99,62.14 58.11,62.02 58.11,61.04 58.23,60.92 58.39,60.92 58.51,61.04 58.51,62.02 58.63,62.14 58.8,62.14 58.92,62.02 58.92,61.04 59.04,60.92 59.21,60.92 59.33,61.04 59.33,62.02 59.44,62.14 59.61,62.14 59.73,62.02 59.73,61.04 59.85,60.92 60.02,60.92 60.14,61.04 60.14,62.02 60.26,62.14 60.43,62.14 60.54,62.02 60.54,61.04 60.66,60.92 60.83,60.92 60.95,61.04 60.95,62.02 61.07,62.14 61.24,62.14 61.36,62.02 61.36,61.04 61.48,60.92 61.64,60.92 61.76,61.04 61.76,62.02 61.88,62.14 62.05,62.14 62.17,62.02 62.17,61.7 62.28,61.59 62.45,61.59 62.58,61.71 62.58,62.02 62.7,62.14 62.95,62.14 64.98,60.11 64.98,59.88 64.9,59.79 64.9,59.61 65.06,59.45 65.06,59.27 65.19,59.14 65.39,59.14 65.62,59.37 65.82,59.37 66.05,59.14 66.46,59.14 67.93,57.67 68.95,57.67 69.03,57.76 69.32,57.76 69.61,57.47 69.61,57.34 69.91,57.03 70.17,57.03 70.28,56.92 70.46,56.92 70.75,57.21 v2(71.23,57.21)
  BOTTOM w0.079: U24.BJ46 75.72,57.72 74.18,57.72 74.1,57.65 73.71,57.65 73.39,57.33 72.2,57.33 71.94,57.59 71.58,57.59 71.26,57.26 71.26,57.24 v2(71.23,57.21)
  BOTTOM w0.127: v1(56.7,60.97) 56.7,61.35 56.91,61.56 57.09,61.56 57.44,61.2 JDIM1.128
M_A_A5: length 37.1
  TOP w0.127: v1(55.43,60.97) 54.04,60.97 53.86,61.15 53.86,61.56 54.04,61.73 56.45,61.73 56.83,62.11 57.02,62.11 57.15,62.24 57.15,62.43 57.29,62.57 59.79,62.57 59.91,62.69 59.91,62.93 60.02,63.04 60.2,63.04 60.31,62.93 60.31,62.69 60.43,62.57 60.6,62.57 60.72,62.69 60.72,62.98 60.83,63.09 61.01,63.09 61.12,62.98 61.12,62.69 61.24,62.57 61.41,62.57 61.53,62.69 61.53,63.03 61.63,63.13 61.81,63.13 61.94,63 61.94,62.69 62.06,62.57 62.22,62.57 62.34,62.69 62.34,63.09 62.46,63.21 62.63,63.21 62.75,63.09 62.75,62.69 62.87,62.57 63.11,62.57 65.32,60.36 66.2,60.36 66.61,59.96 66.61,59.57 67.46,58.72 67.63,58.72 67.88,58.97 68.05,58.97 68.17,58.85 68.17,58.68 67.91,58.43 67.91,58.26 68.1,58.08 68.77,58.08 69.25,58.56 69.53,58.56 69.65,58.44 69.65,58.02 69.77,57.9 69.94,57.9 70.06,58.02 70.06,58.44 70.18,58.56 70.83,58.56 71.31,58.08 71.31,57.8 71.18,57.67 70.88,57.67 v2(70.65,57.9)
  BOTTOM w0.079: v2(70.65,57.9) 70.67,57.9 70.87,58.09 72.15,58.09 72.41,57.83 73.18,57.83 73.5,58.15 73.9,58.15 74.09,58.35 74.47,58.35 74.7,58.12 U24.BG48
  BOTTOM w0.127: v1(55.43,60.97) 55.43,60.82 55.81,60.44 57.06,60.44 57.33,60.7 JDIM1.126
M_A_A6: length 35.6
  TOP w0.127: v2(68.62,58.61) 68.62,59.38 68.12,59.88 68.12,60.07 67.83,60.36 67.83,60.86 67.7,60.99 67.42,60.99 67.23,60.81 67.23,60.56 67.11,60.43 66.84,60.43 66.46,60.82 65.44,60.82 63.18,63.08 63.18,63.41 62.98,63.61 62.39,63.61 62.09,63.92 61.63,63.92 61.51,63.8 61.51,63.63 61.4,63.51 61.23,63.51 61.11,63.63 61.11,63.8 60.99,63.92 60.82,63.92 60.7,63.8 60.7,63.63 60.58,63.51 60.41,63.51 60.3,63.63 60.3,63.8 60.18,63.92 59.85,63.92 59.7,63.77 59.7,63.36 59.37,63.03 57.14,63.03 56.27,62.17 53.58,62.17 53.47,62.28 53.29,62.28 53.07,62.06 53.07,61.66 v1(53.4,61.33)
  BOTTOM w0.076: U24.BE45 76.27,60.17 76.13,60.31 75.53,60.31 75.44,60.22 73.63,60.22 73.3,59.89 72.45,59.89 72.29,60.05 72.16,60.05 71.58,59.47 69.99,59.47 69.12,58.61 v2(68.62,58.61)
  BOTTOM w0.127: v1(53.4,61.33) 53.4,60.95 53.15,60.69 52.13,60.69 51.87,60.95 JDIM1.127
M_A_A7: length 37.7
  TOP w0.127: v2(69.15,54.9) 69.15,54.6 69.3,54.44 69.67,54.44 69.81,54.58 69.81,54.82 69.56,55.08 69.56,55.31 69.75,55.5 69.92,55.5 70.12,55.69 70.12,55.89 69.81,56.2 69.56,56.2 69.39,56.02 69.22,56.02 69.1,56.14 69.1,56.31 69.18,56.38 69.18,56.55 68.87,56.86 68.67,56.86 68.55,56.74 68.55,56.54 68.43,56.42 68.26,56.42 68.15,56.54 68.15,56.74 68.03,56.86 67.58,56.86 66.6,57.83 64.64,57.83 64.2,58.27 64.03,58.27 63.61,57.85 63.44,57.85 63.32,57.96 63.32,58.13 63.75,58.56 63.75,58.73 63.63,58.85 63.46,58.85 63.03,58.42 62.86,58.42 62.74,58.54 62.74,58.71 63.17,59.14 63.17,59.3 63.05,59.42 62.88,59.42 62.46,59 62.29,59 62.17,59.11 62.17,59.28 62.6,59.71 62.6,59.88 62.37,60.11 62.16,60.11 62.08,60.02 61.9,60.02 61.81,60.11 55.99,60.11 v1(55.81,59.93)
  BOTTOM w0.079: v2(69.15,54.9) 69.66,55.41 69.66,57.7 70.21,58.26 72.22,58.26 72.48,58 73.11,58 73.43,58.32 73.83,58.32 74.02,58.51 74.54,58.51 74.61,58.44 75.95,58.44 U24.BG45
  BOTTOM w0.127: JDIM1.122 57.19,59.7 56.87,59.39 56.69,59.39 56.37,59.7 56.04,59.7 v1(55.81,59.93)
M_A_A8: length 36.7
  TOP w0.127: v2(70.9,56.63) 70.9,56.55 71.07,56.39 71.07,56.21 70.98,56.12 70.65,56.12 70.59,56.18 70.43,56.18 69.99,56.63 69.71,56.63 69.07,57.26 67.75,57.26 66.78,58.24 64.87,58.24 64.41,58.7 64.41,58.87 64.64,59.1 64.64,59.26 64.51,59.39 64.36,59.39 64.12,59.15 63.96,59.15 63.84,59.27 63.84,59.44 64.35,59.96 64.35,60.13 64.24,60.25 64.07,60.25 63.55,59.73 63.38,59.73 63.26,59.85 63.26,60.02 63.78,60.53 63.78,60.7 63.66,60.82 63.49,60.82 62.97,60.3 62.81,60.3 62.69,60.42 62.69,60.59 63.2,61.11 63.2,61.28 63.09,61.4 62.92,61.4 62.03,60.51 53.93,60.51 53.81,60.4 53.81,60.15 53.7,60.03 53.53,60.03 53.41,60.15 53.41,60.46 53.28,60.59 53.02,60.59 52.71,60.28 52.42,60.28 v1(51.91,59.76)
  BOTTOM w0.079: v2(70.9,56.63) 70.85,56.68 70.85,57.34 71.27,57.75 72.01,57.75 72.27,57.5 73.32,57.5 73.64,57.81 74.03,57.81 74.11,57.89 75.37,57.89 75.6,58.12 U24.BG47
  BOTTOM w0.127: JDIM1.125 51.22,60.46 v1(51.91,59.76)
M_A_A9: length 36.7
  TOP w0.127: v1(52.89,58.56) 52.89,58.61 52.64,58.86 52.64,58.99 53.25,59.6 54.16,59.6 54.29,59.73 54.29,59.99 54.4,60.11 54.57,60.11 54.69,59.99 54.69,59.59 54.81,59.47 56.02,59.47 56.25,59.7 58.22,59.7 58.34,59.58 58.34,59.21 58.46,59.09 58.63,59.09 58.75,59.21 58.75,59.58 58.87,59.7 59.03,59.7 59.15,59.58 59.15,59.21 59.27,59.09 59.44,59.09 59.56,59.21 59.56,59.58 59.68,59.7 59.85,59.7 59.97,59.58 59.97,59.21 60.09,59.09 60.25,59.09 60.37,59.21 60.37,59.58 60.49,59.7 60.66,59.7 60.78,59.58 60.78,59.21 60.9,59.09 61.07,59.09 61.19,59.21 61.19,59.58 61.3,59.7 61.58,59.7 61.73,59.55 61.73,58.94 63.24,57.43 66.42,57.43 67.85,55.99 68.67,55.99 v2(69.18,55.49)
  BOTTOM w0.079: v2(69.18,55.49) 68.75,55.91 68.75,57.03 70.28,58.57 72.67,58.57 72.84,58.74 73.67,58.74 73.85,58.92 74.49,58.92 74.55,58.98 75.07,58.98 75.45,59.36 U24.BE47
  BOTTOM w0.127: JDIM1.121 51.46,59.46 51.88,59.04 52.41,59.04 v1(52.89,58.56)
M_A_A10: length 42.5
  TOP w0.089: 75.37,56.88 75.54,56.72 76.17,56.72 76.77,56.12 77.53,56.12 78.47,55.18 79.01,55.18 79.45,55.63 79.45,56.14 79.8,56.48 v2(79.8,56.68)
  TOP w0.127: 75.37,56.88 73.59,58.66 73.59,61.65 73.39,61.85 73.39,63.97 73.26,64.1 73.26,65.47 73.06,65.67 71.05,65.67 70.94,65.78 70.64,65.78 70.39,66.03 69.71,66.03 69.56,66.18 69.56,67.09 69.43,67.22 69.1,67.22 69,67.12 69,66.63 68.88,66.51 68.71,66.51 68.6,66.63 68.6,67.09 68.47,67.22 68.29,67.22 68.19,67.12 68.19,66.63 68.07,66.51 67.9,66.51 67.78,66.63 67.78,67.18 67.66,67.3 67.5,67.3 67.38,67.18 67.38,66.63 67.26,66.51 67.09,66.51 66.97,66.63 66.97,67.18 66.85,67.3 66.68,67.3 66.56,67.18 66.56,66.63 66.44,66.51 66.28,66.51 66.16,66.63 66.16,67.18 66.04,67.3 65.87,67.3 65.75,67.18 65.75,66.63 65.63,66.51 65.46,66.51 65.34,66.63 65.34,67.18 65.23,67.3 65.06,67.3 64.94,67.18 64.94,66.63 64.82,66.51 63.61,66.51 63.41,66.71 63.41,67.17 62.88,67.7 57.66,67.7 57.59,67.63 v1(57.14,67.63)
  BOTTOM w0.127: v1(57.14,67.63) 57.16,67.63 57.24,67.7 JDIM1.146 ; U24.BJ38 79.96,57.1 v2(79.8,56.68)
M_A_A11: length 35.1
  TOP w0.127: v2(65.47,56.6) 62.22,56.6 62.07,56.75 62.07,57.39 61.94,57.52 61.76,57.52 61.63,57.39 61.63,56.54 61.51,56.42 61.35,56.42 61.23,56.54 61.23,57.55 61.11,57.67 60.93,57.67 60.82,57.55 60.82,56.54 60.7,56.42 60.53,56.42 60.41,56.54 60.41,57.35 60.29,57.47 60.13,57.47 60.01,57.35 60.01,56.78 59.88,56.65 59.73,56.65 59.6,56.78 59.6,57.35 59.48,57.47 58.89,57.47 58.56,57.8 58.56,58.09 58.39,58.25 58.1,58.25 57.63,58.72 57.45,58.72 57.36,58.63 56.75,58.63 56.67,58.72 56.49,58.72 56.4,58.63 56.35,58.63 56.02,58.31 55.84,58.31 55.51,58.63 55.23,58.63 55.08,58.48 55.08,58.3 v1(55.23,58.15)
  BOTTOM w0.076: 72.09,60.21 71.51,59.64 69.06,59.64 68.51,59.09 68.45,59.09 68.13,58.77 67.74,58.77
  BOTTOM w0.079: 72.09,60.21 72.36,60.21 72.51,60.06 73.23,60.06 73.56,60.38 75.37,60.38 75.61,60.62 U24.BB47
  BOTTOM w0.127: JDIM1.120 57.39,59.2 56.92,58.74 56.48,58.74 55.89,59.32 55.41,59.32 55.23,59.14 v1(55.23,58.15) ; 67.74,58.77 67.14,58.18 67.14,57.94 67.02,57.81 66.78,57.81 66.62,57.66 66.62,57.33 66.48,57.19 65.92,57.19 65.47,56.73 v2(65.47,56.6)
M_A_A12: length 36.4
  TOP w0.127: v1(51.62,58.56) 51.56,58.49 51.56,58.19 51.65,58.1 53.99,58.1 54.14,58.25 54.14,58.48 54.01,58.61 53.5,58.61 53.35,58.76 53.35,59.04 53.5,59.19 54.37,59.19 54.7,58.86 54.88,58.86 55.05,59.04 56.2,59.04 56.42,59.27 56.7,59.27 56.93,59.04 57.16,59.04 57.39,59.27 57.67,59.27 58.25,58.69 58.86,58.69 58.98,58.57 58.98,58.02 59.1,57.9 59.27,57.9 59.39,58.02 59.39,58.57 59.51,58.69 59.68,58.69 59.79,58.57 59.79,58.02 59.91,57.9 60.08,57.9 60.2,58.02 60.2,58.57 60.32,58.69 60.49,58.69 60.61,58.57 60.61,58.21 60.72,58.1 60.89,58.1 61.01,58.23 61.01,58.57 61.13,58.69 61.33,58.69 61.45,58.56 61.45,58.16 61.58,58.04 62.05,58.04 63.07,57.02 66.24,57.02 66.69,56.57 66.69,56.4 66.57,56.28 66.57,56.11 66.69,55.99 66.86,55.99 66.98,56.11 67.15,56.11 67.41,55.85 67.41,55.62 67.55,55.49 v2(68.01,55.49)
  BOTTOM w0.076: 68.26,56.4 68.01,56.15 v2(68.01,55.49)
  BOTTOM w0.079: U24.BE48 74.95,59.36 74.74,59.14 74.48,59.14 74.42,59.09 73.78,59.09 73.6,58.91 72.77,58.91 72.6,58.73 70.21,58.73 68.26,56.78 68.26,56.4
  BOTTOM w0.127: JDIM1.119 51.23,58.95 v1(51.62,58.56)
M_A_A13: length 40.1
  TOP w0.089: v2(78.79,55.76) 78.79,56.23 78.62,56.4 78.62,57.06 78.13,57.55 78.13,57.62 77.81,57.94 77.2,57.94 77.15,57.9 76.9,57.9
  TOP w0.127: 76.9,57.9 76.27,57.9 74.86,59.3 74.86,63.25 74.75,63.37 74.75,67.46 74.63,67.58 74.63,68.09 73.85,68.87 72.55,68.87 71.23,70.19 70.8,70.19 70.65,70.34 70.65,70.78 70.45,70.98 70.22,70.98 70.09,70.85 70.09,70.27 69.96,70.14 69.43,70.14 69.23,70.34 68.79,70.34 68.39,70.75 66.79,70.75 66.28,71.26 65.7,71.26 65.57,71.13 65.57,70.93 65.78,70.71 65.78,70.33 65.56,70.1 64.61,70.1 63.91,70.8 56.83,70.8 56.71,70.67 56.71,70.44 56.88,70.27 v1(57.03,70.27)
  BOTTOM w0.127: v1(57.03,70.27) 57.47,70.7 JDIM1.158 ; U24.BM39 79.25,56.21 v2(78.79,55.76)
M_A_ACT#: length 34
  TOP w0.127: v2(67.93,54.9) 67.7,54.9 67.32,54.52 67.15,54.52 67.04,54.63 67.04,54.83 66.92,54.95 66.75,54.95 66.63,54.83 66.63,54.56 66.51,54.44 66.35,54.44 66.23,54.56 66.23,54.73 66.1,54.85 65.92,54.85 65.82,54.75 65.82,54.47 65.32,53.96 64.7,53.96 64.17,54.49 63.51,54.49 63.18,54.16 59.14,54.16 58.89,54.42 58.89,54.6 59.02,54.72 59.02,54.99 58.93,55.07 58.76,55.07 58.56,54.87 58.4,54.87 58.28,54.99 58.28,55.16 58.47,55.35 58.47,55.52 57.18,56.82 55.16,56.82 55.04,56.7 55.04,56.42 54.92,56.3 54.75,56.3 54.63,56.42 54.63,56.7 54.51,56.82 54.38,56.82 v1(54.06,56.5)
  BOTTOM w0.076: v2(67.93,54.9) 67.58,54.9 67.45,55.03 67.45,55.59 67.24,55.79 67.24,56 70.14,58.9 72.53,58.9 72.7,59.07 73.53,59.07 73.72,59.26 74.23,59.26 U24.BE49
  BOTTOM w0.127: JDIM1.114 57.34,57.7 57.15,57.52 55.08,57.52 v1(54.06,56.5)
M_A_ALERT#: length 23.8
  TOP w0.127: v2(66.48,55.36) 66.48,55.61 65.91,56.18 61.85,56.18 61.66,55.99 59.79,55.99 57.63,58.15 v1(57.14,58.15)
  BOTTOM w0.079: U24.BD46 75.95,59.98 75.66,59.69 75.51,59.69 75.41,59.59 73.81,59.59 73.46,59.24 72.63,59.24 72.46,59.07 70.07,59.07 68.86,57.85 68.6,57.85 68.13,57.39
  BOTTOM w0.127: JDIM1.116 57.19,58.2 v1(57.14,58.15) ; 68.13,57.39 66.48,55.74 v2(66.48,55.36)
M_A_BG#0: length 33
  TOP w0.127: v1(51.69,57.56) 51.33,57.56 51.24,57.47 51.24,57.21 51.45,57.01 52.03,57.01 52.16,57.14 52.41,57.14 52.54,57.01 53.08,57.01 53.34,57.26 53.53,57.26 53.71,57.09 53.89,57.09 54.06,57.26 57.31,57.26 59.42,55.16 59.42,54.85 59.7,54.57 62.27,54.57 62.44,54.75 62.62,54.75 62.8,54.57 63.01,54.57 63.34,54.9 63.94,54.9 64.05,55 64.25,55 64.88,54.37 65.15,54.37 65.32,54.54 65.32,54.74 v2(64.7,55.36)
  BOTTOM w0.079: U24.BB49 74.26,60.55 73.49,60.55 73.16,60.23 72.58,60.23 72.43,60.38 72.02,60.38 71.44,59.8 68.9,59.8 68.64,59.55
  BOTTOM w0.127: 68.64,59.55 68.13,59.04 67.52,59.04 66.36,57.87 65.95,57.87 65,56.92 65,56.69 64.88,56.57 64.77,56.57 64.65,56.45 64.65,56.28 64.77,56.16 64.88,56.16 65,56.04 65,55.65 v2(64.7,55.36) ; v1(51.69,57.56) 51.29,57.95 JDIM1.115
M_A_BG#1: length 33.8
  TOP w0.127: v2(65.87,55.36) 65.87,55.45 65.54,55.78 63.97,55.78 63.84,55.65 63.84,55.41 63.74,55.31 63.56,55.31 63.43,55.44 63.43,55.68 63.34,55.78 63.13,55.78 63.03,55.67 63.03,55.33 62.9,55.21 62.71,55.21 62.62,55.3 62.62,55.68 62.52,55.78 62.32,55.78 62.21,55.67 62.21,55.1 62.09,54.98 61.93,54.98 61.81,55.1 61.81,55.44 61.69,55.56 61.52,55.56 61.4,55.44 61.4,55.1 61.28,54.98 61.11,54.98 60.99,55.1 60.99,55.44 60.87,55.56 59.64,55.56 57.54,57.67 53.07,57.67 v1(52.97,57.57)
  BOTTOM w0.079: 67.91,57.77 68.24,58.1 68.87,58.1 70,59.23 72.39,59.23 72.56,59.41 73.39,59.41 73.74,59.75 75.12,59.75 75.3,59.93 U24.BD47
  BOTTOM w0.127: v2(65.87,55.36) 65.46,55.78 65.46,56.02 65.58,56.15 65.85,56.15 65.97,56.02 66.15,56.02 66.56,56.42 66.56,56.7 66.74,56.88 67.02,56.88 67.19,57.06 67.19,57.31 67.32,57.44 67.58,57.44 67.91,57.77 ; JDIM1.113 51.1,57.46 51.55,57.01 52.86,57.01 52.97,57.12 v1(52.97,57.57)
M_A_BS#0: length 41.2
  TOP w0.127: v1(55.62,67.63) 55.13,67.63 54.82,67.93 54.82,68.41 54.98,68.57 63.28,68.57 63.64,68.21 66.11,68.21 66.23,68.33 66.23,68.68 66.35,68.79 66.51,68.79 66.63,68.68 66.63,68.33 66.75,68.21 66.92,68.21 67.04,68.33 67.04,68.68 67.16,68.79 67.33,68.79 67.45,68.68 67.45,68.33 67.56,68.21 68.08,68.21 68.24,68.06 69.78,68.06 69.89,68.18 69.89,68.45 70.01,68.57 70.19,68.57 70.3,68.46 70.3,68.18 70.42,68.06 70.59,68.06 70.71,68.18 70.71,68.52 70.8,68.62 70.98,68.62 71.11,68.49 71.11,68.18 71.23,68.06 71.56,68.06 71.69,67.93 71.69,67.4 72.05,67.04 73.6,67.04 74.03,66.61 74.03,62.37 74.1,62.29 74.1,58.94 75.88,57.16 77.13,57.16 77.54,56.75 v2(77.63,56.75)
  BOTTOM w0.127: U24.BM43 77.35,56.47 v2(77.63,56.75) ; JDIM1.150 57.6,68.7 57.47,68.57 56.56,68.57 v1(55.62,67.63)
M_A_BS#1: length 44.3
  TOP w0.089: 77.02,60.49 77.98,59.53 77.98,58.36 78.19,58.15 78.6,58.15 v2(78.95,58.51)
  TOP w0.127: 77.02,60.49 76.67,60.84 76.67,61.68 76.57,61.78 76.57,66.56 76.31,66.81 76.31,68.97 74.79,70.5 73.26,70.5 70.62,73.14 65.09,73.14 64.37,72.43 55.43,72.43 53.72,70.71 53.72,70.36 53.76,70.32 v1(53.76,69.95)
  BOTTOM w0.127: JDIM1.145 51.17,67.46 51.37,67.65 52.31,67.65 53.38,68.72 53.38,69.57 v1(53.76,69.95) ; v2(78.95,58.51) 78.98,58.48 78.98,58.39 79.3,58.07 U24.BG39
M_A_CAS#: length 40.3
  TOP w0.127: v1(55.89,69.12) 56.35,69.58 56.98,69.58 57.79,70.39 58.05,70.39 58.17,70.28 58.17,70.06 58.29,69.94 58.46,69.94 58.58,70.06 58.58,70.28 58.7,70.39 58.86,70.39 58.98,70.28 58.98,70.06 59.1,69.94 59.27,69.94 59.39,70.06 59.39,70.28 59.51,70.39 63.46,70.39 63.64,70.22 63.64,69.45 63.89,69.2 64.37,69.2 64.55,69.38 64.88,69.38 65.06,69.2 65.44,69.2 66.53,70.29 68.24,70.29 68.36,70.17 68.36,69.12 68.59,68.9 69.1,68.9 69.33,69.12 69.33,69.46 69.58,69.71 71.13,69.71 72.38,68.46 73.67,68.46 74.23,67.91 74.23,67.47 74.51,67.19 74.51,63.03 74.61,62.93 74.61,59.19 76.16,57.64 77.58,57.64 v2(77.66,57.57)
  BOTTOM w0.127: U24.BJ42 78,57.23 v2(77.66,57.57) ; v1(55.89,69.12) 56.35,69.58 56.98,69.58 57.61,70.2 JDIM1.156
M_A_CB0: length 3.9
  TOP w0.102: R213.2 55.43,52.94 v1(55.69,53.2)
  BOTTOM w0.102: JDIM1.92 57.36,52.2 57.24,52.08 56.78,52.08 55.69,53.17 v1(55.69,53.2)
M_A_CB1: length 5.1
  TOP w0.102: v1(52.87,51.55) 52.04,52.37 51.15,52.37 R212.2
  BOTTOM w0.102: v1(52.87,51.55) 52.44,51.98 51.29,51.98 51.27,51.95 JDIM1.91
M_A_CB2: length 5.4
  TOP w0.102: v1(52.89,54.85) 52.39,54.34 51.43,54.34 50.95,54.83 R203.2
  BOTTOM w0.102: JDIM1.101 51.13,54.46 51.32,54.27 52.31,54.27 v1(52.89,54.85)
M_A_CB3: length 2.9
  TOP w0.102: v1(51.62,54.85) 50.95,55.53 R201.2
  BOTTOM w0.127: v1(51.62,54.85) 51.62,55.21 51.37,55.46 JDIM1.105
M_A_CB4: length 3.8
  TOP w0.102: R220.2 55.48,51.47 v1(55.81,51.8)
  BOTTOM w0.102: JDIM1.88 57.5,51.2 57.4,51.1 56.39,51.1 55.81,51.68 v1(55.81,51.8)
M_A_CB5: length 3.7
  TOP w0.102: R216.2 50.99,51.8 51.24,52.06 51.67,52.06 v1(52.18,51.55)
  BOTTOM w0.102: JDIM1.87 51.59,50.95 v1(52.18,51.55)
