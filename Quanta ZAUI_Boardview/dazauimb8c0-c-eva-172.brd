# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1V8_GFX_MAIN: length 139.3
  TOP w0.254: v2(105.6,98.89) 105.99,99.28 L5.1
  TOP w0.356: C50.1 102.99,109.4 v2(102.99,109.99) ; R17.2 101.67,109.49 v2(102.13,109.95)
  TOP w0.381: v2(102.13,109.95) 101.91,109.95 101.39,110.47 C35.1 ; C34.1 110.25,110.09 v2(110.42,109.91) ; C46.1 109.14,109.47 v2(109.64,109.97)
  TOP w0.508: v1(73.59,116.57) 73.59,116.45 74.23,115.82 PR17.1 ; L4.1 89.46,101.34 88.84,101.96 L3.1 88.7,102.29 C89.1 88.7,104.98 ; L1.1 L2.1 87.68,106 88.7,104.98 ; 88.7,104.98 89.5,104.98
  IN3 w0.508: 73.59,119.09 v1(73.59,116.57)
  IN3 w1.016: 24.17,103.59 24.98,103.59 25.46,104.08 25.46,105.09 26.15,105.78 37.78,105.78 40.7,108.7 42.25,108.7 42.81,109.26 45.07,109.26 45.76,109.94 49.31,109.94 50.99,111.62 50.99,114.41 51.62,115.05 68.92,115.05 72.96,119.09 80.4,119.09 82.61,121.3 87.13,121.3 88.97,119.45 92.78,119.45 94.45,121.12 94.45,122.69 95.72,123.96 99.73,123.96 101.1,125.34 106.41,125.34 107.81,123.94 110.09,123.94 110.55,124.4 113.63,124.4 115.07,122.95 115.07,117.59 114.31,116.83
  BOTTOM w0.305: v2(110.42,109.91) 110.8,109.53 U22.AA21 111.19,109.89 111.2,109.89 111.63,110.32 U22.AB22 ; v2(115.34,114.06) 115.73,113.67 U22.AF27 ; U22.AF26 v2(114.53,113.23) U22.AE25 ; v2(112.91,112.45) U22.AD24 ; v2(112.06,111.6) U22.AC23
  BOTTOM w0.356: U22.AA10 101.77,109.59 v2(102.13,109.95) ; v2(102.99,109.99) U22.AA12
  BOTTOM w0.381: U22.AA20 109.99,109.62 v2(109.64,109.97) 109.26,109.59 U22.AA19 U22.AA18 108.35,109.66 v2(107.94,110.07) 107.46,109.59 U22.AA16 ; v2(103.82,109.97) 104.19,109.6 U22.AA13
  vias: v1(23.43,103.36) v1(23.73,102.78) v1(23.94,103.75) v1(118.04,117.21) v1(119.06,117.21) v1(119.7,117.21) v2(99.25,98.79) v2(99.66,98.31)
+1V8_MAIN_EN_G: length 7.3
  TOP w0.508: PQ2.2 124.41,120.88 123.81,121.47 122.74,121.47 122.02,122.2 PQ1.3 v1(121.04,122.8) 120.55,123.29 PR3.1 PR1.2
+1V_S5_ON: length 125.8
  TOP w0.102: v2(197.75,27.75) 197.86,27.75 197.89,27.78 U13.95
  IN1 w0.089: v1(112.71,42) 110.02,44.69 109.21,44.69 108.09,45.81 108.09,46.52 108.23,46.66 108.56,46.66 109.03,47.14 109.03,48.63 109.29,48.88 110.27,48.88 110.48,49.08 110.48,51.07 110.59,51.18 111.55,51.18 111.76,51.38 112.42,51.38 112.62,51.18 113.41,51.18 113.54,51.05 113.54,49.67 115.23,47.98 126.76,47.98 127.52,48.74 132.89,48.74 134.66,46.98 136.31,46.98 136.54,47.2 137.88,47.2 138.34,46.75 142.37,46.75 v1(142.69,47.07)
  IN2 w0.089: v1(142.69,47.07) 144.36,45.41 144.36,40.17 147.36,37.17 147.75,37.17 148.19,36.72 148.56,36.72 148.8,36.48 149.14,36.48 149.54,36.09 153.07,36.09 153.27,36.29 153.59,36.29 153.72,36.42 154.31,36.42 154.71,36.82 155.26,36.82 155.41,36.97 157.29,36.97 157.95,36.31 159.29,36.31 159.75,35.85 162.11,35.85 162.95,35.02 163.85,35.02 164.2,34.67 164.36,34.67 165.16,33.88 166.25,33.88 166.45,33.67 166.79,33.67 167.04,33.92 178.6,33.92 179.26,33.26 179.26,32.75 179.56,32.45 180.3,32.45 180.55,32.7 182.26,32.7 182.71,32.24 186.55,32.24 187.92,33.62 190.08,33.62 190.23,33.46 191.83,33.46 192.9,34.53 194.52,34.53 194.98,34.99 196.18,34.99 196.25,35.06 v2(196.3,35.06)
  IN3 w0.089: v2(197.75,27.75) 197.72,27.72 197.64,27.72 196.53,28.83 196.53,28.94 195.79,29.68 195.79,34.61 196.25,35.06 v2(196.3,35.06)
  BOTTOM w0.102: v1(112.71,42) 112.69,41.97 112.61,41.97 R674.2
  BOTTOM w0.178: v1(142.69,47.07) 142.85,47.23 PR215.1
+2.5V_SUS: length 200
  TOP w0.254: U4.R9 34.89,71.33 34.17,70.61 ; U6.R9 34.89,51.43 34.17,50.71 ; U2.R9 34.89,84.63 34.07,83.81
  TOP w0.356: U8.R9 35.07,38.04 34.86,37.83 ; U8.B1 46.37,45.58 47.56,45.58 ; U2.B1 45.47,91.88 47.43,93.84 ; U6.B1 46.09,58.45 46.92,58.45 47.43,57.95 ; C192.2 47.06,80.77 45.47,79.18 U4.B1
  TOP w0.508: 34.86,37.83 32.95,35.93 31.8,35.93 C358.1 C359.1 C360.2 33.33,34.92 33.84,34.4 ; 34.17,50.71 33.72,50.71 33.64,50.79 32.23,50.79 31.8,50.35 30.75,50.35 C309.2 C312.1 C314.1 30.55,48.43 29.73,47.61 v1(28.94,47.61) ; v1(29.84,67.99) 30.04,67.99 30.55,68.5 C220.1 C217.2 30.94,70.08 32.31,70.08 32.84,70.61 34.17,70.61 ; 46.92,82.41 47.43,81.9 47.69,81.9 48.06,81.53 C193.1 C192.2 ; v1(28.15,81.27) 28.35,81.07 C194.1 C195.1 30.87,81.5 30.87,81.88 31.78,82.79 32.17,82.79 33.18,83.81 34.07,83.81
  TOP w1.016: 46.92,82.41 46.92,83.17 47.69,83.93 47.69,89.55 47.79,89.65 47.79,93.43 47.81,93.46 ; 47.43,57.95 47.64,57.74 47.64,45.66 47.56,45.58 47.69,45.45 47.69,37.53 46.61,36.45 46.61,34.52 45.76,33.67 42.28,33.67 42.05,33.9 36.39,33.9 35.49,33.01 ; 67.24,101.97 67.24,100.52 66.74,100.01 66.74,99.55 65.97,98.79 65.97,97.09 65.59,96.71 65.59,95.74 64.2,94.35 62.29,94.35 61.33,93.38 55.1,93.38 54.04,92.32 52.64,92.32
  BOTTOM w0.508: 28,47.64 28.03,47.61 v1(28.94,47.61) ; 28,68.62 28.08,68.54 29.02,68.54 29.56,67.99 v1(29.84,67.99)
  BOTTOM w1.016: 33.59,34.4 32.57,34.4 28.13,38.85 28.13,45.81 28,45.93 28,61.99 28.78,62.77 28.78,64.2 28,64.98 28,69.58 28,72.5 28.64,73.14 28.64,80.78 v1(28.15,81.27) 28.38,81.49 28.38,82.79 29.02,83.43 29.02,85.46 ; 30.44,99.45 30.67,99.22 30.67,99.17 31.3,98.54 39.05,98.54 39.53,99.02 44.92,99.02 45.53,98.41 51.03,98.41 51.64,97.8
  vias: v1(28.28,99.81) v1(33.72,33.51) v1(34.48,33.51) v1(51.9,95.79) v1(52.54,95.79) v1(58.35,118.58) v1(58.99,118.6) v1(69.66,117.66) v1(70.29,117.66) v2(67.45,102.7) v2(68.03,102.6)
+3V: length 375
  TOP w0.203: PR32.1 74.59,105.9 74.84,106.16 v2(74.84,106.46) ; R342.2 85.06,29.48 85.37,29.48 v2(86.96,27.9) ; R325.2 181.42,31.86 181.27,32.01 v2(181.27,32.22) ; v1(96.84,27.8) 96.96,27.67 98.23,27.67 98.61,28.05 98.61,28.94 96.65,30.91 95.25,30.91 94.8,31.36 R327.2 94.52,31.61 94.14,31.99 94.14,32.41 R306.1 93.54,33.33 93.1,33.77 R299.1 ; v1(172.78,27.37) 173.21,27.8 173.21,28.08 173.39,28.26 R365.2 ; v1(101.03,122.29) 101.03,122.67 100.74,122.95 R3.2 ; v1(53.53,94.73) 54.04,94.22 C159.1 ; R253.1 60.69,44.56 v1(61.07,44.18) 61.1,44.16 61.86,44.16 R258.2 ; R13.2 61.75,111.5 61.78,111.46 R12.1 62.39,111.46 62.55,111.62 v1(62.55,111.9) ; v2(167.6,26.96) 168.03,26.53 PR102.1 ; R21.1 54.35,109.08 v2(54.29,109.13) ; v1(135.88,57.16) 135.82,57.22 PR55.1 ; v1(45.99,28.38) 45.71,28.38 45.4,28.08 45.4,25.87 45.14,25.61 42.35,25.61 42.05,25.92 PR101.1
  TOP w0.254: R244.1 63.55,45.35 v1(64.32,45.35) ; v1(19.62,74.66) 19.57,74.71 18.69,74.71 C205.2 18.8,75.23 19.81,75.23 20.02,75.44 U3.18 ; v1(24.66,66.34) 24.66,65.98 24.32,65.63 Q13.2 ; U3.22 22.02,75.31 ; Q13.5 v1(24.32,61.33)
  TOP w0.305: R391.2 R390.2 81.98,24.37 v1(81.85,24.24)
  TOP w0.381: R377.2 79.45,26.39 v1(79.34,26.28) ; R369.2 172.78,27.55 v1(172.78,27.37) ; v1(177.02,26.73) 178,27.71 R371.1 ; v1(62.67,96.48) 62.67,96.95 R55.2 61.12,97.97 Q6.2 60.29,98.6 R63.1 58.94,97.52 v1(58.05,98.41) 57.67,98.79 R52.2 ; R409.1 78.25,22.56 v1(77.91,22.9) ; v1(85.15,94.74) 85.53,95.12 R83.2 ; R414.2 74.51,21.9 v1(74.95,22.34) ; C153.1 53.91,95.11 v1(53.53,94.73) ; v1(55.94,98.28) R57.1
  TOP w0.508: PR107.2 149.91,24.73 149.91,23.82 148.27,22.18 ; v1(60.69,109.76) 60.33,109.4 R18.2 ; R453.2 134.84,18.11 136.1,16.85 v2(139.48,16.85) ; v1(88.71,108.83) 91.5,111.62 92.64,111.62 93.2,112.18 93.97,112.18 95.82,114.03 95.82,119.79 96.91,120.89 96.91,121.19 97.27,121.55 98.26,121.55 98.68,121.97 99.06,121.97 99.38,122.29 v1(101.03,122.29) ; C222.1 24.42,68.57 23.96,68.11 23.96,66.77 24.38,66.34 v1(24.66,66.34) ; v1(56.5,21.7) 56.5,21.47 58.09,19.88 R431.1 ; v2(126.93,16.93) 126.67,16.66 R463.2
  IN1 w0.508: v1(59.88,112.71) 59.88,111.75 60.69,110.93 v1(60.69,109.76) ; v2(213.78,10.17) 214.29,10.68 214.29,15.18 215.48,16.37 215.48,17.44 213.22,19.7 213.22,23.46 216.01,26.25 216.01,29.4 216.22,29.6 216.22,31.33 v1(216.01,31.53)
  IN2 w0.254: v1(96.84,27.8) 96.88,27.85 99.7,27.85 99.86,28 103.59,28 103.92,28.33 103.92,28.97 104.47,29.51 105.15,29.51 105.68,28.99 106.92,28.99 107.33,29.4 107.9,29.4 108.38,29.88 v1(108.67,29.88)
  IN2 w0.381: 57.85,99.48 57.45,99.48 56.25,98.28 v1(55.94,98.28)
  IN2 w0.508: v1(42.78,116.57) 42.78,117 44.38,118.6 51.24,118.6 51.88,119.24 59.37,119.24 59.88,118.73 59.88,116.83 60.26,116.45 60.26,115.05 60.51,114.79 ; v1(62.67,96.48) 62.67,97.65 ; 62.67,97.65 63.14,98.12 71.97,98.12 v2(72.22,98.37) ; 62.67,97.65 61.78,97.65 61.02,98.41 v1(58.05,98.41) 57.85,98.61 57.85,101.69 58.25,102.09 v1(58.71,102.09) ; v1(85.02,98.41) 85,98.39 85,94.89 v1(85.15,94.74) ; v2(207.28,10.07) 207.48,10.27 207.96,10.27 208.93,11.24 208.93,11.72 209.21,12 213.14,12 213.78,11.36 v2(213.78,10.17)
  IN3 w0.254: v1(108.72,44.18) 108.72,43.47 109.4,42.8 109.4,42.39 109.84,41.95 109.84,38.39 110.55,37.68 110.55,36.28 111.04,35.79 111.04,34.24 110.9,34.1 110.9,31.22 109.54,29.86 108.7,29.86 v1(108.67,29.88)
  IN3 w0.381: v1(61.52,40.56) 62.8,41.84 62.8,42.15 63.66,43.01 63.66,44.16 64.32,44.82 v1(64.32,45.35)
  IN3 w0.508: v1(60.56,112.71) 60.56,112.46 61.12,111.9 v1(62.55,111.9) ; v2(126.93,16.93) 126.93,17.36 127.29,17.72 129.14,17.72 130.01,16.85 v2(139.48,16.85)
  BOTTOM w0.203: R757.2 85.89,26.81 v2(86.19,27.11) 86.27,27.04 R758.2 ; v1(81.85,24.24) 81.75,24.14 R788.2 ; R660.1 R661.1 108.88,44.03 v1(108.72,44.18) ; PR225.1 v1(143.29,42.47) ; R742.2 94.74,27.81 v1(94.78,27.77) 94.78,27.29 94.68,27.19 R765.2 ; R800.2 86.81,21.96 87.06,22.21 87.06,22.97 87.69,23.61 87.69,24.17 88.63,25.11 v1(88.63,25.69) ; R762.1 81.21,27.47 80.63,28.05 v1(80.58,28.05) ; R791.2 198.31,25.99 R772.2 ; Q41.5 Q41.2 84.52,25.39 84.16,25.74 v2(84.16,26.25) ; PR158.1 142.9,68.76 142.9,67.02 143.35,66.57 143.35,66.04 143.44,65.95 143.44,61.33 v1(143.35,61.23) ; v1(177.02,26.73) 177.76,26 179.77,26 182.13,28.35 182.13,29.4 181.46,30.07 181.46,31 181.27,31.19 v2(181.27,32.22) ; v1(61.52,40.56) 61.55,40.53 61.55,40.53 62.53,41.52 63.36,41.52 64.09,42.25 R671.1
  BOTTOM w0.254: JDIM1.255 51.47,94.95 51.75,95.24 53.02,95.24 v1(53.53,94.73)
  BOTTOM w0.381: R794.1 177.77,23.46 177.02,24.2 v1(177.02,26.73) ; v1(80.58,28.05) 80.58,28.12 R729.2 ; R752.2 205.75,26.98 v2(205.75,26.55) ; v1(53.53,94.73) 55.81,97.01 55.81,98.16 v1(55.94,98.28) ; R734.2 200.22,28.65 200.14,28.74 v2(200.11,28.74) ; R733.2 87.31,28.43 86.96,28.07 v2(86.96,27.9) ; R605.1 59.82,76.39 59.82,91.43 60.8,92.41 60.8,96.03 61.28,96.51 62.65,96.51 v1(62.67,96.48) ; v1(96.84,27.8) 96.84,28.17 R737.2 ; 59.75,43.29 59.65,43.19 59.65,29.4 59.41,29.16 57.12,29.16 v1(57.08,29.2)
  BOTTOM w0.508: v1(22.49,40.63) 22.29,40.42 PR232.1 ; R514.2 41.9,115.68 v1(42.78,116.57) ; PR151.1 72.26,98.41 v2(72.22,98.37) ; v1(45.99,28.38) 45.99,28.64 46.49,29.15 47.31,29.15 48.32,28.13 48.32,24.79 48.84,24.27 48.84,23.21 48.63,23 48.63,21.17 49.24,20.56 50.51,20.56 51.65,21.7 v1(56.5,21.7) ; v1(66.66,118.99) 66.66,119.11 66.35,119.42 PR131.2 ; v2(148.02,21.55) 147.54,21.55 147.04,21.04 147.04,15.86 146.71,15.53 140.38,15.53 139.48,16.43 v2(139.48,16.85) 139.48,17.51 141.29,19.32 141.29,20.57 140.78,21.08 R806.2
  vias: v1(17.08,87.74) v1(17.71,87.74) v1(23.38,39.48) v1(23.38,38.85) v1(24.09,76.03) v1(24.09,75.4) v1(24.57,83.43) v1(24.57,82.79) v1(25.21,83.3) v1(25.21,82.66) v1(25.23,6.08) v1(25.84,5.88) v1(26.48,5.88) v1(27.11,5.88) v1(27.75,6.01) v1(33.08,28.83) v1(33.72,28.83) v1(56.58,28.81) v1(57.85,112.71) v1(58.48,112.71) v1(58.89,103.11) v1(59.12,112.71) v1(59.35,102.09) v1(61.45,42.4) v1(89.11,99.33) v1(89.75,99.33) v1(150.05,27.98) v1(195.72,28.66) v1(196.15,28.18) v1(212.46,26.68) v1(212.46,26.05) v1(215.07,32.65) v2(52.18,105.83) v2(52.77,105.83) v2(136.1,27.11) v2(136.69,27.11) v2(148.75,29.35) v2(149.03,28.82) v2(149.34,29.35) v2(149.64,28.82) v2(149.92,29.35) v2(150.25,28.82) v2(150.51,29.35) v2(150.84,28.82) v2(197.75,26.28)
+3V3_TPM: length 3
  TOP w0.203: v2(121.52,21.29) 121.52,20.86 121.8,20.59 C413.1 C432.1 121.81,19.71 U15.22
  vias: v1(131.53,21.37) v2(128.61,23.1) v2(129.12,23.4)
+3V3_TPM_VSB:
  vias: v1(128.61,17.39)
+3V_CCD_PWR1_C: length 5.9
  BOTTOM w0.305: 59.35,106.14 CN2.32 59.35,107.66 59.5,107.81 59.75,107.81 59.85,107.71 CN2.33 59.85,105.75 59.46,105.36 R518.2 59.12,105.9 59.35,106.14
+3V_DEEP_SUS: length 217.5
  TOP w0.203: 98.44,34.1 97.6,33.26 R304.1 ; R357.2 93,28.67 92.7,28.38 92.7,27.87 92.98,27.6 v1(93.23,27.6) ; R415.1 77.79,21.12 77.79,20.81 78.12,20.48 79.26,20.48 80.58,21.8 v1(80.58,22.47) 80.58,22.52 80.38,22.72 80.38,23.71 v1(80.35,23.74) ; R347.1 R346.1 89.09,29.2 v2(89.04,29.2) 89.29,28.94 R361.2 R367.2 ; v1(63.71,29.73) 63.65,29.73 62.72,30.66 62.72,38.21 63.43,38.92 63.43,40.5 63.69,40.75 64.63,40.75 v1(64.7,40.83) ; v2(86.27,39.66) 85.99,39.66 85.66,39.99 85.66,45.33 85.15,45.83 85.15,46.26 84.67,46.75 83.45,46.75 83.4,46.8 82.82,46.8 82.54,47.08 82.54,47.31 82.03,47.81 81.29,47.81 80.94,47.47 80.94,46.79 81.06,46.67 81.06,46.01 R241.2 ; R356.2 91.56,28.74 v1(91.5,28.69) 91.47,28.69 89.81,27.04 89.47,27.04 89.03,26.6 R383.1
  TOP w0.381: R279.1 97.48,37.11 R283.1 97.49,36.17 97.88,35.77 97.88,34.66 98.44,34.1 99.38,34.1 99.76,33.72 v1(99.76,33.06) 99.76,31.99 v1(101.64,30.11)
  TOP w0.508: R358.1 161.36,29.67 160.92,30.11 v1(160.92,30.52)
  IN1 w0.203: v1(63.71,29.73) 64.25,29.2 66.03,29.2 66.74,29.91 66.74,30.24 68.54,32.04 68.87,32.04 v1(69.91,33.08)
  IN2 w0.178: 140.12,33.08 139.82,33.38 137.18,33.38 137.02,33.22
  IN2 w0.254: v1(77.15,30.47) 78.88,30.47 79.84,29.5 84.01,29.5 84.8,28.71 ; v1(77.15,30.47) 74,30.47 73.06,31.41 71.59,31.41 v1(69.91,33.08) ; v1(77.15,30.47) 75.4,28.71 75.4,27.06 75.75,26.71 v1(76.92,26.71) ; 95.92,28.66 96.45,29.2 100.72,29.2 v1(101.64,30.11) ; 95.92,28.66 95.92,27.93 v1(95.79,27.8) ; 95.92,28.66 95.87,28.61 94.02,28.61 93.58,29.04 93.2,29.04 92.57,28.41 ; 92.57,28.41 92.29,28.69 v1(91.5,28.69) 90.33,28.69 89.83,29.2 v2(89.04,29.2) 88.71,29.2 88.23,28.71 84.8,28.71 ; 92.57,28.41 92.57,28 92.98,27.6 v1(93.23,27.6) ; 84.8,28.71 v1(84.8,27.85)
  IN2 w0.33: 137.02,33.22 137.02,32.78 137.43,32.37 139.81,32.37 140.22,32.78 140.22,32.98 140.12,33.08
  IN2 w0.381: v2(86.27,39.66) 86.75,39.66 87.97,38.44 88.94,38.44 89.34,38.85 93.79,38.85 94.06,38.58 95.6,38.58 96.87,39.85 100.53,39.85 101.53,38.85 101.53,36.31 102.09,35.75 102.09,33.69 101.46,33.06 v1(99.76,33.06)
  IN2 w0.508: 137.02,33.22 135.57,33.22 135.26,33.52 134.1,33.52 133.24,32.66 132.64,32.66 132.01,33.29 125.89,33.29 123.24,30.64 110.03,30.64 109.93,30.53 108.2,30.53 ; v1(160.92,30.52) 160.84,30.6 159.54,30.6 159.06,31.07 156.07,31.07 155.75,31.4 152.15,31.4 151.71,31.84 144.56,31.84 142.75,33.65 141.39,33.65 140.86,33.11 140.14,33.11 140.12,33.08
  IN3 w0.254: v1(65.21,43.34) 65.21,41.34 v1(64.7,40.83)
  BOTTOM w0.203: R801.2 v1(81.33,21.73) 81.31,21.73 v1(80.58,22.47) ; v1(64.7,40.83) 65.49,40.83 65.6,40.72 R677.1 ; R760.2 95.92,26.68 95.73,26.87 95.73,27.74 v1(95.79,27.8) ; v1(77.15,30.47) 77.28,30.34 77.66,30.34 77.94,30.06 R721.2 ; R705.1 69.56,32.73 v1(69.91,33.08) ; v1(80.35,23.74) v1(80.94,24.32) 81.49,24.88 82.37,24.88 82.81,25.32 83.25,25.32 83.63,25.7 83.63,26.53 84.64,27.55 84.64,27.7 v1(84.8,27.85) 84.8,27.75 85.13,27.42 85.13,26.5 86.02,25.61 R779.2 ; R771.2 76.88,26.67 v1(76.92,26.71) 76.87,26.76 R753.2 ; R739.1 88.61,28.76 v2(89.04,29.2) 89.42,28.82 R735.1 ; v1(65.21,43.34) 65.83,43.34 R663.1
  BOTTOM w0.33: v2(86.27,39.66) 86.2,39.66 U24.DF26
  vias: v1(102.27,30.11) v1(102.91,30.11)
+3V_DMIC:
  vias: v1(38.87,115.71)
+3V_EC: length 3
  TOP w0.203: 182.35,24.18 U13.11
  TOP w0.254: v1(180.35,23.74) 180.66,24.04 182.21,24.04 182.35,24.18
+3V_LAN: length 16.6
  IN1 w0.508: v1(43.83,102.14) 43.83,103.01 44.69,103.87 45.78,103.87 46.42,104.51 46.42,105.52 47.18,106.29 48.2,106.29 49.69,107.78 49.69,108.19 50.35,108.85 50.35,112.58 49.13,113.8 v1(49.13,114.31)
  vias: v1(40.52,110.83) v1(40.5,110.2) v1(41.08,110.48) v1(47.81,111.62) v1(48.32,111.21) v1(49.13,114.97)
+3V_LDO_EC: length 83.2
  TOP w0.203: v2(172.1,29.42) 172.11,29.41 172.11,29.01 171.99,28.89 R362.2 ; R333.2 179.6,31.1 R331.1
  TOP w0.381: v2(147.57,36.51) 147.31,36.51 146.22,37.6 PR68.2 ; v2(175.96,25.84) 175.22,25.84 175.19,25.87 175.14,25.87 175.09,25.92 D13.1 174.45,25.62 174.66,25.41 R401.1 175.15,24.46 175.76,23.85 R399.2 ; v2(177.76,32.96) 177.76,32.35 178.17,31.95 178.75,31.95 R331.1
  IN2 w0.254: v1(186.09,23.8) 185.67,24.22 181.41,24.22 180.95,24.67 179.28,24.67 178.83,25.13 176.69,25.13 175.97,25.84 v2(175.96,25.84)
  IN3 w0.254: v1(186.09,23.8) 186.1,23.79 188.07,23.79 188.87,22.99 190.28,22.99 191.31,21.95 191.31,21.49 v1(192.47,20.33)
  IN3 w0.381: v2(147.57,36.51) 147.59,36.51 147.84,36.77 148.87,36.77 149.4,36.24 153.13,36.24 153.39,36.5 153.79,36.5 153.91,36.61 154.37,36.61 154.85,37.1 157.87,37.1 158.58,37.81 159.07,37.81 159.47,37.4 159.47,36.63 159.77,36.33 160.51,36.33 161.24,35.61 162.89,35.61 163.13,35.37 163.51,35.37 165.16,33.72 166.18,33.72 166.46,33.44 166.94,33.44 167.3,33.79 177.46,33.79 177.76,33.49 v2(177.76,32.96)
  BOTTOM w0.203: R805.2 R811.2 192.75,20.05 v1(192.47,20.33)
  BOTTOM w0.381: v2(177.76,32.96) 177.76,32.62 177.32,32.18 174.37,32.18 172.68,30.49 172.68,30.01 v2(172.1,29.42) 172.1,28.99 171.84,28.74 171,28.74 170.72,28.46 v1(170.72,27.72) 170.72,26.99 171.18,26.53 173.54,26.53 174.15,25.92 175.14,25.92 175.22,25.84 v2(175.96,25.84)
+3V_RTC: length 194.9
  TOP w0.305: v1(64.27,104.33) 64.88,103.72 66.38,103.72 R37.1
  IN1 w0.508: v1(16.5,9.08) 16.5,8.19 17.74,6.95 19.54,6.95 19.92,7.33 21.09,7.33 23.18,5.24 24.57,5.24 25.39,4.43 27.18,4.43 28.39,5.64 29.19,5.64 30.41,6.87 32.7,6.87 32.88,7.05 34.77,7.05 35.64,7.92 35.64,8.63 36.4,9.39 36.55,9.39 40.88,13.71 40.88,15.23 42.03,16.37 44.13,16.37 44.64,15.86 45.27,15.86
  IN1 w0.762: 45.51,16.39 45.51,19.07 48.45,22.01 48.45,23.15 47.94,23.66 v4(47.94,23.91)
  IN2 w0.635: v1(64.27,104.33) 63.65,103.71 61.25,103.71 60.5,102.96 56.84,102.96 56.66,102.78 55.54,102.78 52.49,99.73 51.93,99.73 50.63,98.42 50.63,96.91 49.77,96.05 45.22,96.05 44.92,95.74 33.35,95.74 32.21,94.6 32.21,93.59 29.67,91.05 29.67,80.4 29.07,79.79 29.07,73.02 28.56,72.51 28.56,60.15 28.24,59.83 28.24,39.39 31.71,35.93 36.21,35.93 39.05,33.08 43.85,33.08 46.85,30.09 v4(46.85,28.1)
  IN3 w0.762: 65.47,26.91 65.31,26.76 62.12,26.76 61.14,25.77 57.73,25.77 57.46,25.51 55.63,25.51 54.72,24.59 53.81,24.59 53.66,24.44 50.42,24.44 50.27,24.28 48.82,24.28 48.45,23.91 v4(47.94,23.91)
  BOTTOM w0.762: 69.36,30.72 67.47,28.84 67.47,27.88 ; v4(46.85,28.1) 46.85,27.61 47.43,27.02 47.43,24.42 v4(47.94,23.91)
  vias: v1(66.13,27.37) v1(66.1,26.73)
+3V_RTC_1:
  vias: v1(17.89,8.22)
+3V_S5: length 291.1
  TOP w0.203: v1(67.47,21.7) 67.47,21.96 R413.1 ; R406.2 69.15,23.48 v1(69.28,23.35) ; R378.2 92.34,25.97 v2(92.34,25.69) ; R276.1 R272.1 64.58,39.36 64.32,39.61 64.32,39.86 v1(63.94,40.25) 63.94,38.79 63.18,38.02 63.18,30.85 63.82,30.21 64.02,30.21 64.29,29.94 64.29,29.23 64.17,29.1 64.17,28.89 63.18,27.9 v1(63.18,25.89) ; R397.2 66.38,24.59 65.49,23.7 v1(65.49,23.46) ; v1(67.45,31.67) 66.7,30.92 R330.1
  TOP w0.254: U10.5 110.57,34.16 C362.1 ; U9.5 107.98,37.95 C347.1 ; v1(104.74,28.03) 104.18,28.03 103.44,28.76 103.44,30.44 103.21,30.67 102.37,30.67 101.76,31.28 101.76,34.25 101.43,34.58 101.43,36.67 100.9,37.2 100.14,37.2 99.76,37.58 99.76,39.61 99.12,40.25 R268.2 ; R478.2 26.22,12.46 v1(27.85,10.83) ; R344.1 179.79,29.09 179.79,28.54 178.09,26.84 v1(178.09,26.53)
  TOP w0.381: v1(70.8,21.35) 70.8,20.98 71.04,20.74 R424.2 ; v1(86.29,26.45) 86.57,26.18 R389.2 86.38,25.54 85.68,24.84 83.94,24.84 R392.2 ; C347.1 v1(108.24,37.07) ; C362.1 110.56,33.98 110.08,33.5 109.37,33.5 109.13,33.74 109.13,34.17 v1(108.44,34.86)
  TOP w0.508: v1(59.88,49.9) 59.51,49.9 57.77,48.16 57.77,47.08 57.05,46.36 57.05,43.25 55.94,42.15 55.94,42.07 54.37,40.5 54.37,35.4 54.54,35.23 54.54,34.15 55.03,33.67 55.03,31.33 52.89,29.2 52.89,28.85 52.58,28.54 52.51,28.54 52.16,28.18 52.16,27.67 52.67,27.17 52.67,26.48 50.38,24.19 49.39,24.19 48.37,23.18 47.41,23.18 46.52,24.07 v1(45.38,24.07) ; v1(108.56,46.11) 108.54,46.14 v1(105.98,46.14)
  IN1 w0.254: 56.73,110.02 56.73,109.82 57.87,108.67 57.87,108.04 58.23,107.68 61.99,107.68 63.87,105.8 65.21,105.8 66.38,104.63 66.38,103.03 67.43,101.99 68.67,101.99 69.1,102.42 78.56,102.42 78.77,102.62 82.98,102.62 86.57,99.02 86.57,95.82 88.4,94 88.4,88.33 87.89,87.83 87.89,86.38 v1(87.95,86.32)
  IN1 w0.508: v1(75.8,21.32) 73.44,21.32 v1(73.39,21.27) ; v1(137.06,46.79) 136.7,46.42 134.43,46.42 132.66,48.19 127.75,48.19 125.67,46.11 123.4,46.11 122.09,47.43 114.08,47.43 112.76,46.11 v1(108.56,46.11)
  IN2 w0.508: v1(107.88,40.5) 107.43,40.5 106.98,40.94 106.98,41.64 107.49,42.15 108.52,42.15 108.73,42.36 108.73,43.21 108.14,43.8 108.14,43.93 107.78,44.29 107.78,44.69 108.56,45.47 v1(108.56,46.11) ; v1(8.79,24.05) 9.22,24.48 13.16,24.48 14.71,26.02 15.63,26.02
  IN2 w1.016: 14.16,45.45 15.35,44.26 15.35,42.77 15.92,42.2 15.92,26.97 15.63,26.68 15.63,26.02 16.47,25.18 16.87,25.18 19.19,22.87 19.19,21.58 19.75,21.02 19.75,19.44 ; 20.69,18.32 20.69,17.31 18.22,14.85 18.22,9.23
  IN3 w0.254: v2(194.24,27.49) 194.45,27.49 195.13,28.18 195.13,29.45 194.88,29.7 194.39,29.7 191.97,32.12 189.98,32.12 v2(189.42,32.68)
  IN3 w0.508: v1(108.44,34.86) 108.44,35.42 108.75,35.72 108.75,36.71 108.39,37.07 v1(108.24,37.07) 107.82,37.07 106.83,38.05 106.83,39.44 v1(107.88,40.5)
  BOTTOM w0.203: R573.2 v1(87.95,86.32) ; R714.1 108.39,30.85 107.63,30.09 107.63,29.83 ; R784.1 75.1,23.95 R787.1 74.86,23.68 v1(74.61,23.43) ; R667.2 110.68,42.63 110.42,42.89 110.42,43.6 109.64,44.39 109.21,44.39 108.93,44.66 108.93,45.22 108.56,45.59 v1(108.56,46.11) ; R678.1 63.84,40.15 v1(63.94,40.25)
  BOTTOM w0.229: U29.5 109.01,34.13 108.91,34.03 C634.1
  BOTTOM w0.254: R688.2 108.27,37.1 v1(108.24,37.07) ; U26.5 107.84,45.61 C606.2 ; C682.1 76.49,21.09 76.32,20.92 CN12.1 ; U27.5 105.38,45.88 C603.2
  BOTTOM w0.305: R826.1 27.75,18.73 28.13,19.11 28.13,19.95 28.06,20.02 R815.1 27.35,20.19 R814.1 26.55,20.41 v1(25.53,21.44) 25.26,21.7 24.09,21.7 23.8,21.41 23.77,21.41 23.65,21.28 23.65,19.91 23.28,19.54 22.26,19.54
  BOTTOM w0.381: R763.2 83,27.23 v1(82.94,27.29) ; R731.2 83.12,28.1 v1(82.94,27.93) ; R795.2 67.72,21.95 v1(67.47,21.7) ; v2(21.04,19.14) 21.17,19.01 R821.1 ; v1(108.44,34.86) 108.44,34.58 107.99,34.12 C634.1 ; C603.2 105.76,45.92 v1(105.98,46.14) ; C682.1 76.43,21.95 v1(75.8,21.32) ; C606.2 107.99,45.54 v1(108.56,46.11) ; PR211.1 v1(137.06,46.79) ; R797.2 69.67,23.35 v1(69.28,23.35)
  BOTTOM w0.508: v1(8.79,24.05) 8.92,24.18 Q42.2 ; Q43.2 64.66,21.91 v1(65.16,22.41)
  vias: v1(13.9,46.21) v1(14.03,46.85) v1(16.17,90.26) v1(16.72,90.84) v1(19.24,8.22) v1(19.24,7.58) v1(25.16,11.7) v1(33.06,24.04) v1(33.69,24.04) v1(42.99,26.78) v1(43.32,26.22) v1(43.62,26.78) v1(43.95,26.22) v1(44.26,26.78) v1(44.59,26.22) v1(44.89,26.81) v1(51.62,109.71) v1(52.26,109.71) v1(57.85,116.57) v1(58.48,116.57) v1(72.73,21.3) v1(104.66,28.66) v1(105.37,28.05) v1(158.94,21.53) v1(159.57,21.53) v1(160.21,21.53) v1(160.62,22.16) v1(160.84,21.53) v1(161.48,21.53) v1(162.11,21.53) v1(193.91,24.98) v1(194.55,25.01) v2(92.95,25.69)
+3V_SSD:
  vias: v1(21.8,3.36) v1(21.98,5.85) v1(22.13,3.97) v1(22.44,3.36) v1(22.84,3.86) v1(23.24,3.36) v1(36.13,3.26) v1(36.76,3.26) v1(37.6,3.34) v1(38.39,3.92) v1(38.39,3.29)
+3V_WLAN_P: length 48
  TOP w0.381: Q18.2 174.63,20.17 174.36,20.17 174.21,20.02 173.57,20.02 173.25,19.7 173.25,19.04 173.93,18.36 173.93,17.11 v1(173.57,16.75)
  IN2 w0.381: v1(173.57,16.75) 173.89,16.43 177.87,16.43 178.47,17.03 182.05,17.03 184.39,14.69 190.17,14.69 190.92,13.94 197.31,13.94 v2(198.18,14.82)
  BOTTOM w0.203: 179.46,14.81 179.58,14.7 R833.2 180.92,14.7 C707.1 ; Q46.2 181.47,18.39 R816.1 ; R828.2 R825.2 193.56,18.48 v2(193.86,18.17)
  BOTTOM w0.381: v1(173.57,16.75) 173.8,16.52 173.8,15.35 174.37,14.79 179.44,14.79 179.46,14.81 179.46,15.23 180.43,16.19 180.43,17.35 Q46.2
  vias: v1(191.44,24.71) v1(192.07,24.71) v1(192.47,11.92) v1(192.71,24.71) v2(193.08,11.7) v2(193.66,11.72) v2(194.24,11.7) v2(194.83,11.7)
+3VLCD_CON:
  vias: v1(62.14,102.27) v1(62.85,102.27) v1(77.79,98.16) v1(78.42,98.16) v1(78.4,97.5)
+3VLCD_CON_R:
  vias: v1(60.54,105.88) v1(61.15,105.55) v1(61.17,106.18)
+3VLCD_CON_R_C: length 3.5
  TOP w0.305: v1(62.04,106.29) v1(62.04,105.65) 62.04,105.62 62.85,104.81 R34.2
  BOTTOM w0.305: v1(62.04,105.65) 61.85,105.84 CN2.37
+3VPCU: length 425.1
  TOP w0.203: v2(183.55,33.21) 182.91,32.57 R309.2 ; 53.48,15.2 53.96,14.72 R474.2
  TOP w0.254: PR98.2 135.45,27.34 135.71,27.6 137.15,27.6 137.35,27.39 137.92,27.39 138.04,27.52 PR90.2
  TOP w0.381: v2(206.36,23.99) 206.24,23.87 R407.2 ; v1(143.09,38.34) 143.06,38.31 143.06,38.21 142.71,37.86 142.71,36.25 140.97,34.51 140.97,33.18 139.72,31.93 139.24,31.93 138.9,31.58 138.9,30.29 138.31,29.7 138.31,28.82
  TOP w0.508: v1(52.36,108.44) R24.2 R23.1 ; R5.1 C28.2 55.38,112.77 Q2.1 54.16,111.56 v1(54.16,110.1) ; v1(53.96,19.65) 53.96,18.09 53.48,17.61 53.48,15.2 53.02,14.74 53.02,13.68 54.29,12.41 v1(54.29,12.05)
  IN1 w0.381: 208.39,26.35 207.91,26.35 v1(207.71,26.15)
  IN1 w0.508: v2(194.68,36.1) 194.68,35.52 195.85,34.35 195.85,33.46 195.64,33.26 195.64,32.88 195.9,32.63 195.9,30.72 196.28,30.34 196.48,30.34 198.72,28.1 200.87,28.1 201.25,27.71 202.37,27.71 202.58,27.92 204.2,27.92 204.24,27.88 208.06,27.88 208.39,27.55 208.39,26.35 209.61,25.13 212.79,25.13 214.1,26.44 214.1,30.18 214.59,30.67 v2(214.59,30.97)
  IN1 w0.762: v4(41.72,23.61) 41.72,25.18 40.16,26.74 40.16,30.74 40.17,30.75 ; v1(28.89,97.14) 28.89,94.86 26.86,92.82 26.86,88.89 25.46,87.49 23.56,87.49 22.67,86.6 22.67,85.46 23.3,84.82 23.3,81.65 24.85,80.1 24.85,74 25.97,72.88
  IN2 w0.381: v1(207.71,26.15) 207.58,26.02 207.58,25.03 206.54,23.99 v2(206.36,23.99)
  IN2 w0.508: v1(53.96,19.65) 53.86,19.65 52.75,20.76 51.73,20.76 50.63,19.67 48.69,19.67 46.99,21.37 46.99,22.52 46.06,23.46 41.87,23.46 v4(41.72,23.61) ; 159.19,27.65 159.21,27.63 160.54,27.63 161.23,26.94 164.34,26.94 165.11,27.7 170.29,27.7 171.28,26.71 173.19,26.71 173.42,26.94 v2(173.42,27.29) ; v1(54.29,12.05) 54.11,11.87 48.83,11.87 48.47,11.51 48.47,9.76 46.95,8.24 46.92,8.24 46.46,7.78 41.59,7.78 40.08,6.27 40.08,5.66 39.33,4.91 39.33,2.14 39,1.81 14.62,1.81 v1(14.29,2.15)
  IN2 w0.762: 54.21,109.97 54.21,111.29 55.31,112.38 57.08,112.38 57.49,111.97 61.56,111.97 62.34,112.76 64.7,112.76 67.24,110.22 67.24,107.3 70.42,104.13 74.74,104.13 76.21,102.65 82.36,102.65 84.57,100.44 86.55,100.44 88.58,98.41 89.98,98.41 90.66,97.73 90.66,91.06 93.66,88.07 v1(93.66,85.84) 94.89,84.61 94.89,83.08 97.85,80.12 100.04,80.12 101.24,78.92 102.51,78.92 102.72,79.13 104.79,79.13 105.27,79.61 108.35,79.61 108.8,79.16 108.8,76.26 108.34,75.81 106.92,75.81 106.21,75.09 106.21,63.64 107.48,62.37 108.39,62.37 110.31,60.45 110.31,56.23 110.98,55.56 110.98,53.96 111.95,53 112.81,53 ; v1(28.89,97.14) 29.58,97.14 31.3,98.86 43.11,98.86 44.06,99.81 47.43,99.81 48.32,100.7 48.32,102.88 47.28,103.92 47.28,104.96 47.97,105.65 ; 40.42,31.89 38.9,31.89 35.87,34.91 30.9,34.91 27.29,38.52 27.29,62.67 26.78,63.18 26.78,67.68
  IN2 w1.016: 145.65,28.97 144.26,28.97
  BOTTOM w0.203: R697.2 195.91,34.74 195.29,35.37 195.29,35.5 v2(194.68,36.1) ; v1(112.71,52.31) 112.71,52.44 113.6,53.33 113.6,53.96 113.73,54.09 114.11,54.09 114.21,54.19 R628.2 ; R574.2 v1(93.66,85.84) 93.68,85.84 R580.2
  BOTTOM w0.305: v1(138.82,28.66) 138.82,27.16 138.43,26.77 PR265.2
  BOTTOM w0.381: PR264.2 PR265.2 ; PR234.1 143.57,38.21 143.44,38.34 v1(143.09,38.34)
  BOTTOM w0.508: v2(173.42,27.29) 174.18,28.05 174.69,28.05 175.07,28.43 175.07,29.7 176.64,31.28 177.4,31.28 178.27,32.14 179.41,32.14 179.77,32.5 v2(179.77,33.01) ; R842.1 20.01,11.45 19.26,10.7 19.26,9.16 18.6,8.5 18.6,7.56 18.3,7.25 17.61,7.25 17,6.64 17,6.06 16.04,5.09 15.58,5.09 15.17,4.69 15.17,4.13 14.29,3.24 v1(14.29,2.15) ; v1(52.36,108.44) 52.36,108.67 53.47,109.78 53.85,109.78 v1(54.16,110.1) 54.16,111.49 53.53,112.13 52,112.13 50.99,113.14 50.99,115.68 50.56,116.11 44.51,116.11 44.21,116.42 44.21,120.51 43.7,121.02 R507.1
  vias: v1(26.86,69.73) v1(26.86,69.07) v1(40.16,31.24) v1(40.83,31.23) v1(42.4,22.8) v1(113.35,52.31) v1(138.19,28.69) v2(152.59,28.82) v2(153.22,28.82) v2(214.59,31.56)
+3VPCU_EC: length 96.1
  TOP w0.178: 190.57,30.86 190.45,30.73 U13.114
  TOP w0.203: U13.26 182.31,18.18 182.14,18.02 C443.1 ; C386.1 200.01,26.88 199.71,26.58 U13.92 ; 191.26,12.66 191.65,13.05 U13.50 ; L6.2 185.97,32.02 C364.1 187.45,31.57 v2(187.45,31.23) 187.45,31.16 187.65,30.96 U13.121
  TOP w0.254: L10.1 202.64,20.14 203.16,19.62 v1(203.21,19.62) ; C443.1 C442.1 180.7,18.02 180.35,17.66 179.86,17.66 178.7,16.5 v2(178.7,16.42) ; v2(202.96,11.82) 203.03,11.75 203.03,10.88 203.53,10.39 203.53,10.01 203.26,9.74 197.14,9.74 v1(195.9,10.98) 193.03,10.98 192.59,11.42 192.59,11.7 192.39,11.9 C478.1 C477.1 190.84,11.9 v2(190.77,11.97) 190.77,12.17 191.26,12.66 ; C365.1 191.45,31.61 v2(191.32,31.48) 191.32,31.23 191.07,30.97 190.69,30.97 190.57,30.86 ; C386.1 200.75,26.88 201.69,25.94 v1(201.81,25.94)
  IN1 w0.254: v2(202.96,11.82) 202.96,11.67 203.16,11.47 203.82,11.47 204.15,11.8 204.15,15.99 203.31,16.83 203.31,19.49 203.21,19.59 v1(203.21,19.62) ; v2(190.77,11.97) 190.77,13.34 190.41,13.7 184.25,13.7 182.22,15.73 179.13,15.73 178.7,16.17 v2(178.7,16.42)
  IN3 w0.254: v2(187.45,31.23) 187.45,31.16 187.84,30.77 189.22,30.77 189.52,31.08 191.04,31.08 191.32,31.36 v2(191.32,31.48) 191.89,31.48 194.18,29.2 194.24,29.2 194.5,28.94 194.5,28.31 194.24,28.05 194.04,28.05 193.79,27.8 193.79,27.29 194.12,26.96 195.31,26.96 195.6,26.67 196.09,26.67 196.28,26.86 200.9,26.86 v1(201.81,25.94) 201.84,25.92 201.84,23.46 200.72,22.34 200.72,20.69 201.74,19.67 203.11,19.67 203.16,19.62 v1(203.21,19.62)
  BOTTOM w0.254: v2(178.7,16.42) 178.7,16.52 178.47,16.75 176.31,16.75 176.15,16.9 176.15,19.37 175.58,19.95 175.58,21.5 v2(174.94,22.13)
+3VPCU_ECPLL: length 4.7
  TOP w0.203: U13.127 185.25,31.15 ; C372.1 184.43,31.71 L6.1 184.97,32.96 v1(184.82,33.1)
  TOP w0.254: L6.1 185.25,31.96 185.25,31.15
+3VSPI: length 54.3
  TOP w0.203: v1(122.34,17.41) 122.08,17.66 R448.2 ; v2(120.28,22.01) 120.66,22.39 R411.2
  TOP w0.508: v2(152.44,17.05) 153.25,17.05 v1(154.51,18.31) 154.75,18.55 154.75,20.81 155.33,21.4 157.35,21.4 v2(157.49,21.54)
  IN3 w0.508: v2(152.44,17.05) 152.13,17.36 152.13,17.41 151.73,17.82 150.68,17.82 149.87,17 146.18,17 143.13,20.05 137.96,20.05 137.17,20.84 134.02,20.84 133.62,20.43 v2(131.63,20.43) 131.61,20.41 127.82,20.41 126.02,18.6 122.64,18.6 122.59,18.55
  BOTTOM w0.508: v2(157.49,21.54) 157.49,25.01 159.4,26.91 159.4,28.36 160.06,29.02 161.76,29.02 162.72,29.98 v1(162.75,29.98)
  vias: v2(164.2,32.35) v2(164.78,32.35)
+5V: length 164.9
  TOP w0.381: v1(174.92,26.91) 175.44,27.43 R370.1
  TOP w0.508: v1(110.88,14.85) 109.92,15.81 109.92,18.66 111.31,20.05 111.31,22.97 112.99,24.65 117.84,24.65 118.6,25.41 124.7,25.41 125,25.72 125.85,25.72 125.96,25.61 127.77,25.61 v2(128.54,26.38)
  IN1 w1.016: 15.17,85.2 15.17,88 15.99,88.81 17.71,88.81 18.44,89.53 18.44,91.26 20.51,93.33 20.51,94.73 20.76,94.98 20.76,100.19 22.79,102.22 24.32,102.22 25.08,102.98 33.8,102.98 37.11,99.68 48.5,99.68 49.57,100.75 50.33,100.75 51.57,101.99 56.5,101.99 58.1,100.39 59.99,100.39 60.07,100.47 ; 22.77,70.91 23.43,70.26 23.43,65.39 22.92,64.88 22.92,63.23 20.76,61.07 20.76,58.79 19.62,57.64 17.97,57.64 17.08,56.76 17.08,50.53 18.25,49.36 18.25,47.97 16.38,46.09 16.19,46.09 15.56,45.45 15.56,42.43 16.19,41.79 16.19,39.58 15.87,39.27 15.87,32.71 16.19,32.4
  IN2 w0.762: 174.38,26.55 174.33,26.5 174.33,25.54 173.93,25.14 171.12,25.14 170.67,25.59 170.67,26.06 169.92,26.81 168.52,26.81 167.83,26.12 167.45,26.12 167.27,26.3 165.61,26.3 165.15,25.84 161.07,25.84 160.28,26.63 153.5,26.63
  BOTTOM w0.508: v1(16.93,28.79) 17.87,28.79 17.97,28.69 20.7,28.69 PR256.1
  vias: v1(13.65,85.33) v1(13.65,84.7) v1(16.93,31.99) v1(16.93,31.36) v1(16.93,30.69) v1(17.56,31.99) v1(17.56,31.36) v1(17.56,30.72) v1(18.22,31.99) v1(18.2,31.36) v1(18.2,30.69) v1(45.76,12.53) v1(60.41,101.28) v1(61.05,101.28) v1(174.28,26.91) v1(210.35,24.83) v1(212.13,29.73) v1(212.13,28.74) v1(213.42,28.13) v1(215.73,15.07) v1(215.73,14.44) v1(215.73,13.8) v2(123.25,16.39) v2(123.84,16.39) v2(124.42,16.39) v2(125,16.39) v2(143.93,27.55) v2(144.51,27.57) v2(197.88,15.33)
+5V_HDMIC: length 13.5
  TOP w0.508: D5.3 v1(23.94,71.46)
  IN1 w0.508: v1(19.14,81.9) 19.82,81.22 19.82,77.64 21.41,76.06 21.7,76.06 22.27,75.49 22.27,74.65 22.71,74.21 22.71,73.02 23.94,71.79 v1(23.94,71.46)
  vias: v1(17,83.35)
+5V_KB:
  vias: v1(198.89,13.88)
+5V_PVDD: length 2.6
  BOTTOM w0.203: U30.46 208.35,31.22 209.1,30.47 ; U30.41 208.71,33.22
  vias: v1(209.43,30.47)
+5V_S5: length 403.5
  TOP w0.203: PR31.1 73.09,107.42 v1(72.83,107.68)
  TOP w0.254: v1(57.29,17) 57.67,16.62 C448.1 58,15.98 58.34,15.65 U18.5 ; PR43.2 140.21,67.93 139.71,68.43 139.71,69.4 v1(141.62,71.31)
  TOP w0.381: v1(23.18,17.61) 23.18,17.7 22.79,18.08 R447.2 ; R454.2 54.8,18.4 v1(54.9,18.5) ; v1(49.91,25.11) 49.91,25.22 50.11,25.42 R387.1 ; PR66.1 139.69,43.61 140.75,44.66 140.75,46.32 140.55,46.52 140.55,48.02 141.81,49.27 v1(141.81,50.23)
  TOP w0.508: v1(111.85,54.27) 112.36,54.27 113.23,55.14 v1(113.23,57.32) ; v1(49.91,25.11) 45.5,25.11 45.4,25 45.04,25 44.56,24.52 44.56,24.15 44.2,23.79 43.34,23.79 42.61,24.52 35.62,24.52 35.27,24.88 31.51,24.88 30.34,23.71 30.34,22.9 28.84,21.39 28.84,17.3 v1(29.04,17.09) ; PR40.1 132.29,78.5 v1(132.01,78.5)
  IN1 w0.254: v1(196.4,11.72) 198.13,11.72 198.79,12.38 199.55,12.38 200.5,11.44 201.27,11.44 201.79,11.95 201.79,14.31 200.91,15.19 200.91,15.39 200.36,15.93 200.36,16.53 v1(200.32,16.57) ; v1(54.9,18.5) 55.1,18.3 55.1,17.99 56.09,17 v1(57.29,17)
  IN1 w0.508: v1(54.9,18.5) 54.9,19.59 52.2,22.29 52.2,23.34 51.2,24.34 50.67,24.34 v1(49.91,25.11) ; v1(112.38,66.53) 110.93,67.98 109.23,67.98 107.5,69.71 107.5,75.45 106.69,76.26 106.69,79.28 107.55,80.15 v1(113.98,80.15) 115.63,78.5 129.63,78.5 130.49,79.36 131.66,79.36 132.01,79.01 v1(132.01,78.5) 136.46,74.05 141.26,74.05 141.82,73.49 141.82,71.51 v1(141.62,71.31) 141.59,71.31 140.73,70.45 140.73,69.63 141.24,69.12 141.24,68.31 141.74,67.8 141.74,61.89 143.09,60.54 143.09,59.91 144.19,58.81 144.19,55.83 145.84,54.18 145.84,50.82 145.03,50.01 144.04,50.01 143.4,49.36 142.31,49.36 141.81,49.87 v1(141.81,50.23) ; v1(113.23,57.32) 112.65,57.9 v1(111.64,57.9) ; v1(62.55,116.95) 61.97,116.38 61.97,112.44 61.45,111.92 61.45,109.66 60.82,109.03 59.45,109.03 59.07,108.65 v1(59.07,108.32)
  IN2 w0.508: v1(67.93,123.81) 67.55,124.19 61.28,124.19 60.64,123.56 59.75,123.56 59.24,123.05 59.24,122.16 61.02,120.38 61.02,120.13 61.48,119.67 61.48,118.02 v1(62.55,116.95) 63,116.95 65.11,114.84 68.11,114.84 69.3,113.65 69.3,112.69 72.83,109.16 v1(72.83,107.68) 73.22,108.06 75.04,108.06 76.57,109.59 81.47,109.59 81.93,109.13 82.29,109.13 83.53,107.89 87.36,107.89 88.61,106.64 89.27,106.64 92.44,103.47 92.44,102.79 93.69,101.54 93.69,100.77 92.87,99.96 92.87,92.98 93.78,92.07 94.39,92.07 97.6,88.86 97.6,86.07 98.59,85.08 105.22,85.08 105.9,84.39 109.7,84.39 110.36,83.73 110.36,83.11 113.32,80.15 v1(113.98,80.15) ; v1(27.67,63.49) 27.67,72.79 28.24,73.36 28.24,80.13 28.85,80.74 28.85,91.39 31.39,93.93 31.39,95.19 32.84,96.64 44.65,96.64 44.88,96.87 49.21,96.87 49.72,97.38 49.72,98.79 50.93,100 50.93,100.37 54.81,104.25 55.82,104.25 56.86,105.29 57.36,105.29 57.85,105.78 57.85,106.26 59.07,107.48 v1(59.07,108.32)
  IN3 w0.508: v1(111.64,57.9) 111.14,58.4 111.14,62.03 111.57,62.46 111.57,64.79 112.23,65.44 112.23,66.38 v1(112.38,66.53)
  BOTTOM w0.254: PR155.1 142.19,70.73 v1(141.62,71.31) ; U25.5 112.18,53.2 112.53,53.55 C597.1 112.33,53.79 v1(111.85,54.27) ; v1(196.4,11.72) 196.4,12.08 194.91,13.58 R836.1
  BOTTOM w0.305: PR186.2 137.32,52.69 137.12,52.49 137.12,51.57 136.13,50.58 136.13,49.57 135.44,48.88 135.44,48.45 135.88,48.01 PR216.2 136.19,47.57 136.64,48.02 139.52,48.02 139.79,48.29 141.33,48.29 141.56,48.52 141.56,48.79 141.97,49.21 PR207.2
  BOTTOM w0.381: 76.24,108.38 76.22,108.36 PR145.1 ; v1(111.64,57.9) 111.08,57.9 110.7,57.52 110.7,57.29 R624.1 ; R621.2 113.53,57.75 113.23,57.45 v1(113.23,57.32) ; v1(112.38,66.53) 112.85,67 R613.1
  BOTTOM w0.457: v1(141.81,50.23) 141.81,49.53 PR207.2
  BOTTOM w0.508: v1(27.67,63.49) 27.62,63.49 26.99,62.85 26.99,45.83 25.64,44.49 24.65,44.49 23.43,43.27 ; 76.24,108.38 PR143.1 75.02,108.31 75.02,107.73 74.79,107.5 73,107.5 v1(72.83,107.68)
  vias: v1(14.44,23.43) v1(14.69,24.01) v1(14.95,22.31) v1(15.07,23.43) v1(15.3,24.19) v1(15.71,23.43) v1(15.94,24.24) v1(16.32,23.66) v1(16.57,24.24) v1(19.87,43.55) v1(19.87,42.91) v1(22.01,43.79) v1(22.01,43.14) v1(22.01,42.49) v1(22.01,41.85) v1(26.99,16.88) v1(26.99,16.24) v1(26.99,15.61) v1(26.99,14.97) v1(28.01,17.02) v1(28.01,16.38) v1(28.01,15.75) v1(29.04,16.45) v1(29.04,15.81) v1(29.63,16.83) v1(29.63,16.17) v2(201.81,22.08) v2(202.4,22.08) v2(202.98,22.08) v2(203.73,22.08)
+5VA:
  vias: v1(201.03,36.51) v1(201.61,36.31) v1(202.12,36.71)
+5VODD:
  vias: v1(121.78,22.34)
+5VPCU: length 133.8
  TOP w0.203: v1(28.03,27.29) 28,27.29 27.7,27.6 PR93.2
  TOP w0.254: v2(151.6,26.86) 151.7,26.96 151.7,27.93 151.95,28.18 151.95,34.91 151.06,35.8 149.82,35.8 149.59,36.03 v2(148.78,36.03)
  TOP w0.508: R225.1 R222.1 24.33,50.09 23.76,50.66 v1(23.1,50.66) ; v1(145.3,48.02) 143.93,46.65 143.93,40.88 147.6,37.21 147.8,37.21 148.78,36.23 v2(148.78,36.03) ; PR37.1 23.18,87.36 23.66,86.88 v1(23.66,86.35)
  IN2 w0.508: v1(93.91,89.78) 94.7,88.99 94.7,88.78 95.49,88 95.49,86.11 99.55,82.05 104.22,82.05 105.35,80.93 108.77,80.93 112.81,76.89 112.81,69.4 111.57,68.16 111.57,66.25 112.25,65.58 112.25,60.75 112.81,60.18 112.81,58.62 112.45,58.26 112.45,57.01 112.96,56.5 114.49,56.5 114.87,56.12 114.87,50.62 116.79,48.7 120.93,48.7 123.06,46.57 125.59,46.57 128.38,49.36 139.76,49.36 141.41,47.71 144.99,47.71 v1(145.3,48.02)
  BOTTOM w0.203: v2(196.19,36.6) 195.91,36.32 R694.2 ; PR260.1 154.34,26.91 153.96,26.53 153.15,26.53 153,26.38 151.96,26.38 151.6,26.74 v2(151.6,26.86)
  BOTTOM w0.508: v1(19.37,45.83) 19.67,46.14 22.95,46.14 23.92,47.11 23.92,50.17 23.43,50.66 v1(23.1,50.66)
  vias: v1(18.1,45.83) v1(18.73,45.83) v1(19.06,45.27) v1(23,29.78) v1(23,29.15) v1(23.33,30.34) v1(23.63,29.78) v1(23.56,25.01) v1(23.56,24.37) v1(23.56,23.74) v1(23.66,29.15) v1(23.96,30.34) v1(24.04,28.56) v1(24.19,25.01) v1(24.19,24.37) v1(24.19,23.74) v1(24.27,29.78) v1(24.29,29.15) v1(24.83,25.01) v1(24.83,24.37) v1(24.83,23.74) v1(29.75,19.14) v1(30.34,21.32) v1(30.34,20.69) v1(30.34,20.03) v1(30.34,19.39) v1(30.34,18.76) v1(30.34,18.12) v1(30.34,17.49) v1(30.34,16.72) v1(73.62,101.23) v1(74.26,101.23)
+A3VPCU: length 3.9
  TOP w0.203: U13.74 199.72,19.38 199.86,19.52 200.16,19.52
  TOP w0.254: 200.16,19.52 200.37,19.52 200.6,19.28 C433.1 C434.2 201.69,19.36 L10.2
+V3A_LX_R:
  vias: v1(145.58,27.88)
+V3A_OUT: length 1.1
  BOTTOM w0.203: PR236.1 159.42,35.63 PC226.1
  vias: v1(153.66,35.8) v1(154.27,35.98) v1(154.57,34.23) v1(154.87,35.8) v1(155.05,36.41) v1(155.54,35.88) v1(155.69,36.51) v1(157.16,34.56) v1(157.8,34.56) v1(158.43,34.56)
+V5P5A_LX: length 2.7
  TOP w0.381: PC116.2 39.42,19.54 39.42,20.52 PR114.1
  TOP w0.508: PR114.1 38.95,20.56 v2(38.42,20.03)
  vias: v1(41.84,22.06)
+V5P5A_LX_R: length 2.6
  TOP w0.102: v1(40.67,21.68) PR114.2
  TOP w0.508: PR114.2 PC115.1
+V5P5A_OUT: length 5.8
  BOTTOM w0.254: PR277.2 39.33,14.64 38.19,15.78 35.96,15.78 PC269.1
  vias: v1(32.24,17.03) v1(35.75,20.18) v1(35.75,19.54) v1(35.75,18.91) v1(35.75,18.27) v1(36.13,20.81) v1(36.38,19.93) v1(36.38,19.29) v1(36.38,18.66) v1(36.38,18.02)
+VCC1.05_OUT_FET: length 37.8
  TOP w0.203: v1(99.05,32.75) 98.99,32.7 98.99,32.24 98.87,32.12 97.22,32.12 v1(97.18,32.15) 96.07,33.26 94.42,33.26 94.14,33.54 R300.2
  IN3 w0.254: v1(106.56,53.5) 105.8,52.74 104.23,52.74 104.02,52.54 103.48,52.54 102.86,51.92 102.86,48.32 102.57,48.03 102.57,44.1 103.25,43.42 104.28,43.42 105.85,41.85 105.85,40.58 105.45,40.17 102.73,40.17 102.09,39.53 102.09,38.66 100.42,36.99 100.42,34.45 100.09,34.12 100.09,33.44 100.34,33.18 100.34,32.7 100.04,32.4 99.4,32.4 v1(99.05,32.75)
  vias: v1(107.2,53.5) v1(107.63,64.68) v1(108.27,64.65)
+VCC1.05_OUT_SFR: length 2.5
  BOTTOM w0.305: 98.68,50.81 100.45,52.57
+VCC1.05_OUT_SFR_R: length 10.4
  BOTTOM w0.305: U24.CD2 97.4,50.11 97.71,49.81 98.27,49.81 99,50.54 99.05,50.54
  BOTTOM w0.381: R626.1 103.63,55.51 103.39,55.27 102.4,55.27 102.08,54.96 C595.1 C598.2 101.35,53.83 100.93,53.41 100.93,52.42 99.05,50.54
+VCC_V3A: length 1.7
  BOTTOM w0.203: PU11.9 145.05,33.3 144.77,33.58 144.77,34.29 PC234.1
+VCC_V5P5A: length 1.3
  BOTTOM w0.229: PU15.11 43.33,16.91
  BOTTOM w0.254: PC265.1 43.33,16.19 43.33,16.91
+VCCDPHY_1P24: length 4.5
  BOTTOM w0.254: U24.DW32 83.07,32.17
  BOTTOM w0.508: C653.1 85.26,29.48 85.18,29.48 84.52,30.14 84.52,30.72 83.07,32.17
+VCCDSW_1P05: length 3.2
  TOP w0.254: C338.2 80.45,41.81 80.45,41.44 v2(80.94,40.96)
  BOTTOM w0.254: v2(80.94,40.96) 80.99,40.91 81.57,40.91 81.9,40.58 U24.DD34
+VCCFPGM:
  vias: v1(81.27,69.87) v2(82.36,73.96) v2(82.36,73.2) v2(82.36,72.57) v2(82.36,71.93)
+VCCIN: length 48
  TOP w0.254: C207.1 100.05,74.61 99.48,74.61 99.17,74.31 99.17,73.8 v2(98.92,73.54)
  TOP w0.381: C202.1 99.88,76.38 v2(99.88,76.8)
  BOTTOM w0.102: U24.K31 83.51,76.24 ; U24.K31 83.21,76.54 ; U24.K31 83.51,76.85 ; U24.K31 83.82,76.54 ; 88.67,77.47 U24.H19 ; U24.H19 89.37,77.47 89.37,77.47 ; U24.H19 89,77.1 ; 83.05,76.7 U24.J32 83.06,77 ; 85.19,77 U24.J28 ; U24.J28 84.88,76.69 ; U24.J28 84.88,77.32 ; U24.J28 84.58,77 ; U24.K23 87.48,76.54 ; U24.K23 87.17,76.85 ; U24.K23 87.17,76.24 ; U24.K23 86.87,76.54 ; U24.K19 89,76.24 ; U24.K19 88.7,76.54 ; U24.K19 89,76.85 ; U24.K19 89.31,76.54 ; 89.61,76.54 U24.K17 ; U24.K17 90.22,76.54 ; U24.K17 89.92,76.24 ; U24.K17 89.92,76.85 ; U24.J23 86.71,77.42 ; U24.J23 87.02,77 ; U24.J23 86.71,76.67 ; U24.J23 86.41,77 ; 88.24,77 U24.J20 ; U24.J20 88.54,76.7 ; U24.J20 88.85,77 ; U24.J20 88.54,77.36 ; 84.43,76.85 U24.K29 ; U24.K29 84.73,76.54 ; U24.K29 84.12,76.54 ; U24.K29 84.43,76.24 ; U24.J26 86.11,77 ; U24.J26 85.49,77 ; U24.J26 85.8,76.67 ; U24.J22 87.63,77.16 87.32,77.47 U24.H23 ; U24.J22 87.94,77 ; U24.J22 87.32,77 ; U24.J22 87.63,76.67 ; 89.15,77 U24.J18 ; U24.J18 89.46,77.33 ; U24.J18 89.77,77 ; U24.J18 89.46,76.67 ; 84.8,77.47 84.8,77.47 U24.H29 ; 83.66,77 U24.J30 ; U24.J30 83.97,76.66 ; U24.J30 83.97,77.31 ; U24.J30 84.28,77 ; U24.K24 86.26,76.24 ; U24.K24 86.26,76.85 ; U24.K24 86.56,76.54 ; U24.K24 85.95,76.54 ; 83.36,77 83.06,77 ; 83.06,77 83.28,76.78 ; 85.34,77.13 U24.H27 ; U24.H27 84.98,77.47 ; U24.H27 U24.G27 ; U24.K21 88.09,76.85 ; U24.K21 88.09,76.24 ; U24.K21 87.78,76.54 ; U24.K21 88.39,76.54 ; U24.H29 U24.G29 ; U24.H29 83.99,77.47 ; U24.H29 84.43,77.11 ; U24.H23 87.18,77.46 87.18,77.16 87.17,77.16 ; U24.H23 86.81,77.47 ; U24.H23 U24.G23 ; U24.K27 85.65,76.54 ; U24.K27 85.34,76.85 ; U24.K27 85.04,76.54 ; U24.K27 85.34,76.24
  BOTTOM w0.152: U24.AB1 98.56,70.92 98.66,71.03 v2(98.69,71.03)
  BOTTOM w0.178: PR182.1 120.04,55.24 120.04,51.89 119.68,51.52 PL8.2 ; PR164.1 119.96,63.26 119.66,62.97 116.3,62.97
  BOTTOM w0.203: v2(99.88,76.8) 99.48,76.8 98.82,76.14 98.64,76.14 98.38,75.87 U24.M1 ; v2(98.4,78.63) 98.15,78.38 U24.G1 ; U24.U1 97.78,73.44 98.79,73.44 98.89,73.54 v2(98.92,73.54)
  vias: v1(85.53,84.09) v1(85.56,84.72) v1(85.84,83.5) v1(86.93,85.58) v1(87.16,84.57) v1(87.21,83.93) v1(87.16,83.07) v1(87.16,82.41) v2(81.09,48.35) v2(81.53,53.47) v2(81.53,52.88) v2(81.53,52.3) v2(81.53,51.71) v2(81.53,51.13) v2(81.52,50.53) v2(81.58,47.34) v2(81.58,46.35) v2(81.57,45.35) v2(81.77,49.35) v2(81.88,48.39) v2(82.05,51.45) v2(82.05,50.81) v2(82.15,53.48) v2(82.74,58.18) v2(82.66,56.63) v2(82.76,53.5) v2(82.76,52.92) v2(82.79,52.31) v2(82.9,48.36) v2(83.1,47.34) v2(83.25,56.6) v2(83.32,58.18) v2(83.49,48.37) v2(83.58,46.26) v2(84.83,81.76) v2(84.85,81.05) v2(84.83,79.74) v2(84.83,79.09) v2(84.85,78.43) v2(84.85,77.79) v2(84.85,80.39) v2(84.87,76.35) v2(85.84,79.74) v2(85.83,79.09) v2(86.71,81.01) v2(86.68,80.39) v2(86.68,79.74) v2(86.68,79.09) v2(86.68,78.44) v2(86.68,77.79) v2(86.86,76.17) v2(87.43,72.17) v2(87.43,71.59) v2(87.43,71) v2(87.43,70.39) v2(87.43,69.81) v2(87.43,69.15) v2(87.43,68.46) v2(87.67,79.74) v2(87.67,79.09) v2(88.18,76) v2(88.55,81) v2(88.57,80.39) v2(88.57,79.73) v2(88.56,79.07) v2(88.56,78.45) v2(88.56,77.8) v2(88.61,72.16) v2(88.61,71.58) v2(88.61,70.99) v2(88.61,70.41) v2(88.61,69.82) v2(88.61,69.24) v2(88.61,68.64) v2(88.61,68.06) v2(89.35,76.02) v2(90.59,52.89) v2(90.59,52.31) v2(91.13,72.97) v2(91.13,72.39) v2(91.13,71.8) v2(92.47,55.89) v2(92.47,55.31) v2(92.47,54.72) v2(92.46,53.17) v2(92.49,50.08) v2(92.46,48.53) v2(92.75,49.56) v2(93.03,53.01) v2(93.05,50.27) v2(93.05,48.44) v2(94.38,53.92) v2(94.4,53.03) v4(109.26,75.07) v4(109.99,76.54) v4(109.99,75.81) v4(109.99,75.07) v4(110.76,75.07) v4(111.54,75.07) v4(115.91,70.9) v4(115.89,70.17) v4(115.89,69.43) v4(115.91,68.69) v4(116.24,68.03) v4(116.32,73.57) v4(116.65,70.29) v4(116.7,74.23) v4(116.67,69.51) v4(116.67,68.72) v4(116.9,56.02) v4(116.9,55.26) v4(116.9,54.49) v4(116.9,53.73) v4(117.03,68.06) v4(117,60.36) v4(117,59.63) v4(117,58.89) v4(117.05,73.57) v4(117.18,65.19) v4(117.41,70.22) v4(117.41,69.46) v4(117.41,68.69) v4(117.46,74.23) v4(117.66,65.75) v4(117.66,60.74) v4(117.66,60.01) v4(117.66,59.27) v4(117.66,58.53) v4(117.66,56.02) v4(117.66,55.26) v4(117.66,54.49) v4(117.66,53.73) v4(117.82,73.57) v4(117.79,68.06) v4(117.97,65.06) v4(118.02,64.32) v4(118.02,63.56) v4(118.22,74.23) v4(118.17,70.22) v4(118.17,69.46) v4(118.17,68.69) v4(118.43,65.75) v4(118.43,62.34) v4(118.43,61.58) v4(118.43,60.82) v4(118.43,60.06) v4(118.43,59.3) v4(118.43,58.53) v4(118.43,55.99) v4(118.43,55.23) v4(118.43,54.47) v4(118.43,53.71) v4(118.48,52.97) v4(118.48,52.21) v4(118.58,73.57) v4(118.55,68.06) v4(118.71,65.06) v4(118.76,64.3) v4(118.76,63.54) v4(118.93,70.22) v4(118.93,69.46) v4(118.93,68.69) v4(118.98,74.23) v4(119.19,65.75) v4(119.19,62.34) v4(119.19,61.58) v4(119.19,60.82) v4(119.19,60.06) v4(119.19,59.3) v4(119.19,58.53) v4(119.19,55.99) v4(119.19,55.23) v4(119.19,54.47) v4(119.19,53.71) v4(119.24,52.97) v4(119.24,52.21) v4(119.31,68.06) v4(119.37,73.57) v4(119.37,64.73) v4(119.7,70.22) v4(119.7,69.46) v4(119.7,68.69) v4(119.95,62.34) v4(119.95,61.58) v4(119.95,60.82) v4(119.95,60.06) v4(119.95,59.3) v4(119.95,58.53)
+VCCIN_AUX: length 10.9
  BOTTOM w0.203: 99.88,46.6 98.56,46.6 98.03,46.06 97.89,46.06 U24.CN1 ; U24.U12 91.86,73.6 U24.T13 91.16,73.6 91.13,73.63 v2(91.05,73.63) ; U24.DC1 98.49,40.96 98.51,40.98 v2(98.54,40.98) ; U24.P13 92.32,74.29 U24.R12 ; v2(98.56,48.38) U24.CH1 ; v2(98.57,43.43) U24.CV1
  BOTTOM w0.254: v2(91.05,74.29) 91.31,74.29 U24.P13
  BOTTOM w0.381: v1(101.97,46.32) 101.97,46.44 101.48,46.93 C602.2 101.11,46.93 100.77,46.6 99.88,46.6
  vias: v1(103.11,46.01) v1(103.11,45.38) v1(103.11,44.74) v1(103.41,46.57) v1(103.74,46.01) v1(103.74,45.38) v1(103.74,44.74) v1(104.43,65.04) v1(104.43,64.4) v1(104.43,63.77) v1(104.89,65.49) v1(115.45,47.23) v2(85.84,50.28) v2(85.84,47.69) v2(85.89,53.22) v2(85.86,52.61) v2(85.89,52.03) v2(85.89,51.45) v2(85.89,50.86) v2(85.86,49.29) v2(86.42,53.5) v2(86.4,52.92) v2(86.4,52.34) v2(86.42,51.73) v2(86.42,51.12) v2(86.42,47.71) v2(86.96,62.75) v2(86.96,62.17) v2(87.72,62.75) v2(87.72,62.14) v2(88.5,62.72) v2(88.5,62.14) v2(89.95,62.77) v2(91.2,62.77) v2(92.01,41.01) v2(92.5,46.81) v2(92.55,45.59) v2(92.49,44.99) v2(92.49,43.93) v2(92.49,42.71) v2(92.65,62.75) v2(92.6,61.67) v2(92.59,41.01) v2(92.65,63.93) v2(92.65,63.35) v2(92.65,61.07) v2(93.04,46.61) v2(93.04,44.78) v2(93.04,42.95) v4(114.06,42) v4(114.44,41.36) v4(114.84,42) v4(115.23,41.36) v4(115.61,42) v4(115.99,41.36) v4(116.34,42.02) v4(116.47,45.73) v4(116.47,44.99) v4(116.47,44.26) v4(116.47,43.52) v4(116.47,42.79) v4(116.57,39.36) v4(116.57,38.59) v4(116.57,37.83) v4(116.72,41.34) v4(117.11,42.02) v4(117.21,45.73) v4(117.21,44.99) v4(117.21,44.26) v4(117.21,43.52) v4(117.21,42.79) v4(117.21,38.98) v4(117.21,38.21) v4(117.21,37.45) v4(117.46,41.34) v4(117.84,42.02) v4(117.84,39.36) v4(117.84,38.59) v4(117.84,37.83) v4(117.94,45.73) v4(117.94,44.99) v4(117.94,44.26) v4(117.94,43.52) v4(117.94,42.79) v4(118.2,41.34) v4(118.6,45.38) v4(118.6,44.64) v4(118.6,43.9) v4(118.6,43.17) v4(118.63,42.43) v4(118.83,41.72)
+VCCIO_OUT: length 26.6
  TOP w0.203: R185.1 R180.1
  TOP w0.508: v2(94.4,69.48) 94.4,69.35 93.86,68.82 92.95,68.82 92.34,69.43 92.34,72.83 91.68,73.49 91.68,75.76 92.26,76.33 92.26,78.35 v1(92.71,78.79) 93.15,79.23 94.42,79.23 ; 97.47,78.47 97.47,78.57 98.16,79.26 101.03,79.26 101.56,78.73 102.6,78.73 102.8,78.93 104.15,78.93 104.18,78.95 106.39,78.95 107.12,78.22
  BOTTOM w0.254: U24.AD7 94.4,69.61 v2(94.4,69.48)
+VCCLDOSTD_OUT_0P85: length 3.6
  BOTTOM w0.079: 80.19,32.1 80.33,32.24
  BOTTOM w0.254: U24.DW37 80.45,32.62 80.33,32.5 80.33,32.24
  BOTTOM w0.381: 80.19,32.1 80.17,32.09 C652.2
+VCCPFUSE_3P3: length 17.6
  TOP w0.254: R279.2 96.46,38.09 95.78,38.76 94.07,38.76 93.6,39.23 91.6,39.23 91.15,38.77 89.26,38.77 89,38.52 87.11,38.52 86.77,38.17 84.65,38.17 83.65,39.18 82.66,39.18 82.48,39.36 82.48,39.86 82.92,40.3 v2(82.92,40.33)
  BOTTOM w0.254: U24.DC33 82.41,40.87 82.92,40.35 v2(82.92,40.33)
+VCCPLL_OC: length 3
  BOTTOM w0.152: v2(73.47,48.4) 73.67,48.4 74,48.73 U24.CG49
  BOTTOM w0.203: v2(79.65,49.33) 79.95,49.02 U24.CG38 ; U24.CG41 78.65,48.95 v2(78.27,49.33) 78,49.06 U24.CG42
  vias: v1(63.1,51.75)
+VCCPRIM_3P3: length 1.7
  BOTTOM w0.33: U24.DG26 85.98,38.67 86.25,38.93 86.25,38.98 86.25,38.99 v2(86.28,38.99) 86.36,38.99 U24.DF23 ; U24.DG28 85.09,38.67 85.39,38.96 85.39,38.97 85.41,38.99 v2(85.49,38.99)
  vias: v1(100.62,33.72) v1(101.26,33.72)
+VCCRTC: length 28.3
  IN1 w0.508: v1(71.23,34.81) 71.23,34.53 70.53,33.83 70.53,32.61 66.99,29.07 66.99,26.45 66.48,25.94 v1(66.13,25.94)
  IN2 w0.508: v2(82.12,38.25) 81.34,37.47 81.34,34.02 80.81,33.49 79.69,33.49 79.61,33.56 75.91,33.56 74.99,34.48 74.99,35.04 74.36,35.67 72.83,35.67 72.48,35.32 71.74,35.32 v1(71.23,34.81)
  BOTTOM w0.33: U24.DG33 82.54,38.62 82.17,38.25 v2(82.12,38.25)
+VCCST: length 125.8
  TOP w0.381: v1(137.18,50.33) 135.9,50.33 135.22,49.64 v1(135.22,49.24) 135.22,48.07 v1(135.09,47.94)
  IN1 w0.381: v1(135.09,47.94) 133.56,49.47 133.56,50.07 130.34,53.3 124.75,53.3 124.34,52.89 124.34,49.9 v1(123.43,48.99)
  IN1 w0.508: v1(123.43,48.99) 115.63,48.99 114.93,49.68 114.93,55.65 114.34,56.25 111.24,56.25 110.4,57.09 110.4,60.74 109.76,61.38 v1(109.76,62.98) ; v1(103.59,83.15) 103.52,83.08 v1(103.52,81.39) 103.52,80.31 v1(103.52,80.3) 103.52,79.28 104.46,78.35 104.46,75.75 106.26,73.95 106.26,66.92 107.05,66.13 108.39,66.13 109,65.52 v1(109,63.05)
  IN3 w0.508: v1(139.48,31.35) 136.36,31.35 135.67,32.04 135.67,32.9 135.09,33.49 134.53,33.49 133.31,34.71 131.32,34.71 125.4,40.62 125.4,47.02 v1(123.43,48.99) ; v1(109,63.05) 108.62,62.67 105.32,62.67 103.06,60.41 103.06,58.91 102.58,58.43 v1(100.52,58.43) 100.52,57.95 101.58,56.89 101.58,52.06 v1(102.13,51.51)
  BOTTOM w0.203: R633.1 101.72,51.92 v1(102.13,51.51) 102.27,51.66 102.27,52.03 R638.1 ; R591.2 103.11,80.3 v1(103.52,80.3) ; R588.2 103.47,81.44 v1(103.52,81.39) ; R584.2 v1(103.59,83.15) 103.72,83.27 R585.2 ; PC242.1 138.2,31.27 PR252.2
  BOTTOM w0.305: 98.37,51.69 99.43,52.75 99.43,53.41
  BOTTOM w0.381: v1(137.18,50.33) 137.72,50.33 PR200.1
  BOTTOM w0.508: v1(139.48,31.35) 139.39,31.27 PC242.1
