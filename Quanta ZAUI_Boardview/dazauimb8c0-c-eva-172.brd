# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ30: length 54.3
  TOP w0.102: U6.H3 v1(41.07,55.83)
  IN3 w0.089: v2(78.41,70.4) 77.98,70.84 77.44,70.84 77.31,70.96 76.42,70.96 76.15,70.69 74.45,70.69 74.22,70.47 71.05,70.47 66.65,66.08 66.08,66.08 64.73,64.73 64.2,64.73 63.37,63.9 63.37,62.47 62.15,61.25 62.15,60.3 57.35,55.49 57.35,54.39 56.91,53.95 54.94,53.95 53.68,52.69 50.78,52.69 49.01,50.92 48.43,50.92 47.76,50.25 47.59,50.25 47.5,50.34 47.5,50.55 47.41,50.63 47.29,50.63 47.21,50.55 47.21,50.34 47.12,50.25 44.49,50.25 44.11,50.63 44.1,50.63 43.87,50.86 43.87,50.87 43.29,51.45 43.29,54.85 42.42,55.72 41.18,55.72 v1(41.07,55.83)
  BOTTOM w0.079: v2(78.41,70.4) 78.41,70.35 U24.AD42
M_B_DQ31: length 53.7
  TOP w0.102: v1(41.07,52.63) 40.27,52.63 U6.J7
  IN3 w0.089: v1(41.07,52.63) 41.07,52.42 40.94,52.29 40.94,49.82 43.03,47.73 49.09,47.73 50.4,49.03 55.69,49.03 59.06,52.41 59.32,52.41 61.4,54.49 61.4,56.46 64.43,59.5 64.43,60.44 65.84,61.85 65.84,62.76 67.78,64.71 67.78,64.84 71.64,68.69 75.12,68.69 75.37,68.44 76.28,68.44 76.53,68.69 77.65,68.69 v2(77.76,68.58)
  BOTTOM w0.079: v2(77.76,68.58) 78,68.82 U24.AE42
M_B_DQ32: length 49.9
  TOP w0.102: U4.F7 v1(41.87,73.33)
  IN3 w0.089: v2(66.1,82.41) 65.73,82.78 65.34,82.78 65.19,82.63 58.38,82.63 57.84,82.09 51.29,82.09 47.24,78.04 46.37,78.04 44.95,76.62 44.95,75.15 43.57,73.77 43.57,73.58 43.48,73.49 43.18,73.49 43.1,73.4 43.1,73.22 43.18,73.14 43.48,73.14 43.57,73.05 43.57,72.87 43.48,72.78 43.18,72.78 43.1,72.69 43.1,72.51 43.18,72.42 43.48,72.42 43.57,72.34 43.57,72.16 43.48,72.07 42.99,72.07 42.9,71.98 42.9,71.8 42.99,71.71 43.48,71.71 43.57,71.62 43.57,71.45 43.48,71.36 42.99,71.36 42.9,71.27 42.9,71.09 42.99,71 43.48,71 43.57,70.91 43.57,70.73 43.49,70.65 42.6,70.65 42.52,70.73 42.52,72.05 42.27,72.29 U4.F7 v1(41.87,73.33)
  BOTTOM w0.079: U24.J48 74.94,76.99 74.77,76.82 74.59,76.8 74.43,76.72 74.18,76.72 74.04,76.86 72.79,76.86 71.8,77.85 71.44,77.85 69.2,80.09 68.95,80.09
  BOTTOM w0.102: 68.95,80.09 68.41,80.09 66.1,82.4 v2(66.1,82.41)
M_B_DQ33: length 51
  TOP w0.102: U4.H7 v1(41.07,73.33)
  IN3 w0.089: v1(41.07,73.33) 41.47,73.73 43.19,73.73 44.71,75.25 44.71,76.95 44.67,76.99 44.67,77.5 45.16,77.99 45.29,77.99 45.57,77.71 45.69,77.71 45.82,77.83 45.82,77.96 45.54,78.24 45.54,78.37 45.66,78.49 45.79,78.49 46.07,78.21 46.19,78.21 46.32,78.34 46.32,78.46 46.04,78.74 46.04,78.87 46.17,78.99 46.29,78.99 47,78.28 47.14,78.28 47.26,78.4 47.26,78.53 46.54,79.25 46.54,79.37 46.67,79.5 46.79,79.5 47.49,78.8 47.66,78.8 47.76,78.9 47.76,79.04 47.05,79.75 47.05,79.87 47.16,79.99 47.31,79.99 47.97,79.32 48.18,79.32 48.96,80.1 51.19,82.33 57.74,82.33 58.28,82.87 65.09,82.87 65.24,83.02 67.22,83.02 67.38,82.85 v2(67.51,82.85)
  BOTTOM w0.079: 68.9,81.59 71.81,78.67 72.88,78.67 73.3,78.26 73.3,78.21 73.64,77.87 74.42,77.87 74.6,77.92 74.72,77.92 74.86,77.87 75.11,77.87 75.31,77.97 75.31,77.96 76.13,77.96 76.27,77.82 U24.J45
  BOTTOM w0.102: 68.9,81.59 67.63,82.85 v2(67.51,82.85)
M_B_DQ34: length 48.7
  TOP w0.102: v1(41.06,74) 40.45,73.39 40.45,73.21 40.17,72.93 U4.J7
  IN3 w0.089: v2(65.54,83.43) 65.48,83.49 65,83.49 64.91,83.4 64.91,83.21 64.83,83.12 64.65,83.12 64.56,83.21 64.56,83.4 64.47,83.49 64.29,83.49 64.2,83.4 64.2,83.21 64.11,83.12 63.94,83.12 63.85,83.21 63.85,83.4 63.76,83.49 63.58,83.49 63.49,83.4 63.49,83.21 63.4,83.12 63.22,83.12 63.14,83.21 63.14,83.4 63.05,83.49 62.87,83.49 62.78,83.4 62.78,83.21 62.69,83.12 62.51,83.12 62.42,83.21 62.42,83.4 62.34,83.49 62.16,83.49 62.07,83.4 62.07,83.21 61.98,83.12 61.8,83.12 61.71,83.21 61.71,83.4 61.62,83.49 61.45,83.49 61.36,83.4 61.36,83.21 61.27,83.12 61.09,83.12 61,83.21 61,83.4 60.91,83.49 60.74,83.49 60.65,83.4 60.65,83.21 60.56,83.12 60.38,83.12 60.29,83.21 60.29,83.4 60.2,83.49 60.02,83.49 59.94,83.4 59.94,83.21 59.85,83.12 59.67,83.12 59.58,83.21 59.58,83.4 59.49,83.49 59.31,83.49 59.22,83.4 59.22,83.21 59.14,83.12 58.96,83.12 58.87,83.21 58.87,83.4 58.78,83.49 58.29,83.49 57.38,82.57 51.09,82.57 49.42,80.9 49.21,80.9 49.08,81.04 48.81,81.04 48.68,80.9 48.47,80.9 48.33,81.04 48.11,81.04 47.98,80.9 47.73,80.9 44.56,77.73 44.1,77.73 43.87,77.5 43.87,76.37 44.47,75.77 44.47,75.35 43.09,73.97 41.09,73.97 v1(41.06,74)
  BOTTOM w0.079: U24.J49 74.28,77.03 72.85,77.03 71.87,78.01 71.51,78.01 69.02,80.5
  BOTTOM w0.102: 69.02,80.5 68.59,80.5 66.25,82.84 66.13,82.84 v2(65.54,83.43)
M_B_DQ35: length 49.3
  TOP w0.102: U4.H3 v1(41.07,75.73)
  IN3 w0.089: v2(67.37,83.43) 67.37,83.69 66.22,84.84 65.31,84.84 65.15,84.68 64.96,84.68 64.8,84.84 64.6,84.84 64.44,84.68 64.25,84.68 64.09,84.84 63.89,84.84 63.73,84.68 63.54,84.68 63.38,84.84 63.18,84.84 63.02,84.68 62.82,84.68 62.67,84.84 62.47,84.84 62.31,84.68 62.11,84.68 61.95,84.84 61.76,84.84 61.6,84.68 61.4,84.68 61.24,84.84 61.05,84.84 60.89,84.68 60.69,84.68 60.53,84.84 60.33,84.84 60.18,84.68 59.98,84.68 59.82,84.84 59.62,84.84 59.46,84.68 59.27,84.68 59.11,84.84 58.91,84.84 58.75,84.68 58.56,84.68 58.4,84.84 57.95,84.84 57.29,84.17 54.37,84.17 54.28,84.09 54.28,83.87 54.19,83.78 54.01,83.78 53.93,83.87 53.93,84.09 53.84,84.17 50.82,84.17 50.02,83.37 49.74,83.37 49.64,83.27 49.64,83.01 49.56,82.92 49.38,82.92 49.29,83.01 49.29,83.25 49.17,83.37 48.64,83.37 47.91,82.64 47.91,82.32 47.82,82.23 46.57,82.23 46.48,82.14 46.48,82.02 46.39,81.93 46.21,81.93 46.12,82.02 46.12,82.14 46.03,82.23 45.74,82.23 45.44,81.93 45.44,81.8 45.49,81.75 45.49,81.62 45.37,81.5 45.24,81.5 45.19,81.55 45.06,81.55 44.94,81.43 44.94,81.3 45.17,81.07 45.17,80.97 45.04,80.84 44.89,80.84 44.68,81.05 44.56,81.05 44.43,80.92 44.43,80.8 44.49,80.74 44.49,80.62 44.36,80.49 44.23,80.49 44.18,80.55 44.06,80.55 43.93,80.42 43.93,80.29 43.98,80.24 43.98,80.12 43.86,79.99 43.73,79.99 43.68,80.04 43.55,80.04 43.43,79.92 43.43,79.79 43.64,79.58 43.64,79.43 43.52,79.31 43.41,79.31 43.18,79.54 43.05,79.54 42.92,79.41 42.92,79.29 42.98,79.24 42.98,79.11 42.85,78.98 42.73,78.98 42.67,79.04 42.55,79.04 42.27,78.76 42.27,77.16 42.05,76.95 42.04,76.93 41.7,76.93 41.47,76.7 41.47,76.13 v1(41.07,75.73)
  BOTTOM w0.076: 69.7,81.14 70.04,80.8 70.04,80.68
  BOTTOM w0.079: 70.04,80.68 71.88,78.84 72.95,78.84 73.47,78.33 73.47,78.29 73.73,78.03 74.39,78.03 74.57,78.09 74.76,78.09 74.9,78.03 75.07,78.03 75.51,78.26 U24.G47
  BOTTOM w0.102: v2(67.37,83.43) 67.6,83.43 68.19,82.84 68.19,82.66 69.7,81.14
M_B_DQ36: length 50.3
  TOP w0.102: U4.H8 v1(41.07,72.53)
  IN3 w0.089: v1(41.07,72.53) 41.47,72.13 42.09,72.13 42.28,71.94 42.28,70.7 42.1,70.52 42.1,69.99 42.19,69.9 42.43,69.9 42.52,69.99 42.52,70.32 42.61,70.4 42.78,70.4 42.87,70.32 42.87,69.99 42.96,69.9 43.14,69.9 43.23,69.99 43.23,70.32 43.32,70.4 43.5,70.4 43.58,70.32 43.58,69.99 43.67,69.9 43.97,69.9 44.05,69.99 44.05,70.52 43.81,70.77 43.81,73.67 45.19,75.05 45.19,76.52 46.47,77.8 47.34,77.8 51.39,81.85 57.94,81.85 58.48,82.39 65.51,82.39 v2(65.52,82.38)
  BOTTOM w0.076: 68.82,79.82 69.22,79.82 71.06,77.97
  BOTTOM w0.079: 71.06,77.97 71.36,77.68 71.73,77.68 72.72,76.69 73.97,76.69 74.11,76.55 74.48,76.55 74.64,76.64 75.12,76.69 U24.J47
  BOTTOM w0.102: v2(65.52,82.38) 68.08,79.82 68.82,79.82
M_B_DQ37: length 49.5
  TOP w0.102: U4.H2 v1(41.07,76.53)
  IN3 w0.089: v1(41.07,76.53) 40.85,76.31 40.76,76.31 40.56,76.5 40.56,77.95 40.65,78.04 41.12,78.04 41.21,78.13 41.21,78.31 41.12,78.39 40.65,78.39 40.56,78.48 40.56,78.89 41.72,80.05 41.84,80.05 42.27,79.62 42.4,79.62 42.52,79.75 42.52,79.87 42.1,80.3 42.1,80.42 42.22,80.55 42.35,80.55 42.77,80.12 42.9,80.12 43.03,80.25 43.03,80.37 42.6,80.8 42.6,80.93 44.39,82.71 47.3,82.71 48.44,83.85 49.52,83.85 51.04,85.37 66.42,85.37 68.58,83.22 69.16,83.22 69.35,83.02 69.35,82.87 v2(69.38,82.84)
  BOTTOM w0.079: 70.93,80.45 70.93,80.27 72,79.19 73.53,79.19 73.77,78.95 74.49,78.95 74.68,78.76 75.11,78.76 75.27,78.6 75.75,78.6 76.09,78.26 U24.G45
  BOTTOM w0.102: v2(69.38,82.84) 69.38,82.71 70.93,81.16 70.93,80.45
M_B_DQ38: length 47.6
  TOP w0.102: U4.G2 41.47,76.93 v1(41.87,77.33)
  IN3 w0.089: v1(41.87,77.33) 41.59,77.33 41.46,77.46 41.46,78.29 41.92,78.75 41.92,79 42.05,79.13 42.3,79.13 43.46,80.29 43.46,80.41 43.03,80.84 43.03,80.96 43.16,81.09 43.28,81.09 43.71,80.66 43.83,80.66 43.96,80.79 43.96,80.92 43.53,81.34 43.53,81.47 43.66,81.59 43.78,81.59 44.21,81.17 44.34,81.17 45.05,81.88 45.05,82.01 45.03,82.03 45.03,82.16 45.15,82.29 45.28,82.29 45.3,82.26 45.43,82.26 45.64,82.47 47.4,82.47 48.54,83.61 49.66,83.61 50.47,84.42 53.41,84.42 53.5,84.5 53.5,85.04 53.59,85.13 53.77,85.13 53.86,85.04 53.86,84.5 53.95,84.42 54.13,84.42 54.21,84.5 54.21,85.04 54.3,85.13 54.48,85.13 54.57,85.04 54.57,84.5 54.66,84.42 55.08,84.42 55.23,84.57 55.37,84.57 55.52,84.42 55.74,84.42 55.92,84.59 56.27,84.59 56.45,84.42 56.62,84.42 56.75,84.55 56.9,84.55 57.03,84.42 57.19,84.42 57.85,85.08 66.38,85.08 67.75,83.71 67.75,83.15 67.93,82.97 68.06,82.97 68.2,83.11 68.35,83.11 v2(68.62,82.84)
  BOTTOM w0.079: U24.G48 74.89,78.31 74.42,78.78 73.7,78.78 73.46,79.03 71.93,79.03 70.47,80.48 70.47,80.73
  BOTTOM w0.102: v2(68.62,82.84) 70.47,80.98 70.47,80.73
M_B_DQ39: length 46.8
  TOP w0.102: v1(41.18,75.04) 41.03,75.2 40.65,75.2 39.87,75.98 U4.J3
  IN3 w0.089: v2(69.96,82.84) 69.58,83.23 69.49,83.23 69.26,83.46 68.68,83.46 66.52,85.62 50.94,85.62 49.42,84.09 48.34,84.09 47.2,82.96 44.29,82.96 40.32,78.99 40.32,76.39 40.65,76.06 40.65,75.58 v1(41.18,75.04)
  BOTTOM w0.079: 71.18,80.3 72.12,79.36 73.59,79.36 73.84,79.12 74.74,79.12 U24.E48
  BOTTOM w0.102: 71.18,80.3 71.18,81.29 69.96,82.51 v2(69.96,82.84)
M_B_DQ40: length 43.8
  TOP w0.102: U4.C2 45.07,76.53 45.07,75.79 v1(45.83,75.02)
  IN3 w0.089: v2(79.56,77.71) 79.91,78.06 79.91,78.75 79.09,79.58 76.75,81.92 75.11,81.92 74.58,82.45 66.69,82.45 66.24,82 58.65,82 58.11,81.46 53.25,81.46 52.41,80.62 50.72,80.62 47.08,76.98 47.08,76.32 46.84,76.07 46.4,76.07 46.28,75.94 46.28,75.77 46.46,75.59 46.46,75.48 46,75.02 v1(45.83,75.02)
  BOTTOM w0.076: v2(79.56,77.71) 79.95,77.32 U24.J38
M_B_DQ41: length 42.6
  TOP w0.102: v1(45.07,74.36) 43.87,75.56 U4.D3
  IN3 w0.089: v2(78.93,78.6) 78.52,79.01 77.98,79.01 77.1,79.89 77.1,80.88 76.55,81.44 74.91,81.44 74.38,81.96 66.89,81.96 66.44,81.51 58.85,81.51 57.56,80.22 53,80.22 52.87,80.1 50.88,80.1 47.57,76.78 47.57,76.12 47.05,75.6 47.05,74.94 46.74,74.62 45.33,74.62 v1(45.07,74.36)
  BOTTOM w0.076: v2(78.93,78.6) 79.3,78.23 U24.G39
M_B_DQ42: length 42.4
  TOP w0.102: U4.A3 46.62,75.78 v1(46.62,75.08)
  IN3 w0.089: v1(46.62,75.08) 46.81,75.27 46.81,75.7 47.32,76.22 47.32,76.88 50.82,80.38 52.51,80.38 53.35,81.22 58.21,81.22 58.75,81.75 66.34,81.75 66.79,82.21 74.48,82.21 75.01,81.68 76.65,81.68 77.75,80.58 77.75,80.45 77.4,80.11 77.4,79.98 77.53,79.86 77.65,79.86 78,80.2 78.12,80.2 78.25,80.08 78.25,79.95 77.88,79.58 77.88,79.46 78.01,79.33 78.13,79.33 78.5,79.7 78.63,79.7 78.9,79.43 78.9,79.3 78.89,79.29 78.89,79.17 79.02,79.04 79.14,79.04 79.15,79.05 79.28,79.05 79.54,78.79 v2(79.54,78.6)
  BOTTOM w0.076: v2(79.54,78.6) 79.56,78.6 79.95,78.21 U24.G38
M_B_DQ43: length 42.4
  TOP w0.102: v1(45.78,74.2) 45.78,74.33 44.67,75.44 U4.C3
  IN3 w0.089: v2(77.66,78.73) 77.66,78.99 76.86,79.79 76.86,80.12 76.78,80.2 76.25,80.2 76.17,80.28 76.17,80.74 76.06,80.85 75.9,80.85 75.81,80.75 75.81,80.09 75.7,79.98 75.58,79.98 75.46,80.1 75.46,81.09 75.35,81.2 74.81,81.2 74.28,81.72 66.99,81.72 66.54,81.27 58.95,81.27 57.66,79.98 53.14,79.98 53.01,79.86 50.98,79.86 47.81,76.68 47.81,76.02 47.29,75.5 47.29,74.84 46.78,74.33 45.91,74.33 v1(45.78,74.2)
  BOTTOM w0.076: v2(77.66,78.73) 77.66,78.6 78,78.26 U24.G42
M_B_DQ44: length 44.5
  TOP w0.102: U4.D7 v1(44.27,73.33)
  IN3 w0.089: v2(79.06,76.82) 78.57,76.34 77.58,76.34 77.07,76.84 76.48,76.84 75.73,77.58 72.07,77.58 70.3,79.35 59.74,79.35 57.77,77.39 51.25,77.39 50.25,76.39 50.25,75.09 48.35,73.19 48.35,72.78 46.08,70.51 44.91,70.51 44.67,70.74 44.67,72.93 v1(44.27,73.33)
  BOTTOM w0.076: U24.J39 79.3,77.06 v2(79.06,76.82)
M_B_DQ45: length 43.2
  TOP w0.102: U4.B8 v1(45.87,71.73)
  IN3 w0.089: v1(45.87,71.73) 46.03,71.57 46.46,71.57 47.87,72.98 47.87,73.39 49.77,75.29 49.77,76.59 51.05,77.87 57.57,77.87 59.54,79.84 72.51,79.84 72.6,79.75 72.6,78.69 72.68,78.61 72.86,78.61 72.95,78.7 72.95,79.75 73.04,79.84 73.22,79.84 73.31,79.75 73.31,78.7 73.4,78.61 73.49,78.61 73.66,78.78 73.66,79.41 73.75,79.5 73.93,79.5 74.02,79.41 74.02,78.81 74.24,78.59 74.24,78.21 74.38,78.07 75.93,78.07 76.68,77.32 77.4,77.32 77.66,77.58 v2(77.66,77.71)
  BOTTOM w0.076: v2(77.66,77.71) 78,77.37 U24.J42
M_B_DQ46: length 41.9
  TOP w0.102: U4.C7 v1(45.07,72.53)
  IN3 w0.089: v1(45.07,72.53) 45.07,72.2 45.12,72.15 45.5,72.15 45.74,72.39 45.92,72.39 46.37,71.94 46.49,71.94 47.63,73.08 47.63,73.49 49.53,75.39 49.53,76.69 50.95,78.11 53.95,78.11 54.04,78.2 54.04,78.2 54.13,78.29 54.31,78.29 54.4,78.2 54.4,78.2 54.49,78.11 54.66,78.11 54.75,78.2 54.75,78.2 54.84,78.29 55.02,78.29 55.11,78.2 55.11,78.2 55.2,78.11 55.37,78.11 55.46,78.2 55.46,78.2 55.55,78.29 55.73,78.29 55.82,78.2 55.82,78.2 55.91,78.11 56.09,78.11 56.17,78.2 56.17,78.2 56.26,78.29 56.44,78.29 56.53,78.2 56.53,78.2 56.62,78.11 56.89,78.11 57.48,78.7 58.06,78.7 59.44,80.08 67.03,80.08 67.25,80.3 67.55,80.3 67.77,80.08 68.68,80.08 68.84,80.24 69,80.24 69.16,80.08 70.07,80.08 70.2,80.21 70.41,80.21 70.54,80.08 71.47,80.08 71.69,80.3 71.88,80.3 72.1,80.08 72.37,80.08 72.63,80.34 72.86,80.34 73.13,80.08 73.47,80.08 73.57,79.98 73.57,79.85 73.65,79.77 73.84,79.77 73.93,79.86 73.93,79.99 74.01,80.08 74.15,80.08 74.26,79.97 74.26,78.91 74.48,78.69 74.48,78.41 74.59,78.31 76.03,78.31 76.76,77.58 76.95,77.58 v2(77.07,77.71)
  BOTTOM w0.076: U24.G43 77.35,77.99 v2(77.07,77.71)
M_B_DQ47: length 43.1
  TOP w0.102: U4.C8 v1(45.07,71.73)
  IN3 w0.089: v2(77.68,76.82) 77.54,76.82 77.28,77.08 76.58,77.08 75.83,77.82 72.68,77.82 72.33,78.17 71.87,78.17 71.79,78.26 71.79,78.43 71.89,78.53 72.19,78.53 72.27,78.61 72.27,78.79 72.17,78.88 71.27,78.88 71.17,78.98 71.17,79.15 71.26,79.24 72.19,79.24 72.27,79.32 72.27,79.5 72.17,79.6 59.64,79.6 57.67,77.63 51.15,77.63 50.01,76.49 50.01,75.19 48.11,73.29 48.11,72.88 46.57,71.33 45.47,71.33 v1(45.07,71.73)
  BOTTOM w0.076: v2(77.68,76.82) 77.66,76.82 77.35,77.13 U24.J43
M_B_DQ48: length 43.4
  TOP w0.102: U2.C7 v1(45.07,85.83)
  IN3 w0.089: v2(75.8,84.47) 75.68,84.35 72.9,84.35 72.81,84.26 72.81,83.76 72.72,83.67 72.55,83.67 72.46,83.76 72.46,84.26 72.37,84.35 72.19,84.35 72.1,84.26 72.1,83.76 72.01,83.67 71.84,83.67 71.75,83.76 71.75,84.26 71.66,84.35 69.95,84.35 69.72,84.57 69.15,84.57 66.55,87.17 65.62,87.17 65.18,86.73 58.68,86.73 58.6,86.82 58.6,87.08 58.51,87.17 58.33,87.17 58.24,87.08 58.24,86.82 58.15,86.73 57.97,86.73 57.88,86.82 57.88,87.08 57.8,87.17 57.62,87.17 57.53,87.08 57.53,86.82 57.44,86.73 57.26,86.73 57.17,86.82 57.17,87.08 57.08,87.17 56.91,87.17 56.82,87.08 56.82,86.82 56.73,86.73 50.48,86.73 49.17,85.43 47.59,85.43 47.44,85.29 47.44,84.79 47.35,84.7 47.17,84.7 47.08,84.79 47.08,85.34 46.99,85.43 45.47,85.43 v1(45.07,85.83)
  BOTTOM w0.079: v2(75.8,84.47) 76.72,83.55 76.72,82.02 77.19,81.54 77.19,81.26 77.48,80.97 U24.B43
M_B_DQ49: length 44.8
  TOP w0.102: v1(44.94,87.08) 43.87,88.16 U2.D3
  IN3 w0.089: v2(75.42,85.58) 75.39,85.55 70.45,85.55 70.23,85.77 69.95,85.77 66.64,89.07 62.53,89.07 62.44,88.98 62.44,88.45 62.36,88.37 62.18,88.37 62.09,88.46 62.09,88.98 62,89.07 61.82,89.07 61.73,88.98 61.73,88.45 61.65,88.37 61.47,88.37 61.37,88.46 61.37,88.71 61.29,88.8 61.11,88.8 61.02,88.71 61.02,88.45 60.93,88.37 50.06,88.37 48.78,87.08 v1(44.94,87.08)
  BOTTOM w0.079: U24.D43 77.48,79.42 77.15,79.74 77.15,81.06 77.02,81.19 77.02,81.47 76.52,81.98 76.52,83.15 75.4,84.26 75.4,84.59
  BOTTOM w0.102: 75.4,84.59 75.42,84.62 v2(75.42,85.58)
M_B_DQ50: length 41.4
  TOP w0.102: U2.B8 v1(45.87,85.03)
  IN3 w0.089: v1(45.87,85.03) 46.27,84.63 46.27,84.07 46.5,83.83 46.84,83.83 47.97,84.97 49.05,84.97 50.58,86.49 65.28,86.49 65.72,86.93 66.45,86.93 69.05,84.33 69.62,84.33 69.85,84.1 70.72,84.1 71.4,83.43 73.87,83.43 73.96,83.51 73.96,83.95 74.05,84.03 74.23,84.03 74.31,83.95 74.31,83.51 74.4,83.43 74.58,83.43 74.67,83.51 74.67,83.95 74.76,84.03 74.94,84.03 75.03,83.95 75.03,83.51 75.11,83.43 75.29,83.43 75.38,83.51 75.38,83.95 75.47,84.03 76.74,84.03 76.97,84.26 v2(76.97,84.47)
  BOTTOM w0.079: U24.A43 77.48,81.49 76.91,82.06 76.91,84.2 76.97,84.26 v2(76.97,84.47)
M_B_DQ51: length 44.2
  TOP w0.102: v1(45.04,87.76) 44.67,88.13 U2.C3
  IN3 w0.089: v1(45.04,87.76) 45.48,87.32 48.64,87.32 49.92,88.61 60.4,88.61 60.49,88.7 60.49,89.22 60.57,89.31 60.82,89.31 61,89.14 61.33,89.14 61.51,89.31 66.74,89.31 70.05,86.01 70.33,86.01 70.54,85.8 74.81,85.8 75.07,86.07 77.51,86.07 78.3,85.27 78.3,83.49 v2(78.93,82.87)
  BOTTOM w0.079: U24.C40 78.81,80.13 79.15,80.47 79.15,81.02 79.24,81.22 79.24,81.59 79.1,81.73 79.1,82.61 78.93,82.79 v2(78.93,82.87)
M_B_DQ52: length 44.3
  TOP w0.102: U2.C8 v1(45.07,85.03)
  IN3 w0.089: v1(45.07,85.03) 45.47,84.63 45.47,83.86 45.74,83.59 46.94,83.59 48.07,84.73 49.15,84.73 50.68,86.25 65.38,86.25 65.82,86.69 66.35,86.69 68.95,84.09 69.52,84.09 69.75,83.86 70.62,83.86 71.3,83.18 75.72,83.18 75.81,83.27 75.81,83.7 75.9,83.79 76.08,83.79 76.17,83.7 76.17,83.27 76.25,83.18 76.43,83.18 76.52,83.27 76.52,83.7 76.61,83.79 76.79,83.79 76.88,83.7 76.88,83.27 76.97,83.18 77.15,83.18 77.23,83.26 77.23,83.7 77.63,84.1 v2(77.63,84.16)
  BOTTOM w0.079: U24.C43 77.54,80.12 77.76,80.66 77.76,80.8 77.73,80.85 77.73,81.21 77.76,81.32 77.76,81.48 77.07,82.17 77.07,83.6 v2(77.63,84.16)
M_B_DQ53: length 45.3
  TOP w0.102: U2.D7 v1(44.27,85.83)
  IN3 w0.089: v2(77.63,82.94) 71.19,82.94 70.52,83.62 69.65,83.62 69.42,83.85 68.85,83.85 66.25,86.45 65.92,86.45 65.48,86.01 50.78,86.01 49.25,84.49 48.17,84.49 47.04,83.35 43.85,83.35 43.25,83.95 43.25,85.1 43.99,85.83 v1(44.27,85.83)
  BOTTOM w0.079: v2(77.63,82.94) 77.28,82.59 77.28,82.2 77.93,81.55 77.93,81.29 77.9,81.19 77.9,80.9 77.93,80.85 77.93,80.62 77.79,80.27 77.79,79.62 77.99,79.42 U24.D40
M_B_DQ54: length 43.9
  TOP w0.102: v1(45.75,87.72) 45.07,88.4 45.07,89.83 U2.C2
  IN3 w0.089: v1(45.75,87.72) 45.91,87.57 47.56,87.57 49.55,89.55 66.84,89.55 70.15,86.25 70.43,86.25 70.64,86.04 74.71,86.04 74.97,86.31 77.61,86.31 78.54,85.37 78.54,84.42 v2(78.93,84.03)
  BOTTOM w0.079: U24.B40 78.81,80.72 78.98,80.89 78.98,81.05 79.08,81.26 79.08,81.52 78.94,81.66 78.94,82.32 78.57,82.68 78.57,83.65 78.93,84.01 v2(78.93,84.03)
M_B_DQ55: length 43
  TOP w0.102: U2.A3 46.6,89.1 v1(46.6,87.97)
  IN3 w0.089: v2(78.93,85.2) 78.93,85.33 77.71,86.55 74.87,86.55 74.61,86.29 70.74,86.29 70.53,86.49 70.25,86.49 66.94,89.79 61.17,89.79 61.08,89.88 61.08,90.04 60.99,90.13 60.81,90.13 60.72,90.04 60.72,89.88 60.63,89.79 60.46,89.79 60.37,89.88 60.37,90.04 60.28,90.13 60.1,90.13 60.01,90.04 60.01,89.88 59.92,89.79 59.74,89.79 59.66,89.88 59.66,90.04 59.57,90.13 59.39,90.13 59.3,90.04 59.3,89.88 59.21,89.79 59.03,89.79 58.94,89.88 58.94,90.04 58.86,90.13 58.68,90.13 58.59,90.04 58.59,89.88 58.5,89.79 49.45,89.79 47.52,87.87 46.7,87.87 v1(46.6,87.97)
  BOTTOM w0.079: 78.55,84.7 78.55,83.96 78.4,83.81 78.4,82.62 78.77,82.25 78.77,81.4 U24.A40
  BOTTOM w0.102: v2(78.93,85.2) 78.55,84.82 78.55,84.7
M_B_DQ56: length 58.7
  TOP w0.102: U2.J3 40.92,88.38 v1(41.21,88.38)
  IN3 w0.089: v2(82.46,82.99) 82.56,82.99 82.87,83.3 82.87,86.17 77.91,91.13 77.91,91.5 74.22,95.19 58.59,95.19 58.24,94.84 54.28,94.84 53.69,94.25 48.2,94.25 46.56,92.61 42.6,92.61 42.15,92.16 41.69,92.16 40.64,91.11 40.64,88.82 41.08,88.38 v1(41.21,88.38)
  BOTTOM w0.076: U24.B35 81.56,81.07
  BOTTOM w0.079: 81.56,81.07 81.62,81.28 81.62,81.32 81.94,81.94 81.94,82.47 v2(82.46,82.99)
M_B_DQ57: length 60.2
  TOP w0.102: U2.H2 v1(41.07,89.83)
  IN3 w0.089: v2(82.43,85.33) 82.43,86.26 77.37,91.33 77.37,91.7 74.12,94.95 59.6,94.95 59.51,94.86 59.51,94.17 59.42,94.08 59.24,94.08 59.16,94.17 59.16,94.86 59.07,94.95 58.89,94.95 58.8,94.86 58.8,94.08 58.73,94.01 58.53,94.01 58.44,94.1 58.44,94.35 58.35,94.44 58.17,94.44 58.08,94.35 58.08,94.1 58,94.01 48.3,94.01 46.66,92.37 42.7,92.37 42.25,91.92 41.79,91.92 41.47,91.6 41.47,90.47 41.46,90.46 41.46,90.44 41.07,90.05 v1(41.07,89.83)
  BOTTOM w0.079: U24.D35 80.53,79.42 80.45,79.49 80.45,80.4 80.45,80.4 80.54,80.57 80.54,80.82 80.49,80.95 80.49,81.13 80.54,81.26 80.54,83.94 81.29,84.7
  BOTTOM w0.102: 81.29,84.7 81.93,85.33 v2(82.43,85.33)
M_B_DQ58: length 57.3
  TOP w0.102: U2.G2 v1(41.87,90.63)
  IN3 w0.089: v1(41.87,90.63) 41.87,90.74 42.28,91.15 42.28,91.61 42.8,92.13 44.96,92.13 45.04,92.04 45.04,91.67 45.13,91.59 45.31,91.59 45.4,91.68 45.4,92.04 45.49,92.13 45.67,92.13 45.76,92.04 45.76,91.39 45.84,91.3 46.02,91.3 46.11,91.39 46.11,92.04 46.2,92.13 46.76,92.13 48.4,93.77 60.33,93.77 60.42,93.86 60.42,94.62 60.51,94.71 60.68,94.71 60.77,94.62 60.77,93.86 60.86,93.77 61.04,93.77 61.13,93.86 61.13,94.62 61.22,94.71 61.39,94.71 61.48,94.62 61.48,94.08 61.58,93.98 61.94,93.98 62.66,94.71 74.02,94.71 77.13,91.6 77.13,91.23 81.85,86.5 81.85,84.77 v2(82.46,84.16)
  BOTTOM w0.079: U24.A35 81.77,82.11 81.77,82.54 82.08,82.85 82.08,83.78 v2(82.46,84.16)
M_B_DQ59: length 59.2
  TOP w0.102: v1(39.99,86.9) 39.87,86.78 U2.J7
  IN3 w0.089: v1(39.99,86.9) 39.99,86.27 40.17,86.09 40.58,86.09 40.67,86.18 40.67,87.14 41.14,87.62 42.35,87.62 44.18,89.44 47.52,89.44 49.69,91.62 66.26,91.62 66.97,92.33 68.47,92.33 68.54,92.27 68.54,91.75 68.63,91.66 68.81,91.66 68.89,91.75 68.89,92.83 68.98,92.91 69.16,92.91 69.25,92.83 69.25,92.64 69.34,92.55 69.69,92.55 70.42,93.27 73.41,93.27 75.59,91.09 75.59,88.3 76.18,87.7 78.13,87.7 78.47,87.37 78.95,87.37 80.36,85.96 80.36,83.43 v2(79.49,82.56)
  BOTTOM w0.079: U24.D38 80.11,79.57 79.82,79.87 79.82,80.82 79.68,81.23 79.68,81.66 79.84,81.82 79.84,82.23 79.51,82.56 v2(79.49,82.56)
M_B_DQ60: length 59
  TOP w0.102: U2.H3 v1(41.07,89.03)
  IN3 w0.089: v1(41.07,89.03) 41.07,89.05 41.47,89.45 41.47,90.03 41.67,90.23 42.01,90.23 42.01,90.23 42.04,90.23 42.27,90.47 42.27,90.8 42.5,91.03 43.16,91.03 43.25,91.12 43.25,91.22 43.34,91.31 43.52,91.31 43.6,91.22 43.6,91.12 43.69,91.03 43.87,91.03 43.96,91.12 43.96,91.22 44.05,91.31 44.23,91.31 44.32,91.22 44.32,91.12 44.4,91.03 44.58,91.03 44.67,91.12 44.67,91.22 44.76,91.31 44.94,91.31 45.03,91.22 45.03,91.15 45.12,91.06 46.28,91.06 46.39,91.17 46.39,91.55 46.49,91.65 46.89,91.65 48.17,92.92 53.95,92.92 54.19,93.17 54.19,93.46 54.26,93.53 54.61,93.53 54.7,93.44 54.7,93.36 54.79,93.27 54.96,93.27 55.05,93.36 55.05,93.44 55.14,93.53 55.32,93.53 55.41,93.44 55.41,93.36 55.5,93.27 55.67,93.27 55.76,93.36 55.76,93.44 55.85,93.53 56.03,93.53 56.12,93.44 56.12,93.36 56.21,93.27 56.39,93.27 56.47,93.36 56.47,93.44 56.56,93.53 56.74,93.53 56.83,93.44 56.83,93.36 56.92,93.27 57.1,93.27 57.19,93.36 57.19,93.44 57.27,93.53 57.45,93.53 57.54,93.44 57.54,93.36 57.63,93.27 57.81,93.27 57.9,93.36 57.9,93.44 57.99,93.53 58.16,93.53 58.25,93.44 58.25,93.36 58.34,93.27 58.52,93.27 58.61,93.36 58.61,93.44 58.7,93.53 58.87,93.53 58.96,93.44 58.96,93.36 59.05,93.27 59.23,93.27 59.32,93.36 59.32,93.44 59.41,93.53 59.59,93.53 59.68,93.44 59.68,93.36 59.76,93.27 59.94,93.27 60.03,93.36 60.03,93.44 60.12,93.53 60.3,93.53 60.39,93.44 60.39,93.36 60.48,93.27 60.65,93.27 60.74,93.36 60.74,93.44 60.83,93.53 61.01,93.53 61.1,93.44 61.1,93.36 61.19,93.27 61.36,93.27 61.45,93.36 61.45,93.44 61.54,93.53 61.83,93.53 62.76,94.46 73.92,94.46 76.88,91.5 76.88,91.13 81.59,86.42 81.59,84.62 82.05,84.16 82.05,82.82 v2(82.46,82.41)
  BOTTOM w0.076: U24.C35 81.72,80.63
  BOTTOM w0.079: v2(82.46,82.41) 82.1,82.05 82.1,81.9 81.79,81.28 81.79,81.14 81.72,80.89 81.72,80.63
M_B_DQ61: length 58.7
  TOP w0.102: U2.H8 v1(41.07,85.83)
  IN3 w0.089: v1(41.07,85.83) 41.47,86.23 42.91,86.23 43.24,86.56 43.24,87.48 44.48,88.72 46.84,88.72 46.93,88.63 46.93,88.57 47.01,88.48 47.19,88.48 47.28,88.57 47.28,88.63 47.37,88.72 47.82,88.72 49.28,90.19 57.92,90.19 58.26,90.52 61.63,90.52 61.72,90.44 61.72,90.28 61.8,90.19 61.98,90.19 62.07,90.28 62.07,90.44 62.16,90.52 62.34,90.52 62.43,90.44 62.43,90.28 62.52,90.19 62.69,90.19 62.78,90.28 62.78,90.44 62.87,90.52 63.05,90.52 63.14,90.44 63.14,90.28 63.23,90.19 63.4,90.19 63.49,90.28 63.49,90.44 63.58,90.52 63.76,90.52 63.85,90.44 63.85,90.28 63.94,90.19 64.12,90.19 64.2,90.28 64.2,90.44 64.29,90.52 64.47,90.52 64.56,90.44 64.56,90.28 64.65,90.19 64.83,90.19 64.92,90.28 64.92,90.44 65,90.52 65.18,90.52 65.27,90.44 65.27,90.28 65.36,90.19 65.54,90.19 65.63,90.28 65.63,90.44 65.72,90.52 65.89,90.52 65.98,90.44 65.98,90.28 66.07,90.19 66.25,90.19 66.34,90.28 66.34,90.44 66.43,90.52 66.61,90.52 66.69,90.44 66.69,90.28 66.78,90.19 66.96,90.19 67.05,90.28 67.05,90.44 67.14,90.52 67.32,90.52 67.41,90.44 67.41,89.89 67.49,89.8 67.67,89.8 67.76,89.89 67.76,90.44 67.85,90.52 68.03,90.52 68.12,90.44 68.12,89.18 68.21,89.09 68.38,89.09 68.47,89.18 68.47,90.44 68.56,90.52 68.74,90.52 68.83,90.44 68.83,88.47 70.41,86.89 70.7,86.89 70.9,86.68 74.13,86.68 74.41,86.96 77.86,86.96 78.21,86.6 78.37,86.6 v2(79.49,85.48)
  BOTTOM w0.079: 80.37,84.6 80.37,81.28 80.33,81.16 80.33,80.93 80.37,80.79 80.37,80.61 80.28,80.45 80.28,80.23 U24.C38
  BOTTOM w0.102: 80.37,84.6 v2(79.49,85.48)
M_B_DQ62: length 57.3
  TOP w0.102: U2.H7 v1(41.07,86.63)
  IN3 w0.089: v1(41.07,86.63) 41.07,86.97 41.45,87.35 42.43,87.35 44.28,89.2 47.62,89.2 49.79,91.38 66.53,91.38 66.62,91.29 66.62,91.1 66.71,91.01 66.89,91.01 66.98,91.1 66.98,92 67.07,92.09 67.25,92.09 67.33,92 67.33,91.1 67.42,91.01 67.6,91.01 67.69,91.1 67.69,92 67.78,92.09 67.96,92.09 68.05,92 68.05,91.1 68.13,91.01 68.31,91.01 68.4,91.1 68.4,91.29 68.49,91.38 68.87,91.38 70.52,93.03 73.31,93.03 75.35,90.99 75.35,88.2 76.08,87.46 78.03,87.46 78.37,87.13 78.85,87.13 80.12,85.86 80.12,83.77 v2(79.49,83.15)
  BOTTOM w0.079: U24.B38 80.11,80.73 79.98,80.87 79.84,81.26 79.84,81.59 80.01,81.75 80.01,82.62 v2(79.49,83.15)
M_B_DQ63: length 57
  TOP w0.102: U2.F7 v1(41.87,86.63)
  IN3 w0.089: v1(41.87,86.63) 42.35,87.11 42.53,87.11 44.38,88.96 47.72,88.96 49.18,90.43 57.39,90.43 57.73,90.77 57.97,90.77 58.06,90.85 58.06,91.05 58.15,91.14 58.32,91.14 58.41,91.05 58.41,90.85 58.5,90.77 58.68,90.77 58.77,90.85 58.77,91.05 58.86,91.14 59.03,91.14 59.12,91.05 59.12,90.85 59.21,90.77 59.39,90.77 59.48,90.85 59.48,91.05 59.57,91.14 59.75,91.14 59.83,91.05 59.83,90.85 59.92,90.77 60.1,90.77 60.19,90.85 60.19,91.05 60.28,91.14 60.46,91.14 60.55,91.05 60.55,90.85 60.63,90.77 60.81,90.77 60.9,90.85 60.9,91.05 60.99,91.14 61.17,91.14 61.26,91.05 61.26,90.85 61.35,90.77 61.52,90.77 61.61,90.85 61.61,91.05 61.7,91.14 61.88,91.14 61.97,91.05 61.97,90.85 62.06,90.77 62.23,90.77 62.32,90.85 62.32,91.05 62.41,91.14 62.59,91.14 62.68,91.05 62.68,90.85 62.77,90.77 62.95,90.77 63.03,90.85 63.03,91.05 63.12,91.14 63.3,91.14 63.39,91.05 63.39,90.85 63.48,90.77 63.66,90.77 63.75,90.85 63.75,91.05 63.84,91.14 64.01,91.14 64.1,91.05 64.1,90.85 64.19,90.77 64.37,90.77 64.46,90.85 64.46,91.05 64.55,91.14 64.72,91.14 64.81,91.05 64.81,90.85 64.9,90.77 65.08,90.77 65.17,90.85 65.17,91.05 65.26,91.14 65.44,91.14 65.52,91.05 65.52,90.85 65.61,90.77 65.79,90.77 65.88,90.85 65.88,91.05 65.97,91.14 66.15,91.14 66.24,91.05 66.24,90.85 66.32,90.77 68.59,90.77 70.62,92.79 73.15,92.79 75.11,90.83 75.11,88.1 75.98,87.22 77.93,87.22 78.27,86.89 78.75,86.89 79.88,85.76 79.88,84.7 v2(79.49,84.31)
  BOTTOM w0.079: v2(79.49,84.31) 80.18,83.62 80.18,81.43 U24.A38
M_B_DQSN0: length 53.4
  TOP w0.102: U8.F3 v1(42.67,42.68)
  IN3 w0.089: v2(72.14,67.57) 71.96,67.75 71.83,67.75 69.15,65.08 69.15,64.88 68.4,64.13 68.4,63.12 68.85,62.67 68.85,62.13 68.42,61.71 68.19,61.71 68.01,61.52 68.01,60.67 68.69,59.98 68.69,59.27 66.56,57.14 65.22,57.14 63.23,55.15 63.23,53.76 60.07,50.59 59.82,50.59 59.37,50.14 59.37,49.45 58.54,48.63 57.86,48.63 57.67,48.44 57.67,47.21 56.87,46.41 50.69,46.41 49.02,44.74 48.3,44.74 48.12,44.55 48.12,43.72 47.82,43.42 46.17,43.42 45.76,43.01 45.22,43.01 45.05,43.19 45.05,43.54 44.96,43.63 44.64,43.63 44.55,43.54 44.55,43.32 44.35,43.12 43.87,43.12 43.38,43.61 42.88,43.61 42.38,43.12 42.38,42.88 42.58,42.68 v1(42.67,42.68)
  BOTTOM w0.079: v2(72.14,67.57) 72.22,67.57 72.22,67.57 72.25,67.57 72.6,67.22 72.87,67.22 73.04,67.05 74.11,67.05 74.19,67.12 74.42,67.12 74.45,67.1 75.42,67.1 75.55,67.14 75.68,67.25 75.68,67.44 75.74,67.49 U24.AH46
M_B_DQSN1: length 57.1
  TOP w0.102: U8.A7 v1(46.67,39.48)
  IN3 w0.089: v2(78.4,67.6) 78.4,67.34 78.31,67.25 77.45,67.25 77.13,66.93 77.13,66.85 75.34,65.06 75.14,65.06 74.59,64.51 74.59,60.38 74.11,59.9 74.11,57.57 74.24,57.44 74.24,57.12 74.1,56.99 74.1,54.5 73.94,54.34 73.21,54.34 72.96,54.09 72.96,53.65 73.17,53.44 73.68,53.44 73.77,53.35 73.77,53.03 73.68,52.95 72.91,52.95 68.64,48.68 68.64,48.11 68.39,47.87 62.99,47.87 62.43,47.31 62.08,47.31 57.77,43 57.77,40.74 57.45,40.42 55.64,40.42 55.18,40.88 54.55,40.88 54.34,40.67 54.34,40.18 54.25,40.09 53.94,40.09 53.85,40.18 53.85,40.67 53.64,40.88 49.69,40.88 48.93,40.11 48.16,40.11 46.89,38.85 46.67,38.85 46.28,39.24 46.28,39.41 46.37,39.5 46.66,39.5 v1(46.67,39.48)
  BOTTOM w0.076: 78.65,67.45 78.5,67.6 v2(78.4,67.6)
  BOTTOM w0.079: 78.65,67.45 U24.AJ41
M_B_DQSN2: length 43.7
  TOP w0.102: U6.A7 46.01,53.03 45.91,53.13 45.91,53.66 46.1,53.85 46.1,54.19 46.27,54.36 v1(46.48,54.36)
  IN3 w0.089: v1(46.48,54.36) 46.21,54.36 46.05,54.21 46.05,53.98 46.17,53.86 46.69,53.86 47.31,54.47 47.81,54.47 48.43,53.86 48.69,53.86 49.13,54.3 49.13,54.6 51.67,57.14 53.32,57.14 53.81,57.62 53.81,58.24 54.44,58.86 57.46,58.86 59.85,61.25 59.85,62.2 61.07,63.42 61.07,65.01 64.07,68 64.75,68 65.04,68.29 65.79,68.29 66.86,69.36 66.86,69.57 v2(66.7,69.74)
  BOTTOM w0.079: U24.AC47 75.46,70 75.51,69.94 75.51,69.88 75.45,69.79 75.39,69.77 72.52,69.77 70.89,71.4 68.88,71.4 68.12,70.65 67.32,70.65 66.97,70.29 66.97,70 v2(66.7,69.74)
M_B_DQSN3: length 54.6
  TOP w0.102: v1(42.27,54.86) 42.04,55.1 42.04,55.6 41.97,55.66 41.97,55.93 U6.F3
  IN3 w0.089: v2(78.93,69.48) 78.38,70.03 76.82,70.03 76.59,70.26 74.89,70.26 74.7,70.06 71.25,70.06 66.78,65.59 66.65,65.59 64.4,63.34 64.4,62.44 62.9,60.95 62.9,60.01 58.08,55.19 58.08,54.05 57.23,53.2 57.23,52.62 55.73,51.12 51.24,51.12 50.91,51.45 50.6,51.45 48.67,49.52 43.95,49.52 42.52,50.95 42.52,53.66 42.1,54.09 42.1,54.69 v1(42.27,54.86)
  BOTTOM w0.076: v2(78.93,69.48) 78.65,69.2 U24.AE41
M_B_DQSN4: length 49.7
  TOP w0.102: v1(42.67,75.73) 42.73,75.8 42.73,76 42.6,76.13 U4.F3
  IN3 w0.089: v2(66.74,83.46) 66.56,83.63 66.56,83.81 66.18,84.19 58,84.19 57.49,83.68 54.84,83.68 54.44,83.27 53.64,83.27 53.23,83.68 51.03,83.68 49.09,81.74 47.22,81.74 46.99,81.5 46.99,81.15 46.88,81.04 46.73,81.04 46.33,81.43 46,81.43 45.71,81.14 45.71,80.78 46.1,80.39 46.1,80.26 45.33,79.49 45.2,79.49 44.78,79.91 44.48,79.91 44.14,79.57 44.14,79.27 44.57,78.85 44.57,78.72 44.27,78.43 43.56,78.43 42.77,77.65 42.77,76.97 42.61,76.8 42.61,76.5 43.23,75.89 43.34,75.89 43.58,75.64 43.58,75.46 42.82,74.69 42.04,74.69 41.96,74.77 41.96,74.89 42.33,75.27 42.33,75.63 42.43,75.73 v1(42.67,75.73)
  BOTTOM w0.076: v2(66.74,83.46) 66.53,83.25 66.53,83.14 67.32,82.35 67.82,82.35 69.47,80.7 69.47,80.67 69.59,80.54 69.6,80.54 69.63,80.5 69.63,80.5 69.65,80.49
  BOTTOM w0.079: 69.65,80.49 71.72,78.42 71.94,78.42 72.94,77.41 74.45,77.41 74.58,77.36 74.72,77.36 74.86,77.43 75.09,77.43 75.23,77.36 75.35,77.36 75.47,77.42 75.54,77.48 75.54,77.59 75.49,77.64 U24.H47
M_B_DQSN5: length 42.9
  TOP w0.102: U4.A7 45.85,73.36 v1(45.85,73.54)
  IN3 w0.089: v1(45.85,73.54) 45.67,73.36 45.67,73.26 45.84,73.09 46.65,73.09 46.93,73.37 46.93,73.78 48.83,75.68 48.83,76.98 50.7,78.85 53.53,78.85 54.16,79.49 57.86,79.49 59.15,80.78 66.74,80.78 67.18,81.22 67.76,81.22 67.97,81.01 67.97,80.87 68.06,80.78 68.38,80.78 68.46,80.87 68.46,81.01 68.67,81.22 69.16,81.22 69.37,81.01 69.37,80.87 69.45,80.78 69.77,80.78 69.86,80.87 69.86,81.01 70.07,81.22 70.55,81.22 70.76,81.01 70.76,80.87 70.85,80.78 71.17,80.78 71.26,80.87 71.26,81.01 71.47,81.22 74.09,81.22 74.96,80.34 74.96,79.78 75.25,79.49 76.27,79.49 76.67,79.09 76.67,78.89 77.02,78.54 77.16,78.54 77.41,78.29 78.09,78.29 78.14,78.24 78.3,78.24 78.82,77.71 v2(78.93,77.71)
  BOTTOM w0.076: U24.G41 78.65,77.99 v2(78.93,77.71)
M_B_DQSN6: length 43.8
  TOP w0.102: U2.A7 46.3,86.26 46.3,86.52 46.41,86.63 v1(46.67,86.63)
  IN3 w0.089: v1(46.67,86.63) 46.37,86.33 46.37,86.25 46.46,86.16 47.84,86.16 48.26,86.57 49.11,86.57 50.4,87.87 62.86,87.87 62.95,87.96 62.95,88.37 63.15,88.57 63.64,88.57 63.85,88.37 63.85,87.84 63.94,87.75 64.25,87.75 64.34,87.84 64.34,88.37 64.55,88.57 65.04,88.57 65.24,88.37 65.24,87.96 65.33,87.87 66.84,87.87 69.44,85.27 70.03,85.27 70.24,85.06 76.7,85.06 76.83,85.19 76.83,85.48 76.76,85.56 v2(76.59,85.56)
  BOTTOM w0.079: U24.C42 77.99,80.23 77.99,80.14 78.07,80.06 78.27,80.06 78.33,80.13 78.42,80.3 78.42,80.48 78.38,80.56 78.38,80.85 78.43,80.95 78.43,81.08 78.38,81.22 78.38,82.16 78.05,82.49 78.05,84.3 77.85,84.5 77.85,84.57 77.84,84.58
  BOTTOM w0.102: 77.84,84.58 77.73,84.68 77.33,84.68 76.98,85.03 76.98,85.16 v2(76.59,85.56)
M_B_DQSN7: length 58.8
  TOP w0.102: v1(42.61,88.63) 42.61,89.09 U2.F3
  IN3 w0.089: v2(80.91,83.17) 80.91,83.12 81.13,82.9 81.28,82.9 81.34,82.96 81.34,83.87 80.87,84.34 80.87,86.15 79.16,87.86 78.67,87.86 78.31,88.23 76.76,88.23 76.19,88.8 76.19,91.21 73.64,93.77 68.46,93.77 68.38,93.68 68.38,93.04 68.17,92.84 67.68,92.84 67.47,93.04 67.47,93.68 67.38,93.77 67.07,93.77 66.98,93.68 66.98,93.04 66.77,92.84 66.28,92.84 66.08,93.04 66.08,93.68 65.99,93.77 63.05,93.77 61.86,92.57 61.5,92.57 61.41,92.48 61.41,92.33 61.2,92.12 60.71,92.12 60.51,92.33 60.51,92.48 60.42,92.57 60.1,92.57 60.01,92.48 60.01,92.33 59.8,92.12 59.32,92.12 59.11,92.33 59.11,92.48 59.02,92.57 54.58,92.57 54.22,92.21 48.47,92.21 47.94,91.68 47.94,91.42 46.88,90.36 45.13,90.36 44.77,90 43.81,90 42.95,89.14 42.48,89.14 42.35,89.01 42.35,88.89 v1(42.61,88.63)
  BOTTOM w0.079: v2(80.91,83.17) 81.12,82.96 81.3,82.96 81.51,82.75 81.51,81.98 81.37,81.71 81.2,81.55 81.16,81.47 81.16,81.26 81.2,81.18 81.2,80.93 81.11,80.73 81.04,80.58 81.04,80.25 80.77,79.98 U24.D36
M_B_DQSP0: length 53.4
  TOP w0.102: U8.G3 v1(41.87,42.68)
  IN3 w0.089: v1(41.87,42.68) 42.18,42.99 42.18,43.2 42.79,43.81 43.46,43.81 43.95,43.32 44.27,43.32 44.35,43.41 44.35,43.62 44.56,43.83 45.04,43.83 45.25,43.62 45.25,43.27 45.31,43.22 45.68,43.22 46.09,43.63 47.73,43.63 47.92,43.81 47.92,44.64 48.22,44.94 48.94,44.94 50.61,46.61 56.78,46.61 57.47,47.3 57.47,48.53 57.77,48.83 58.46,48.83 59.17,49.54 59.17,50.23 59.74,50.79 59.98,50.79 63.03,53.84 63.03,55.23 65.14,57.34 66.47,57.34 68.49,59.35 68.49,59.9 67.8,60.58 67.8,61.61 68.11,61.91 68.34,61.91 68.64,62.22 68.64,62.59 68.2,63.03 68.2,64.22 68.95,64.97 68.95,65.16 71.74,67.96 72.3,67.96 72.67,67.59 v2(72.74,67.59)
  BOTTOM w0.079: v2(72.74,67.59) 73.11,67.22 74.04,67.22 74.12,67.29 74.49,67.29 74.51,67.26 75.39,67.26 75.47,67.29 75.51,67.33 75.51,67.44 75.46,67.49 U24.AH47
M_B_DQSP1: length 57.2
  TOP w0.102: U8.B7 v1(45.87,39.48)
  IN3 w0.089: v2(78.44,66.74) 78.44,66.93 78.3,67.07 77.53,67.07 77.3,66.85 77.3,66.74 75.41,64.85 75.21,64.85 74.79,64.43 74.79,60.3 74.31,59.82 74.31,57.65 74.44,57.53 74.44,57.04 74.31,56.9 74.31,54.42 74.03,54.14 73.3,54.14 73.16,54.01 73.16,53.73 73.25,53.64 73.77,53.64 73.98,53.44 73.98,52.95 73.77,52.74 73,52.74 68.85,48.59 68.85,48.03 68.48,47.66 63.08,47.66 62.52,47.1 62.16,47.1 57.97,42.91 57.97,40.66 57.53,40.22 55.55,40.22 55.1,40.68 54.64,40.68 54.55,40.59 54.55,40.1 54.34,39.89 53.85,39.89 53.65,40.1 53.65,40.59 53.56,40.68 49.78,40.68 49.01,39.91 48.24,39.91 46.98,38.64 46.59,38.64 46.07,39.16 46.07,39.28 v1(45.87,39.48)
  BOTTOM w0.076: v2(78.44,66.74) 78.44,66.64 78.65,66.43
  BOTTOM w0.079: U24.AL41 78.65,66.43
M_B_DQSP2: length 43.7
  TOP w0.102: v1(45.68,54.36) 45.88,54.16 45.88,53.94 45.69,53.75 45.69,53.25 U6.B7
  IN3 w0.089: v1(45.68,54.36) 45.85,54.19 45.85,53.89 46.09,53.65 46.78,53.65 47.39,54.27 47.73,54.27 48.34,53.65 48.78,53.65 49.34,54.22 49.34,54.51 51.76,56.93 53.4,56.93 54.01,57.54 54.01,58.15 54.52,58.66 57.55,58.66 60.06,61.17 60.06,62.12 61.28,63.34 61.28,64.92 64.15,67.8 64.83,67.8 65.12,68.08 65.87,68.08 67.07,69.28 67.07,69.52 v2(67.28,69.74)
  BOTTOM w0.079: U24.AC46 75.79,70 75.68,69.89 75.68,69.83 75.56,69.65 75.42,69.6 72.45,69.6 70.82,71.23 68.95,71.23 68.19,70.48 67.39,70.48 67.13,70.22 67.13,69.89 v2(67.28,69.74)
M_B_DQSP3: length 54.6
  TOP w0.102: v1(41.59,54.85) 41.82,55.08 41.82,55.51 41.76,55.57 41.76,55.94 U6.G3
  IN3 w0.089: v2(78.37,69.48) 78.37,69.79 78.31,69.85 76.74,69.85 76.51,70.08 74.97,70.08 74.77,69.89 71.36,69.89 66.86,65.39 66.74,65.39 64.6,63.26 64.6,62.36 63.1,60.86 63.1,59.92 58.29,55.1 58.29,53.97 57.43,53.12 57.43,52.53 55.81,50.91 51.16,50.91 50.83,51.24 50.68,51.24 48.75,49.31 43.87,49.31 42.32,50.86 42.32,53.58 41.9,54 41.9,54.55 v1(41.59,54.85)
  BOTTOM w0.076: U24.AD41 78.65,69.76 v2(78.37,69.48)
M_B_DQSP4: length 49.7
  TOP w0.102: U4.G3 v1(41.87,75.73)
  IN3 w0.089: v2(66.15,83.46) 66.35,83.66 66.35,83.72 66.09,83.98 58.08,83.98 57.58,83.48 54.93,83.48 54.52,83.07 53.55,83.07 53.15,83.48 51.12,83.48 49.17,81.53 47.31,81.53 47.19,81.42 47.19,81.06 46.96,80.83 46.64,80.83 46.25,81.23 46.08,81.23 45.91,81.05 45.91,80.87 46.31,80.47 46.31,80.18 45.41,79.28 45.12,79.28 44.69,79.71 44.57,79.71 44.34,79.48 44.34,79.36 44.77,78.93 44.77,78.64 44.36,78.23 43.64,78.23 42.98,77.56 42.98,76.88 42.81,76.72 42.81,76.58 43.31,76.09 43.43,76.09 43.79,75.73 43.79,75.37 42.9,74.48 41.95,74.48 41.76,74.68 41.76,74.98 42.13,75.35 42.13,75.48 v1(41.87,75.73)
  BOTTOM w0.076: 69.53,80.37 69.3,80.6 69.3,80.63 67.76,82.18 67.25,82.18 66.36,83.07 66.36,83.25 v2(66.15,83.46)
  BOTTOM w0.079: 69.53,80.37 71.65,78.25 71.87,78.25 72.87,77.25 74.42,77.25 74.55,77.19 74.76,77.19 74.9,77.26 75.05,77.26 75.19,77.19 75.39,77.19 75.57,77.28 75.95,77.63 U24.H46
M_B_DQSP5: length 42.9
  TOP w0.102: v1(45.05,73.54) 45.05,73.44 45.47,73.02 U4.B7
  IN3 w0.089: v2(78.29,77.71) 78.29,77.95 78.21,78.03 78.05,78.03 78,78.08 77.33,78.08 77.08,78.34 76.93,78.34 76.47,78.8 76.47,79.01 76.19,79.28 75.17,79.28 74.76,79.7 74.76,80.26 74,81.01 71.55,81.01 71.46,80.92 71.46,80.78 71.25,80.57 70.77,80.57 70.56,80.78 70.56,80.92 70.47,81.01 70.15,81.01 70.06,80.92 70.06,80.78 69.86,80.57 69.37,80.57 69.16,80.78 69.16,80.92 69.07,81.01 68.76,81.01 68.67,80.92 68.67,80.78 68.46,80.57 67.97,80.57 67.77,80.78 67.77,80.92 67.68,81.01 67.27,81.01 66.83,80.57 59.24,80.57 57.95,79.28 54.25,79.28 53.61,78.65 50.79,78.65 49.03,76.9 49.03,75.59 47.13,73.69 47.13,73.29 46.73,72.88 45.76,72.88 45.46,73.18 45.46,73.36 45.29,73.54 v1(45.05,73.54)
  BOTTOM w0.076: v2(78.29,77.71) 78.65,77.35 U24.J41
M_B_DQSP6: length 43.8
  TOP w0.102: U2.B7 v1(45.87,86.63)
  IN3 w0.089: v1(45.87,86.63) 46.16,86.34 46.16,86.17 46.38,85.95 47.93,85.95 48.35,86.37 49.19,86.37 50.49,87.67 62.94,87.67 63.15,87.87 63.15,88.28 63.24,88.37 63.56,88.37 63.64,88.28 63.64,87.75 63.85,87.55 64.34,87.55 64.55,87.75 64.55,88.28 64.64,88.37 64.95,88.37 65.04,88.28 65.04,87.87 65.25,87.67 66.76,87.67 69.35,85.07 69.94,85.07 70.16,84.85 76.79,84.85 77.04,85.1 77.04,85.39 v2(77.2,85.56)
  BOTTOM w0.079: 78.01,84.7 78.01,84.57 78.22,84.36 78.22,82.56 78.55,82.23 78.55,81.25 78.6,81.11 78.6,80.91 78.55,80.81 78.55,80.59 78.59,80.51 78.59,80.26 78.47,80.03 78.34,79.89 78.33,79.88 78.29,79.88 U24.D42
  BOTTOM w0.102: 78.01,84.7 78.01,84.7 77.82,84.9 77.42,84.9 77.2,85.12 v2(77.2,85.56)
M_B_DQSP7: length 58.8
  TOP w0.102: v1(41.84,88.63) 41.84,89.06 U2.G3
  IN3 w0.089: v2(80.91,82.59) 81.02,82.7 81.37,82.7 81.55,82.88 81.55,83.96 81.08,84.43 81.08,86.24 79.24,88.07 78.76,88.07 78.4,88.43 76.85,88.43 76.39,88.89 76.39,91.3 73.72,93.97 68.38,93.97 68.17,93.76 68.17,93.13 68.08,93.04 67.77,93.04 67.68,93.13 67.68,93.76 67.47,93.97 66.98,93.97 66.77,93.76 66.77,93.13 66.69,93.04 66.37,93.04 66.28,93.13 66.28,93.76 66.07,93.97 62.97,93.97 61.77,92.77 61.41,92.77 61.21,92.56 61.21,92.41 61.12,92.32 60.8,92.32 60.71,92.41 60.71,92.56 60.5,92.77 60.02,92.77 59.81,92.56 59.81,92.41 59.72,92.32 59.4,92.32 59.31,92.41 59.31,92.56 59.11,92.77 54.49,92.77 54.14,92.42 48.39,92.42 47.74,91.76 47.74,91.5 46.8,90.56 45.05,90.56 44.69,90.21 43.72,90.21 42.86,89.34 42.4,89.34 42.15,89.09 42.15,88.94 v1(41.84,88.63)
  BOTTOM w0.079: v2(80.91,82.59) 81.11,82.79 81.23,82.79 81.34,82.68 81.34,82.02 81.24,81.81 81.06,81.65 81,81.5 81,81.21 81.04,81.14 81.04,80.97 80.96,80.8 80.87,80.61 80.87,80.49 U24.C36
M_B_PARITY: length 152.6
  TOP w0.076: v1(30.95,56.5) 34,56.5 U6.T3 ; U2.T3 v1(33.44,90.26) 32.76,90.94 32.76,92.81 30.86,94.72 R67.2 ; v1(31.43,43.04) 31.51,43.12 32.76,43.12 32.83,43.19 32.83,43.32 32.91,43.39 33.03,43.39 33.11,43.32 33.11,43.19 33.19,43.12 33.31,43.12 33.39,43.19 33.39,43.32 33.47,43.39 33.59,43.39 33.67,43.32 33.67,43.19 33.75,43.12 34.23,43.12 U8.T3 ; U4.T3 33.46,76.13 33.38,76.21 33.38,76.33 33.3,76.4 33.18,76.4 33.1,76.33 33.1,76.21 33.02,76.13 32.54,76.13 32.27,76.4 v1(30.95,76.4)
  IN1 w0.089: v1(33.44,90.26) 33.44,89.99 32.56,89.1 32.56,88.84 32.43,88.71 32.24,88.71 31.89,89.06 31.18,89.06 30.98,88.86 30.98,81.15 31.82,80.31 31.82,78.76 31.37,78.32 31.37,76.83 v1(30.95,76.4) 30.78,76.23 30.78,70.89 30.86,70.8 31.02,70.8 31.1,70.72 31.1,70.6 31.02,70.51 30.86,70.51 30.78,70.43 30.78,69.61 31.25,69.14 31.25,61.43 31.51,61.17 31.51,59.97 31.37,59.84 31.37,56.93 v1(30.95,56.5) 30.57,56.12 30.57,55.8 30.65,55.71 30.69,55.71 30.78,55.62 30.78,55.5 30.69,55.42 30.65,55.42 30.57,55.33 30.57,55.21 30.65,55.13 30.69,55.13 30.78,55.04 30.78,54.92 30.69,54.83 30.65,54.83 30.57,54.75 30.57,54.63 30.65,54.54 30.69,54.54 30.78,54.46 30.78,54.34 30.69,54.25 30.65,54.25 30.57,54.16 30.57,54.04 30.65,53.96 30.69,53.96 30.78,53.87 30.78,53.75 30.69,53.67 30.65,53.67 30.57,53.58 30.57,53.46 30.65,53.37 30.69,53.37 30.78,53.29 30.78,53.17 30.69,53.08 30.65,53.08 30.57,53 30.57,52.87 30.65,52.79 31.1,52.79 31.18,52.7 31.18,52.58 31.1,52.5 30.65,52.5 30.57,52.41 30.57,52.29 30.65,52.21 31.1,52.21 31.18,52.12 31.18,52 31.1,51.91 30.65,51.91 30.57,51.83 30.57,51.57 30.69,51.45 31.1,51.45 31.18,51.36 31.18,49.54 31.51,49.21 31.51,47.63 31.56,47.58 31.56,43.17 v1(31.43,43.04)
  IN3 w0.102: v2(79.69,74.92) 79.23,75.37 78.83,75.37 78.47,75.73 77.33,75.73 76.95,76.11 75.7,76.11 74.86,76.95 70.8,76.95 70.66,76.8 67.72,76.8 66.78,75.87 61,75.87 57.54,72.41 55.15,72.41 53.39,70.65 51.64,70.65 50.73,69.75 50.73,68.57 47.81,65.65 47.81,65.24 47.26,64.68 40.07,64.68 39.98,64.77 39.98,65.53 39.89,65.62 39.76,65.62 39.68,65.53 39.68,64.77 39.59,64.68 39.46,64.68 39.37,64.77 39.37,65.53 39.28,65.62 39.15,65.62 39.07,65.53 39.07,64.77 38.98,64.68 37.51,64.68 32.82,59.98 32.35,59.98 32.09,59.72 32.09,57.32 31.71,56.93 30.81,56.93 30.06,56.19 30.06,46.65 29.78,46.37 29.78,45.07 30.45,44.4 30.93,44.4 31.1,44.23 31.1,43.37 v1(31.43,43.04)
  BOTTOM w0.079: v2(79.69,74.92) 79.95,74.66 U24.P38
M_B_RAS#: length 160.1
  TOP w0.076: v1(33.59,92.95) v1(32.5,94.04) R69.2 ; U4.L8 38.27,72.48 37.91,72.84 37.91,73.46 36.66,74.7 v1(36.13,74.7) ; U8.L8 38.27,39.12 37.83,39.56 37.83,40 36.82,41.01 36.54,41.01 v1(36.54,41.01) ; U2.L8 38.27,85.47 37.91,85.83 37.91,86.53 37.23,87.2 v1(37.23,87.36) ; v1(36.13,54.8) 37.04,53.88 37.43,53.88 37.91,53.4 37.91,52.63 38.27,52.27 U6.L8
  IN1 w0.089: v1(36.54,41.01) 36.38,41.16 36.38,45.08 37.78,46.47 37.78,46.77 37.7,46.86 37.21,46.86 37.12,46.95 37.12,47.07 37.21,47.15 37.7,47.15 37.78,47.24 37.78,47.36 37.7,47.44 37.21,47.44 37.12,47.53 37.12,47.65 37.21,47.74 37.7,47.74 37.78,47.82 37.78,49.07 37.16,49.69 36.74,49.69 36.13,50.3 36.13,52.32 36.25,52.44 36.25,54.68 v1(36.13,54.8) 36.56,55.22 36.56,55.49 36.65,55.58 36.65,56.97 36.73,57.05 37.06,57.05 37.17,57.15 37.17,57.27 37.09,57.34 36.84,57.34 36.75,57.43 36.75,57.54 36.84,57.63 37.08,57.63 37.17,57.71 37.17,65.6 36.91,65.85 36.91,68.38 36.16,69.13 36.16,72.26 36.25,72.35 36.25,74.58 v1(36.13,74.7) 36.56,75.13 36.56,75.42 36.65,75.51 36.65,76.73 37.26,77.34 37.26,80.41 36.34,81.33 36.34,85.35 36.7,85.71 37.1,85.71 37.23,85.85 v1(37.23,87.36)
  IN3 w0.089: v1(33.59,92.95) 33.88,92.66 33.88,89.86 34.61,89.14 36.05,89.14 36.51,88.68 36.51,87.87 37.02,87.36 v1(37.23,87.36)
  IN3 w0.102: v2(69.28,75.74) 68.79,75.26 67.97,75.26 67.31,74.6 62.42,74.6 58.96,71.14 56.6,71.14 53.48,68.02 51.98,68.02 49.62,65.66 49.62,65.21 47.81,63.41 39.73,63.41 36.91,60.59 35.85,60.59 33.46,58.2 33.46,55.86 32.16,54.56 32.16,50.65 31.88,50.37 31.88,49.91 33.64,48.15 33.64,47.64 33.84,47.43 34.47,47.43 34.62,47.28 34.62,45.69 34.76,45.55 35.35,45.55 35.44,45.46 35.44,45.34 35.35,45.25 33.74,45.25 33.64,45.15 33.64,45.05 33.74,44.94 35.96,44.94 36.08,44.83 36.08,44.72 36,44.64 35.14,44.64 35.06,44.56 35.06,44.39 35.12,44.33 36.08,44.33 36.18,44.23 36.18,44.09 36.09,44.01 35.07,44.01 34.98,43.92 34.98,43.79 35.07,43.7 36.09,43.7 36.18,43.61 36.18,43.49 36.09,43.4 35.12,43.4 35.03,43.31 35.03,43.18 35.12,43.09 36.09,43.09 36.18,43 36.18,42.88 36.09,42.79 35.07,42.79 34.98,42.7 34.98,42.57 35.07,42.48 36.11,42.48 36.46,42.14 36.46,41.08 v1(36.54,41.01)
  BOTTOM w0.079: v2(69.28,75.74) 69.28,75.54 70.86,73.95 71.38,73.95 73.08,72.25 74.08,72.25 74.1,72.26 75.01,72.26 75.24,72.5 U24.V47
M_B_WE#: length 155.1
  TOP w0.076: v1(38.03,75.46) 37.89,75.32 37.61,75.32 37.53,75.4 37.53,75.65 37.81,75.93 37.81,76.2 38.01,76.4 38.01,76.63 37.81,76.83 37.81,77.3 37.91,77.41 38.16,77.41 38.27,77.3 U4.L2 ; v1(36.23,92.98) 36.45,93.2 v1(36.45,93.95) 36.45,94.23 36.36,94.32 R73.2 ; v1(38.09,88.66) 37.68,88.66 37.6,88.73 37.6,88.94 37.91,89.24 37.91,89.87 U2.L2 ; v1(38.03,55.56) 37.81,55.79 37.81,56.3 38.01,56.5 38.01,56.73 37.81,56.93 37.81,57.34 37.91,57.44 38.11,57.44 38.27,57.28 U6.L2 ; v1(38.14,41.59) 38.14,41.92 37.88,42.18 37.88,43.39 38.27,43.78 U8.L2
  IN1 w0.089: v1(38.09,88.66) 38.37,88.38 38.37,88.18 38.26,88.07 38.09,88.07 37.94,87.92 37.94,87.44 38.27,87.11 38.27,84.53 38.28,84.53 38.28,75.7 v1(38.03,75.46) 37.61,75.04 37.61,74.52 37.27,74.18 37.27,72.41 37.96,71.71 37.96,66.24 38.85,65.35 38.85,59.82 38.28,59.25 38.28,55.8 v1(38.03,55.56) 38.03,55.53 37.61,55.1 37.61,54.62 37.27,54.28 37.27,52.51 38.8,50.98 38.8,50.77 38.71,50.69 38.3,50.69 38.21,50.6 38.21,50.48 38.3,50.4 38.71,50.4 38.8,50.31 38.8,50.19 38.71,50.11 38.5,50.11 38.42,50.02 38.42,49.9 38.5,49.81 38.71,49.81 38.8,49.73 38.8,45.63 38.67,45.5 38.25,45.5 37.4,44.65 37.4,42.91 38.31,42 38.31,41.77 v1(38.14,41.59)
  IN3 w0.089: v1(38.09,88.66) 38.08,88.67 37.49,88.67 35.67,90.49 35.67,91.98 36.23,92.54 v1(36.23,92.98)
  IN3 w0.102: v2(78.98,73.19) 77.61,74.55 73.24,74.55 72.33,73.65 68.59,73.65 68.02,73.07 65.94,73.07 65.33,72.46 62.56,72.46 57.3,67.21 55.6,67.21 55.44,67.05 55.44,66.52 54.82,65.9 52.01,65.9 51.14,65.03 51.14,64.56 47.86,61.28 44.87,61.28 44.69,61.1 44.41,61.1 44.23,61.28 43.08,61.28 42.82,61.02 42.6,61.02 42.35,61.28 40.78,61.28 36.36,56.86 36.36,56.63 36.26,56.53 36.03,56.53 35.92,56.42 35.92,56.32 36.04,56.21 36.27,56.21 36.36,56.12 36.36,55.99 36.27,55.9 35.76,55.9 35.63,55.78 35.63,54.8 35.55,54.71 35.26,54.71 35.17,54.62 35.17,54.49 35.26,54.4 35.55,54.4 35.63,54.31 35.63,54.19 35.55,54.1 35.26,54.1 35.17,54.01 35.17,53.88 35.26,53.79 35.55,53.79 35.63,53.7 35.63,53.58 35.55,53.49 35.26,53.49 35.17,53.4 35.17,53.27 35.26,53.18 35.54,53.18 35.63,53.08 35.63,52.96 35.56,52.88 35.25,52.88 35.17,52.8 35.17,52.65 35.24,52.57 36.27,52.57 36.36,52.49 36.36,52.36 36.27,52.27 35.26,52.27 35.17,52.18 35.17,52.05 35.26,51.96 36.27,51.96 36.36,51.88 36.36,51.75 36.27,51.66 35.26,51.66 35.17,51.57 35.17,51.44 35.26,51.35 36.27,51.35 36.36,51.27 36.36,51.14 36.27,51.05 35.26,51.05 35.17,50.96 35.17,50.83 35.26,50.75 36.27,50.75 36.36,50.66 36.36,50.53 36.27,50.44 35.87,50.44 35.78,50.35 35.78,50.22 35.87,50.14 36.37,50.14 36.5,50.01 36.5,49.91 36.42,49.83 36.42,49.6 36.49,49.53 37.09,49.53 37.2,49.41 37.2,49.29 37.13,49.22 36.82,49.22 36.73,49.13 36.73,49.01 36.82,48.92 37.11,48.92 37.2,48.83 37.2,48.7 37.11,48.61 36.82,48.61 36.73,48.52 36.73,48.4 36.82,48.31 37.11,48.31 37.2,48.22 37.2,48.07 37.13,48 36.81,48 36.73,47.92 36.73,47.79 36.86,47.66 37.1,47.66 37.2,47.56 37.2,42.84 37.8,42.23 37.8,41.7 37.91,41.59 v1(38.14,41.59)
  BOTTOM w0.079: v2(78.98,73.19) 78.98,73.01 U24.V41
MAIND: length 9.2
  TOP w0.102: PR67.2 27.31,40 v1(27.7,39.61) 27.7,36.83 PQ8.3 26.42,36.63 25.91,36.12 24.55,36.12 PC68.1 25.21,35.1 PQ10.2
MAINON: length 425
  TOP w0.102: v1(27.9,28.1) 27.85,28.05 27.54,28.05 27.44,28.16 PR89.1 ; U13.30 182.48,16.58 182.08,16.98 181.16,16.98 180.78,16.59 R462.1 180.04,16.59 v2(179.87,16.42) ; v1(25.84,41.08) 25.6,41.32 PQ7.2 ; R288.1 107.38,36.31 107.81,35.88 v1(107.83,35.88) ; PR116.2 169.23,18.15 169.58,18.5 v2(169.58,19.19) ; v2(136.08,20) 135.8,20.28 135.8,22.74 135.42,23.13 135.42,23.73 135.57,23.88 135.57,24.23 135.86,24.53 136.31,24.53 138.44,26.66 139.15,26.66 v2(139.36,26.86) 139.36,26.94 140.04,27.62 PR92.2 140.04,28.49 140.35,28.79 140.35,29.35 140.22,29.48 140.22,31.4 141.69,32.88 141.69,33.97 142.45,34.73 143.32,34.73 143.7,35.11 143.7,35.55 143.44,35.8 v1(143.44,37.65) ; PR121.2 47.43,11.42 48.07,12.05 51.04,12.05 51.38,12.39 51.38,15.75 52.23,16.6 52.23,18.17 52.49,18.43 v1(52.49,19.29) ; PR59.1 25.7,50.64 25.03,49.97 v2(25.03,49.34)
  IN1 w0.089: v1(68.18,125.57) 68.13,125.52 68.13,124.7 67.65,124.22 66.46,124.22 66.23,123.99 66.23,122.75 65.31,121.83 64.39,121.83 63.51,120.95 63.51,120.38 62.67,119.54 62.67,118.48 63.51,117.64 63.51,110.82 v1(62.9,110.21)
  IN2 w0.089: 25.97,41.08 v1(25.84,41.08) ; 25.97,41.08 26.4,40.65 26.4,37.63 v1(28.13,35.9) ; 25.97,41.08 26.4,41.52 26.4,47.97 v2(25.03,49.34) 25.41,49.34 26.24,50.17 26.24,62.12 25.9,62.46 25.9,73.72 25.41,74.21 25.41,81.36 26.4,82.35 26.4,84.29 25.79,84.9 25.16,84.9 24.9,85.16 24.9,86.88 27.56,89.53 27.56,91.85 30.14,94.43 30.14,95.64 31.92,97.42 43.99,97.42 44.88,98.32 48.12,98.32 50.14,100.34 50.14,100.69 51.67,102.21 51.67,103.12 54.38,105.83 54.65,105.83 54.89,106.07 54.89,106.41 55.38,106.91 56.29,106.91 57.21,107.82 57.21,109.95 57.89,110.62 62.49,110.62 v1(62.9,110.21) ; v1(27.9,28.1) 27.99,28.19 34.54,28.19 35.29,27.45 39.2,27.45 41.08,25.56 41.08,23.35 41.54,22.9 45.84,22.9 46.44,22.29 46.44,21.14 48.75,18.83 52.03,18.83 v1(52.49,19.29) 52.69,19.09 54.19,19.09 55.19,20.09 57.43,20.09 58.19,19.33 60.58,19.33 64.21,15.7 70.69,15.7 70.74,15.75 73.27,15.75 74.05,16.52 80.41,16.52 84.22,20.33 88.1,20.33 91.12,17.31 101.66,17.31 102.61,16.36 107.73,16.36 109.2,17.83 111.24,17.83 111.64,17.42 112.1,17.42 112.56,17.89 112.56,18.3 112.82,18.55 113.5,18.55 113.96,18.09 120.25,18.09 122.07,19.91 123.86,19.91 124.5,19.26 126.27,19.26 126.53,19.52 135.54,19.52 136.02,20 v2(136.08,20) 136.66,20 137.15,19.52 155.33,19.52 155.48,19.67 161.88,19.67 162.74,18.81 169.21,18.81 v2(169.58,19.19) ; v1(107.83,35.88) 112.97,35.88 114.76,34.09 117.19,34.09 118.61,35.5 121.32,35.5 123.62,37.79 137.42,37.79 137.65,38.03 141.92,38.03 142.29,37.65 v1(143.44,37.65)
  IN3 w0.089: v1(143.44,37.65) 143.52,37.73 143.52,38.92 144.08,39.48 144.08,39.61 144.21,39.74 144.21,43 144.71,43.5 144.71,44.92 145.1,45.3 145.1,46.32 146.75,47.97 v1(146.75,49.08)
  BOTTOM w0.102: PR259.1 148.4,27.95 147.38,26.94 146.32,26.94 146.06,27.19 145.48,27.19 144.69,27.98 143.78,27.98 143.52,27.72 143.52,27.11 143.44,27.04 142.43,27.04 142.3,27.16 141.79,27.16 141.55,27.41 139.6,27.41 139.36,27.16 v2(139.36,26.86) ; v1(27.9,28.1) 27.95,28.05 29.4,28.05 29.91,28.56 29.91,31.86 28.13,33.64 v1(28.13,35.9) ; PR214.1 141.44,47.1 142.1,47.76 142.68,47.76 143.75,48.83 v1(145.12,48.83) 146.49,48.83 v1(146.75,49.08) ; v2(169.58,19.19) 169.58,18.76 170.19,18.15 173.24,18.15 175.45,15.94 179.39,15.94 v2(179.87,16.42)
  BOTTOM w0.152: v1(68.18,125.57) 68.07,125.46 PR125.1
