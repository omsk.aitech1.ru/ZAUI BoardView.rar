# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ60: length 51.5
  IN1 w0.089: v1(56.45,94.42) 56.86,94.84 57.47,94.84 57.77,94.53 57.9,94.53 58.1,94.73 58.22,94.73 58.36,94.6 58.36,94.47 58.16,94.27 58.16,94.15 58.29,94.01 58.42,94.01 58.62,94.21 58.74,94.21 58.88,94.08 58.88,93.95 58.68,93.75 58.68,93.63 58.82,93.49 58.94,93.49 59.14,93.69 59.26,93.69 59.4,93.56 59.4,93.43 59.2,93.23 59.2,93.11 59.34,92.97 59.46,92.97 59.66,93.17 59.79,93.17 59.92,93.03 59.92,92.91 59.72,92.71 59.72,92.59 59.86,92.45 59.98,92.45 60.18,92.65 60.31,92.65 60.44,92.51 60.44,92.39 60.24,92.19 60.24,92.06 64.64,87.67 66.51,87.67 67.45,86.73 68.95,86.73 70.09,85.58 71.74,85.58 75.92,81.41 75.92,79.62 76.52,79.02 76.52,77.68 76.76,77.44 76.76,77.35 77.18,76.93 77.18,76.32 77.7,75.8 77.7,75.79 77.79,75.7 77.79,74.79 78.19,74.38 78.19,74.05 78.67,73.57 80.02,73.57 80.33,73.27 80.33,72.66 80.4,72.59 80.4,71.94 80.38,71.92 80.38,68.06 80.53,67.91 80.53,65.47 79.96,64.89 v1(79.63,64.89)
  BOTTOM w0.102: JDIM1.250 56.97,93.7 56.45,94.22 v1(56.45,94.42) ; U24.AR38 v1(79.63,64.89)
M_A_DQ61: length 51.1
  IN1 w0.089: v1(78.98,64.89) 79.44,65.35 79.91,65.35 80.22,65.67 80.22,67.78 80.08,67.92 80.08,72.04 80.11,72.07 80.11,72.47 79.84,72.73 77.91,72.73 77.74,72.91 77.74,74.24 77.4,74.57 77.4,75.68 76.87,76.21 76.87,76.82 76.46,77.23 76.46,77.32 75.63,78.15 75.63,81.28 71.63,85.28 69.91,85.28 68.85,86.35 67.32,86.35 66.64,87.03 65.65,87.03 65.56,87.11 65.56,87.25 65.47,87.34 65.28,87.34 65.2,87.25 65.2,87.11 65.11,87.03 64.87,87.03 57.88,94.01 55.59,94.01 v1(55.18,94.42)
  BOTTOM w0.102: v1(55.18,94.42) 55.18,94.35 56.82,92.7 JDIM1.246 ; v1(78.98,64.89) U24.AR39
M_A_DQ62: length 50.8
  IN1 w0.089: v1(51.55,93.36) 51.96,93.77 54.3,93.77 54.35,93.72 57.76,93.72 64.75,86.73 66.48,86.73 67.19,86.02 68.74,86.02 69.78,84.97 71.52,84.97 75.33,81.16 75.33,78.03 76.17,77.2 76.17,77.11 76.57,76.72 76.57,76.13 76.39,75.95 76.39,75.17 77.41,74.15 77.41,73.14 77.03,72.76 77,72.76 76.64,72.4 76.64,71.74 77.41,70.97 77.41,69.96 77.46,69.91 77.46,68.93 77.37,68.85 77.37,68.39 77.56,68.2 78.02,68.2 78.17,68.06 78.47,68.06 78.77,67.76 78.77,67.32 78.82,67.28 78.82,66.14 78.7,66.03 78.7,65.65 78.44,65.39 78.13,65.39 v1(77.71,64.96)
  BOTTOM w0.076: v1(77.71,64.96) 77.71,64.74 U24.AR42
  BOTTOM w0.102: JDIM1.249 51.45,93.45 v1(51.55,93.36)
M_A_DQ63: length 51.2
  IN1 w0.089: v1(52.18,90.84) 52.97,91.63 56.73,91.63 56.8,91.7 57.37,91.7 60.12,88.95 60.12,88.82 59.88,88.58 59.88,88.45 60.01,88.32 60.14,88.32 60.38,88.56 60.51,88.56 60.64,88.43 60.64,88.3 60.4,88.06 60.4,87.93 60.54,87.8 60.66,87.8 60.9,88.04 61.03,88.04 61.16,87.91 61.16,87.78 60.92,87.54 60.92,87.41 61.06,87.28 61.18,87.28 61.43,87.52 61.55,87.52 61.69,87.39 61.69,87.26 61.44,87.02 61.44,86.89 61.58,86.76 61.7,86.76 61.95,87 62.07,87 64.66,84.41 68.14,84.41 69.2,83.35 70.57,83.35 70.92,83 70.92,82.56 70.72,82.36 70.72,80.87 73.34,78.26 73.34,77.87 74.54,76.67 74.54,73.72 74.99,73.27 74.99,69.91 75.51,69.4 75.51,68.41 76.21,67.7 76.21,67.03 76.72,66.52 76.72,65.85 76.26,65.4 76.26,64.57 76.88,63.95 v1(77.05,63.95)
  BOTTOM w0.102: JDIM1.237 51.2,90.45 51.37,90.28 52,90.28 52.18,90.46 v1(52.18,90.84) ; v1(77.05,63.95) 77.33,63.54 U24.AT43
M_A_DQSN0: length 32.1
  IN1 w0.089: v1(52.26,41.95) 52.55,41.65 52.55,41.58 52.88,41.25 54.02,41.25 55.99,43.22 56.86,43.22 61.57,47.93 62.24,47.93 63.17,48.86 67.81,48.86 68.04,49.09 68.04,49.24 v2(68.38,49.58)
  BOTTOM w0.079: U24.BY47 75.3,52.65 75.24,52.71 73.21,52.71 72.77,52.27 72.32,52.27 70.44,50.39 69.85,50.39 69.47,50.01 68.27,50.01 68.15,49.89 68.15,49.81 v2(68.38,49.58)
  BOTTOM w0.102: JDIM1.53 51.27,42.45 51.51,42.7 52.29,42.7 52.59,42.4 52.59,42.28 v1(52.26,41.95)
M_A_DQSN1: length 40.7
  IN1 w0.089: v1(52.84,32.93) 52.61,32.7 52.61,32.48 52.71,32.38 54.86,32.38 55.64,33.16 58.97,33.16 60.12,34.31 60.55,34.31 63.37,37.13 63.37,37.56 64.18,38.37 67.49,38.37 68.15,39.03 69.06,39.03 69.38,39.34 69.38,39.93 71.97,42.52 71.97,42.88 73.53,44.44 73.72,44.44 74.51,45.22 74.51,46.04 75.23,46.76 75.23,49.24 76.79,50.81 78.27,50.81 78.43,50.97 v2(78.43,51.16)
  BOTTOM w0.102: v2(78.43,51.16) 78.48,51.11 78.48,50.9 U24.CC41 ; v1(52.84,32.93) 52.7,32.78 52.7,32.45 52.29,32.04 51.34,32.04 51.25,31.95 JDIM1.11
M_A_DQSN2: length 31.5
  IN1 w0.089: v2(68.95,52.49) 69.11,52.65 69.11,52.77 69,52.88 68.2,52.88 68.15,52.83 65.76,52.83 65.63,52.96 59.07,52.96 56.28,50.17 56.28,47.85 55.78,47.34 55.14,47.34 54.73,47.76 54.73,47.86 v1(54.33,48.25)
  BOTTOM w0.079: v2(68.95,52.49) 69.15,52.69 69.15,52.8 69.39,53.04 70.6,53.04 71.4,53.83 72.08,54.51 73.56,54.51 73.64,54.59 73.94,54.59 74.1,54.75 75.07,54.75 U24.BR47
  BOTTOM w0.102: v1(54.33,48.25) 54.51,48.08 54.51,47.8 54.77,47.53 57.24,47.53 57.41,47.71 JDIM1.74
M_A_DQSN3: length 37.9
  IN1 w0.089: v1(55.65,37.66) 55.76,37.77 55.76,38.19 56.01,38.43 57.15,38.43 57.48,38.1 57.94,38.1 58.14,38.3 58.14,38.85 58.49,39.2 58.82,39.2 59.21,38.8 59.34,38.8 59.56,39.03 59.56,39.15 59.17,39.55 59.17,39.88 59.53,40.24 59.86,40.24 60.26,39.84 60.38,39.84 60.61,40.07 60.61,40.2 60.21,40.59 60.21,40.92 60.68,41.39 61.91,41.39 63.45,42.92 65.52,42.92 65.64,43.05 65.64,43.57 68.08,46 68.48,46 70.03,47.55 70.03,47.95 71.99,49.91 72.08,49.91 72.09,49.93 72.09,49.94 72.11,49.95 72.12,49.95 72.31,50.14 73.32,50.14 73.88,50.7 73.88,51.32 75.81,53.25 76.28,53.25 76.63,53.6 77.81,53.6 77.92,53.71 78.08,53.71 v2(78.3,53.93)
  BOTTOM w0.102: v1(55.65,37.66) 55.81,37.5 55.81,37.22 56.1,36.94 57.19,36.94 57.45,37.2 JDIM1.32 ; U24.BV41 78.3,53.82 v2(78.3,53.93)
M_A_DQSN4: length 40.7
  IN1 w0.089: v1(52.26,75.04) 52.28,75.02 52.28,74.56 52.54,74.31 53.43,74.31 54.79,75.67 57.26,75.67 57.78,75.15 57.78,71.73 59.59,69.93 59.59,66.03 65.14,60.48 66.98,60.48 67.12,60.34 67.12,60.03 v2(67.04,59.96)
  BOTTOM w0.079: v2(67.04,59.96) 67.04,60.73 68.62,62.31 72.07,62.31 72.64,62.87 74.44,62.87 74.48,62.9 74.81,62.9 74.83,62.88 75.34,62.88 75.73,62.48 75.94,62.48 U24.AV46
  BOTTOM w0.102: v1(52.26,75.04) 52.51,75.3 52.51,75.42 52.36,75.58 51.41,75.58 51.29,75.46 JDIM1.177
M_A_DQSN5: length 46.1
  IN1 w0.089: v1(53.17,87.23) 52.86,86.92 52.86,86.82 53.09,86.6 57.06,86.6 63.46,80.2 65.63,80.2 67.73,78.09 67.73,77.5 67.62,77.39 67.62,75.95 71.39,72.18 71.39,69.73 72.27,68.85 72.27,68.79 72.47,68.6 73.31,68.6 73.88,68.03 73.88,67.54 74.52,66.91 74.52,63.1 75.49,62.12 76.42,62.12 76.81,61.73 77.96,61.73 v2(78.34,62.11)
  BOTTOM w0.076: v2(78.34,62.11) 78.65,61.79 U24.AY41
  BOTTOM w0.102: JDIM1.219 51.29,85.95 51.41,86.08 52.35,86.08 52.89,86.62 52.89,86.96 v1(53.17,87.23)
M_A_DQSN6: length 36.8
  IN1 w0.089: v1(56.15,80.78) 56.04,80.78 55.94,80.89 55.94,81.14 56.09,81.29 57.05,81.29 61.91,76.43 61.91,73.61 62.89,72.63 63.4,72.63 63.54,72.49 63.54,72.17 63.4,72.03 63.31,72.03 63.08,71.8 63.08,71.18 63.31,70.95 63.91,70.95 64.03,70.83 64.03,70.44 63.94,70.35 63.31,70.35 63.08,70.12 63.08,69.7 63.8,68.98 64.67,68.98 68.88,64.77 68.92,64.77 69.34,64.35 70.99,64.35 71.11,64.24 v2(71.11,64.1)
  BOTTOM w0.079: v2(71.11,64.1) 71.18,64.17 71.66,64.17 71.74,64.25 72.25,64.25 72.62,64.62 74.26,64.62 74.29,64.59 75.41,64.59 75.51,64.7 75.66,64.7 U24.AN46
  BOTTOM w0.102: v1(56.15,80.78) 55.94,80.99 55.94,81.11 56.04,81.22 57.03,81.22 57.54,80.7 JDIM1.198
M_A_DQSN7: length 51.1
  IN1 w0.089: v1(55.89,92.14) 55.97,92.21 55.97,92.7 56.2,92.93 57.44,92.93 65.22,85.15 68.45,85.15 69.48,84.12 70.84,84.12 72.3,82.66 72.3,82.13 71.88,81.72 71.88,81.59 72.18,81.29 72.31,81.29 72.71,81.7 73.26,81.7 73.73,81.23 74.12,81.23 74.55,80.81 74.55,80.06 74.32,79.83 73.44,79.83 73.35,79.74 73.35,79.32 73.44,79.24 74.32,79.24 74.55,79 74.55,77.7 75.28,76.97 75.28,74.06 75.49,73.84 75.49,70.18 76.27,69.41 76.27,69.37 76.52,69.12 76.52,68.64 76.39,68.52 76.39,68.19 77.32,67.25 77.32,66.78 77.1,66.56 77.1,65.6 76.69,65.19 76.69,64.7 76.87,64.52 77.3,64.52 77.34,64.56 77.88,64.56 77.97,64.65 78.12,64.65 v1(78.36,64.89)
  BOTTOM w0.102: v1(55.89,92.14) 55.97,92.06 55.97,91.6 56.22,91.35 57.34,91.35 57.48,91.21 JDIM1.240 ; U24.AR41 78.36,64.86 v1(78.36,64.89)
M_A_DQSN8: length 5.8
  TOP w0.102: v1(53.02,53.15) 52.53,52.65 51.43,52.65 50.95,53.14 R208.1
  BOTTOM w0.102: v1(53.02,53.15) 53.02,53.07 52.56,52.61 51.5,52.61 51.16,52.95 JDIM1.95
M_A_DQSP0: length 32.1
  IN1 w0.089: v1(52.89,41.95) 52.79,41.85 52.79,41.68 52.98,41.49 53.92,41.49 55.89,43.46 56.76,43.46 61.47,48.17 62.14,48.17 63.07,49.1 67.69,49.1 67.8,49.21 v2(67.8,49.57)
  BOTTOM w0.079: v2(67.8,49.57) 67.98,49.75 67.98,49.96 68.2,50.18 69.4,50.18 69.78,50.56 70.37,50.56 72.25,52.44 72.7,52.44 73.14,52.88 75.31,52.88 75.71,52.48 U24.BY46
  BOTTOM w0.102: JDIM1.55 52.39,42.95 52.84,42.51 52.84,42 v1(52.89,41.95)
M_A_DQSP1: length 40.7
  IN1 w0.089: v2(78.43,50.25) 78.07,50.61 76.85,50.61 75.44,49.21 75.44,46.67 74.74,45.97 74.74,45.11 73.82,44.19 73.63,44.19 72.21,42.78 72.21,42.42 69.62,39.83 69.62,39.24 69.16,38.78 68.25,38.78 67.59,38.12 64.28,38.12 63.61,37.46 63.61,37.03 60.65,34.07 60.22,34.07 59.07,32.92 55.74,32.92 54.96,32.14 52.61,32.14 52.37,32.38 52.37,32.76 v1(52.21,32.93)
  BOTTOM w0.102: v2(78.43,50.25) 78.65,50.03 U24.CE41 ; JDIM1.13 51.16,32.45 51.32,32.29 52.18,32.29 52.44,32.55 52.44,32.7 v1(52.21,32.93)
M_A_DQSP2: length 31.5
  IN1 w0.089: v1(54.97,48.25) 54.97,47.86 55.24,47.59 55.68,47.59 56.04,47.95 56.04,50.27 58.97,53.2 65.73,53.2 65.86,53.07 68.05,53.07 68.1,53.12 69.1,53.12 69.35,52.87 69.35,52.67 69.53,52.49 v2(69.53,52.48)
  BOTTOM w0.076: 69.32,52.65 69.49,52.48 v2(69.53,52.48)
  BOTTOM w0.079: U24.BR46 75.91,54.98 75.63,54.71 75.26,54.71 75.13,54.58 74.17,54.58 74.01,54.42 73.71,54.42 73.63,54.34 72.15,54.34 71.56,53.76 70.67,52.87 69.45,52.87 69.32,52.73 69.32,52.65
  BOTTOM w0.102: JDIM1.76 57.55,48.2 57.14,47.79 54.88,47.79 54.76,47.9 54.76,48.05 v1(54.97,48.25)
M_A_DQSP3: length 37.9
  IN1 w0.089: v1(56.29,37.66) 56.01,37.95 56.01,38.09 56.11,38.19 57.05,38.19 57.38,37.86 58.04,37.86 58.38,38.2 58.38,38.75 58.59,38.96 58.72,38.96 59.11,38.56 59.44,38.56 59.81,38.93 59.81,39.25 59.41,39.65 59.41,39.78 59.63,40 59.76,40 60.16,39.6 60.48,39.6 60.85,39.97 60.85,40.3 60.45,40.69 60.45,40.82 60.78,41.15 62.01,41.15 63.55,42.68 65.62,42.68 65.89,42.95 65.89,43.47 68.18,45.76 68.58,45.76 70.27,47.45 70.27,47.85 72.38,49.96 73.4,49.96 74.06,50.62 74.06,51.25 75.88,53.07 76.36,53.07 76.71,53.42 77.88,53.42 77.99,53.53 78.32,53.53 78.42,53.43 78.42,53.16 v2(78.3,53.04)
  BOTTOM w0.102: v2(78.3,53.04) 78.3,52.74 78.48,52.55 U24.BW41 ; 58.45,37.71 57.59,37.71 57.08,37.2 56.2,37.2 56.07,37.33 56.07,37.44 v1(56.29,37.66)
M_A_DQSP4: length 40.7
  IN1 w0.089: v1(52.89,75.04) 52.82,75.04 52.53,74.74 52.53,74.66 52.64,74.55 53.33,74.55 54.69,75.91 57.36,75.91 58.02,75.25 58.02,71.84 59.83,70.03 59.83,66.13 65.24,60.72 67.08,60.72 67.36,60.44 67.36,60.15 67.56,59.96 v2(67.63,59.96)
  BOTTOM w0.076: 74.86,62.71 75.25,62.71 75.33,62.63 75.33,62.52 U24.AV47
  BOTTOM w0.079: v2(67.63,59.96) 67.55,59.96 67.21,60.29 67.21,60.66 68.69,62.14 72.14,62.14 72.71,62.7 74.51,62.7 74.55,62.74 74.74,62.74 74.76,62.71 74.86,62.71
  BOTTOM w0.102: JDIM1.179 51.29,75.95 51.41,75.83 52.46,75.83 52.77,75.53 52.77,75.19 52.89,75.06 v1(52.89,75.04)
M_A_DQSP5: length 46.2
  IN1 w0.089: v2(78.32,61.19) 78.32,61.46 78.23,61.55 76.74,61.55 76.35,61.95 75.42,61.95 74.31,63.05 74.31,66.86 73.7,67.47 73.7,67.95 73.23,68.42 72.4,68.42 72.15,68.67 72.11,68.67 71.14,69.63 71.14,72.08 67.38,75.85 67.38,77.49 67.49,77.6 67.49,77.99 65.53,79.96 63.36,79.96 56.96,86.36 52.99,86.36 52.62,86.72 52.62,86.97 v1(52.37,87.23)
  BOTTOM w0.076: v2(78.32,61.19) 78.65,60.87 U24.BB41
  BOTTOM w0.102: JDIM1.221 51.29,86.45 51.41,86.33 52.24,86.33 52.64,86.73 52.64,86.96 v1(52.37,87.23)
M_A_DQSP6: length 36.8
  IN1 w0.089: v1(55.51,80.78) 55.7,80.97 55.7,81.24 55.99,81.53 57.15,81.53 62.15,76.53 62.15,73.71 62.99,72.87 63.5,72.87 63.78,72.59 63.78,72.07 63.5,71.79 63.41,71.79 63.32,71.7 63.32,71.28 63.41,71.19 64.01,71.19 64.27,70.93 64.27,70.34 64.04,70.11 63.41,70.11 63.32,70.02 63.32,69.8 63.9,69.22 64.77,69.22 68.98,65.01 69.02,65.01 69.44,64.59 71.45,64.59 v2(71.51,64.53)
  BOTTOM w0.079: U24.AN47 75.39,64.9 75.39,64.82 75.34,64.76 74.36,64.76 74.33,64.79 72.55,64.79 72.2,64.43 71.61,64.43 v2(71.51,64.53)
  BOTTOM w0.102: v1(55.51,80.78) 55.69,80.96 55.69,81.22 55.94,81.47 57.14,81.47 57.4,81.21 JDIM1.200
M_A_DQSP7: length 51.1
  IN1 w0.089: v1(56.53,92.14) 56.21,92.45 56.21,92.6 56.3,92.69 57.34,92.69 65.12,84.91 68.35,84.91 69.38,83.88 70.74,83.88 72.06,82.56 72.06,82.23 71.64,81.82 71.64,81.49 72.08,81.05 72.41,81.05 72.81,81.46 73.16,81.46 73.63,80.99 74.02,80.99 74.31,80.71 74.31,80.16 74.22,80.07 73.34,80.07 73.11,79.84 73.11,79.22 73.34,78.99 74.22,78.99 74.31,78.9 74.31,77.6 75.04,76.87 75.04,73.96 75.25,73.74 75.25,70.08 76.1,69.24 76.15,69.24 76.34,69.05 76.34,68.72 76.21,68.59 76.21,68.11 77.14,67.18 77.14,66.86 76.92,66.63 76.92,65.67 76.52,65.27 76.52,64.62 76.79,64.35 77.38,64.35 77.42,64.39 77.95,64.39 78.04,64.48 78.54,64.48 78.63,64.39 78.63,64.23 v1(78.38,63.99)
  BOTTOM w0.102: v1(78.38,63.99) 78.39,63.98 U24.AT41 ; v1(56.53,92.14) 56.22,91.83 56.22,91.71 56.33,91.6 57.36,91.6 57.47,91.7 JDIM1.242
M_A_DQSP8: length 2.7
  TOP w0.102: R205.1 50.95,53.82 v1(51.62,53.15)
  BOTTOM w0.102: v1(51.62,53.15) 51.6,53.15 51.29,53.46 JDIM1.97
M_A_PARITY: length 44.8
  TOP w0.089: 75.12,57.52 75.73,56.91 76.23,56.91 76.84,56.3 77.61,56.3 78.55,55.36 78.93,55.36 79.28,55.7 79.28,56.34 79.41,56.48 79.41,57.26 79.34,57.34 79.34,58.89 79.14,59.08 v2(79.14,59.41)
  TOP w0.127: v1(54.27,67.09) 56.37,67.09 56.68,67.4 56.68,67.8 57.05,68.16 63.05,68.16 63.41,67.8 67.88,67.8 68.06,67.63 70.89,67.63 71.88,66.63 73.5,66.63 73.79,66.34 73.79,62.03 73.85,61.97 73.85,58.79 75.12,57.52
  BOTTOM w0.127: U24.BF39 79.3,59.25 v2(79.14,59.41) ; JDIM1.143 51.44,64.95 52.77,66.28 53.48,66.28 54.26,67.07 54.26,67.09 54.27,67.09 v1(54.27,67.09)
M_A_RAS#: length 42.6
  TOP w0.127: v2(78.24,56.65) 78.24,56.68 78.17,56.76 78.17,56.86 77.88,57.14 77.45,57.14 77.2,57.39 76.03,57.39 74.36,59.07 74.36,62.61 74.27,62.7 74.27,66.95 73.79,67.43 73.79,67.76 73.49,68.06 72.2,68.06 70.95,69.3 70.09,69.3 69.28,68.49 68.39,68.49 67.68,69.2 66.05,69.2 65.64,68.79 63.72,68.79 63.39,69.12 63.13,69.12 63.01,69.24 63.01,69.83 62.9,69.94 62.72,69.94 62.6,69.82 62.6,69.24 62.48,69.12 62.31,69.12 62.2,69.24 62.2,69.81 62.06,69.94 61.88,69.94 61.79,69.85 61.79,69.08 61.68,68.97 61.51,68.97 61.38,69.1 61.38,69.81 61.25,69.94 61.07,69.94 60.98,69.84 60.98,69.1 60.87,69 60.69,69 60.57,69.12 60.57,69.88 60.46,69.99 60.28,69.99 60.16,69.87 60.16,69.09 60.04,68.97 59.88,68.97 59.76,69.09 59.76,69.41 59.64,69.53 59.47,69.53 59.35,69.41 59.35,69.09 59.23,68.97 59.06,68.97 58.94,69.09 58.94,69.41 58.82,69.53 58.66,69.53 58.54,69.41 58.54,69.09 58.42,68.97 58.25,68.97 58.13,69.09 58.13,69.41 58.01,69.53 57.84,69.53 57.72,69.41 57.72,69.24 57.61,69.12 v1(57.16,69.12)
  BOTTOM w0.127: v1(57.16,69.12) 57.19,69.12 57.26,69.2 57.52,69.2 57.52,69.2 JDIM1.152 ; v2(78.24,56.65) 78.29,56.6 78.29,56.57 U24.BM41
M_A_WE#: length 39.8
  TOP w0.089: v2(76.8,58.3) 76.8,58.51 76.13,59.17 76.13,60.06 75.94,60.25
  TOP w0.127: 75.94,60.25 75.14,61.05 75.14,63.49 74.99,63.64 74.99,68.36 74.08,69.28 72.74,69.28 70.6,71.42 68.69,71.42 68.44,71.66 65.44,71.66 64.98,71.21 55.99,71.21 55.54,70.75 55.54,69.95 54.27,68.69 53.19,68.69 v1(52.93,68.95)
  BOTTOM w0.079: U24.BG43 77.06,58.04 v2(76.8,58.3)
  BOTTOM w0.127: JDIM1.151 51.1,68.95 51.23,69.09 51.23,69.14 51.55,69.46 52.42,69.46 v1(52.93,68.95)
M_B1_ZQ0: length 3.8
  TOP w0.102: R113.1 v1(43.38,82.15) 43.38,83.52 U2.F9
M_B2_ZQ0: length 3.5
  TOP w0.102: R189.1 42.35,68.05 42.35,71.25 U4.F9
M_B3_ZQ0: length 3.8
  TOP w0.102: U6.F9 42.35,51.35 42.35,50.49 41.22,49.35 v1(41.22,49.02) R228.1
M_B4_ZQ0: length 4.4
  TOP w0.102: U8.F9 42.45,38.1 42.45,37.68 v1(40.54,35.77) 40.08,35.3 R294.1
M_B_A0: length 155.5
  TOP w0.076: U2.P3 35.6,89.43 34.8,88.63 v1(34.22,88.63) 33.76,88.63 32.28,90.11 32.28,92.37 31.41,93.23 v1(31.41,93.26) 31.39,93.26 30.94,93.71 R85.2 ; v1(33.13,54.52) 33.13,55.03 33.72,55.62 34.99,55.62 35.48,56.11 35.75,56.11 U6.P3 ; v1(33.13,74.42) 33.13,74.86 33.79,75.52 34.99,75.52 35.53,76.06 35.79,76.06 U4.P3 ; v1(33.77,41.62) 33.53,41.62 33.42,41.72 33.42,42.14 33.56,42.28 34.96,42.28 35.6,42.91 35.7,42.91 U8.P3
  IN1 w0.089: v1(34.22,88.63) 34.19,88.6 34.19,88.17 34.11,88.09 33.87,88.09 33.79,88.01 33.79,87.9 33.87,87.82 34.11,87.82 34.19,87.75 34.19,87.64 34.11,87.56 33.87,87.56 33.79,87.48 33.79,87.37 33.87,87.29 34.11,87.29 34.19,87.21 34.19,86.44 34.05,86.3 34.05,80.38 34.21,80.23 34.21,78.27 33.44,77.51 33.44,76.97 33.62,76.8 33.62,75.94 33.32,75.64 33.32,74.61 v1(33.13,74.42) 33.32,74.24 33.32,73.53 33.82,73.03 33.82,65.79 34.27,65.34 34.27,63.92 33.67,63.32 33.67,63.1 33.84,62.92 33.84,62.72 33.67,62.55 33.67,62.09 34.21,61.55 34.21,58.73 33.44,57.97 33.44,55.86 33.32,55.74 33.32,54.75 33.13,54.56 v1(33.13,54.52) 33.32,54.34 33.32,53.44 33.84,52.91 33.84,52.03 33.55,51.74 33.55,48.46 33.72,48.29 33.72,46.44 33.91,46.25 33.91,44.96 33.62,44.66 33.62,42.23 33.79,42.05 34.13,42.05 34.73,41.45 34.73,41.16 34.66,41.08 34.52,41.08 34.44,41.16 34.44,41.38 34.35,41.47 34.25,41.47 34.15,41.37 34.15,41.18 34.05,41.08 33.74,41.08 33.64,41.18 33.64,41.49 v1(33.77,41.62)
  IN3 w0.102: v2(73.21,76.31) 72.83,76.69 71.18,76.69 71.04,76.55 67.83,76.55 66.89,75.61 61.1,75.61 57.65,72.16 55.26,72.16 53.49,70.39 51.74,70.39 50.99,69.64 50.99,68.47 48.6,66.08 48.6,65.65 47.38,64.43 37.62,64.43 32.92,59.73 32.58,59.73 32.35,59.49 32.35,57.21 30.36,55.23 30.36,49.99 30.57,49.79 30.57,49.59 30.36,49.39 30.36,49.15 30.45,49.06 31.11,49.06 31.2,48.97 31.2,48.85 31.11,48.76 30.45,48.76 30.36,48.67 30.36,47.8 30.45,47.71 30.62,47.71 30.71,47.62 30.71,47.5 30.62,47.41 30.45,47.41 30.36,47.32 30.36,47.1 30.57,46.9 30.57,46.61 30.36,46.41 30.36,46.41 30.08,46.13 30.08,45.15 30.29,44.94 30.62,44.94 30.82,44.74 31.61,44.74 31.86,44.49 31.86,42.81 31.56,42.51 31.56,41.9 31.76,41.69 32.72,41.69 32.81,41.78 32.81,42.2 32.9,42.29 33.03,42.29 33.12,42.2 33.12,41.78 33.21,41.69 33.69,41.69 v1(33.77,41.62)
  BOTTOM w0.076: 78,74.58 78,74.83 77.66,75.17 77.66,75.8 77.4,76.06 75.25,76.06 75.1,76.14 74.89,76.14 74.44,75.96 73.57,75.96 v2(73.21,76.31)
  BOTTOM w0.079: U24.P42 78,74.58
M_B_A1: length 154.9
  TOP w0.076: v1(34.48,73.71) 35.06,73.71 35.13,73.63 35.13,73.44 35.21,73.37 35.34,73.37 35.41,73.44 35.41,73.63 35.49,73.71 36.01,73.71 36.38,73.34 36.38,73.09 36.23,72.93 U4.P7 ; U2.P7 35.87,85.96 35.75,85.84 35.54,85.84 35.44,85.94 35.44,86.88 v1(35.34,86.98) 34.73,86.98 33.98,87.73 33.64,87.73 30.68,90.69 R89.2 ; U6.P7 36.01,53.17 36.01,53.35 35.08,54.28 34.78,54.28 34.48,53.98 v1(34.48,53.81) ; U8.P7 35.84,39.91 35.53,39.91 35.14,40.3 34.86,40.3 v1(34.48,40.68)
  IN1 w0.089: v1(35.34,86.98) 35.06,86.98 34.96,86.87 34.96,86.68 35.14,86.49 35.14,86.31 34.82,85.99 34.82,80.7 34.97,80.55 34.97,78.32 35.12,78.16 35.12,76.37 34.08,75.32 34.08,73.85 34.22,73.71 v1(34.48,73.71) 34.73,73.46 34.73,73.01 34.58,72.86 34.58,66.25 35.03,65.8 35.03,60.49 34.97,60.43 34.97,56.94 35.12,56.78 35.12,56.46 34.86,56.21 34.48,56.21 34.22,55.95 34.22,55.57 34.08,55.42 34.08,53.96 34.23,53.81 v1(34.48,53.81) 34.73,53.56 34.73,53.08 34.61,52.96 34.61,51.72 34.31,51.42 34.31,48.78 34.48,48.61 34.48,46.76 35.1,46.14 35.1,45.89 35.18,45.8 35.26,45.8 35.35,45.72 35.35,45.6 35.26,45.51 35.18,45.51 35.1,45.42 35.1,45.3 35.18,45.22 35.26,45.22 35.35,45.13 35.35,45.01 35.26,44.93 35.18,44.93 35.1,44.84 35.1,44.72 35.18,44.63 35.26,44.63 35.35,44.55 35.35,44.43 35.26,44.34 35.18,44.34 35.1,44.26 35.1,44.14 35.18,44.05 35.26,44.05 35.35,43.96 35.35,43.84 35.26,43.76 35.18,43.76 35.1,43.67 35.1,43.55 35.18,43.47 35.26,43.47 35.35,43.38 35.35,43.26 35.26,43.17 35.18,43.17 35.1,43.09 35.1,42.65 34.76,42.32 34.76,41.78 34.99,41.55 34.99,40.57 35.22,40.35 35.49,40.35 35.55,40.3 35.55,40.14 35.47,40.07 35.09,40.07 v1(34.48,40.68)
  IN3 w0.102: v1(34.48,40.68) 34.43,40.63 33.59,40.63 33.22,40.99 31.74,40.99 30.59,42.14 30.59,42.27 30.76,42.44 30.76,42.57 30.67,42.66 30.55,42.66 30.38,42.48 30.25,42.48 30.16,42.57 30.16,42.7 30.33,42.87 30.33,43 30.24,43.09 30.12,43.09 29.95,42.92 29.82,42.92 29.73,43.01 29.73,43.13 29.9,43.3 29.9,43.43 29.81,43.52 29.69,43.52 29.51,43.35 29.39,43.35 29.3,43.44 29.3,43.56 29.47,43.73 29.47,43.86 29.38,43.95 29.25,43.95 29.08,43.78 28.96,43.78 28.87,43.87 28.87,43.99 29.04,44.17 29.04,44.29 28.95,44.38 28.82,44.38 28.65,44.21 28.53,44.21 28.27,44.47 28.27,44.69 28.36,44.77 28.88,44.77 28.97,44.86 28.97,44.99 28.88,45.08 28.36,45.08 28.27,45.17 28.27,45.29 28.36,45.38 28.88,45.38 28.97,45.47 28.97,45.6 28.88,45.69 28.36,45.69 28.27,45.78 28.27,45.9 28.36,45.99 28.88,45.99 28.97,46.08 28.97,46.21 28.88,46.3 28.36,46.3 28.27,46.39 28.27,46.51 28.36,46.6 28.53,46.6 28.62,46.69 28.62,46.82 28.53,46.91 28.36,46.91 28.27,47 28.27,56.98 31.58,60.29 31.58,61.24 33.95,63.61 35.26,63.61 38.05,66.4 46.66,66.4 47.94,67.68 48.76,67.68 49.97,68.89 49.97,70.06 51.32,71.41 53.07,71.41 54.84,73.18 57.23,73.18 61,76.95 64.55,76.95 v2(64.72,76.78)
  BOTTOM w0.079: U24.Y49 74.28,71.91 72.92,71.91 71.23,73.6 70.62,73.6 68.69,75.53 67.4,75.53 67.24,75.68
  BOTTOM w0.127: v2(64.72,76.78) 65.19,76.31 66.61,76.31 67.24,75.68
M_B_A2: length 153.6
  TOP w0.076: U8.R3 35.07,43.07 34.73,42.73 32.75,42.73 v1(32.12,42.1) ; 30.41,94.22 31.01,94.22 32.52,92.71 32.52,90.46 v1(33.72,89.27) 33.9,89.08 34.12,89.08 34.13,89.09 34.69,89.09 35.03,89.43 U2.R3 ; U6.R3 34.73,55.89 33.98,55.89 33.6,56.26 32.31,56.26 32.07,56.02 v1(32.07,55.64) ; U4.R3 34.73,75.79 32.42,75.79 32.17,75.54 v1(32.07,75.54)
  TOP w0.127: 30.41,94.22 30.34,94.22 29.84,94.72 R66.2
  IN1 w0.089: v1(32.12,42.1) 32.31,41.91 32.31,40.66 32.4,40.58 32.53,40.58 32.6,40.65 32.6,45.17 32.89,45.46 32.89,45.83 32.7,46.02 32.7,47.87 32.52,48.05 32.52,49.64 32.2,49.96 32.2,50.97 32.47,51.24 32.47,52.01 32.3,52.18 32.3,53.64 31.91,54.03 31.91,55.49 v1(32.07,55.64) 32.07,55.93 32.39,56.25 32.39,58.36 33.19,59.16 33.19,59.75 32.65,60.29 32.65,68.98 32.27,69.36 32.27,70.94 32.47,71.14 32.47,71.87 32.21,72.13 32.21,73.64 31.91,73.94 31.91,74.67 31.79,74.79 31.79,75.16 32.07,75.44 v1(32.07,75.54) 32.07,75.83 32.39,76.15 32.39,77.9 33.19,78.7 33.19,79.81 33.03,79.97 33.03,82.12 32.66,82.5 32.66,84.78 32.9,85.03 32.9,86.42 33.54,87.05 33.54,87.78 33.46,87.86 33.25,87.86 33.17,87.94 33.17,88.05 33.25,88.12 33.46,88.12 33.54,88.2 33.54,88.31 33.46,88.39 33.16,88.39 33.08,88.47 33.08,88.58 33.16,88.66 33.68,88.66 33.84,88.82 33.84,89.14 v1(33.72,89.27)
  IN3 w0.102: v1(32.12,42.1) 32.12,44.84 31.91,45.05 31.28,45.05 31.18,45.15 31.18,45.25 31.28,45.35 31.71,45.35 31.78,45.42 31.78,45.57 31.69,45.66 31.03,45.66 30.95,45.74 30.95,45.87 31.03,45.96 31.72,45.96 31.81,46.05 31.81,46.18 31.72,46.26 30.87,46.26 30.78,46.35 30.78,46.48 30.87,46.57 31.72,46.57 31.81,46.66 31.81,46.79 31.72,46.87 31.46,46.87 31.37,46.96 31.37,47.09 31.46,47.18 31.72,47.18 31.81,47.27 31.81,47.39 31.72,47.48 31.61,47.48 31.52,47.57 31.52,47.7 31.61,47.79 31.72,47.79 31.81,47.88 31.81,48 31.72,48.09 30.9,48.09 30.81,48.18 30.81,48.31 30.9,48.4 31.72,48.4 31.81,48.49 31.81,48.91 30.62,50.09 30.62,55.12 32.7,57.21 32.7,58.52 35.54,61.35 35.75,61.35 37.13,62.74 37.13,62.86 37.03,62.97 37.03,63.09 37.12,63.18 37.24,63.18 37.35,63.08 37.47,63.08 37.56,63.17 37.56,63.29 37.46,63.4 37.46,63.52 37.55,63.61 37.67,63.61 37.78,63.51 37.9,63.51 37.99,63.6 37.99,63.72 37.89,63.83 37.89,63.96 37.98,64.05 38.1,64.05 38.21,63.94 38.34,63.94 38.57,64.17 47.5,64.17 48.86,65.53 48.86,65.98 51.24,68.36 51.24,69.08 51.53,69.37 53.74,69.37 56.28,71.91 57.76,71.91 61.21,75.36 67,75.36 67.79,76.16 v2(67.99,76.16)
  BOTTOM w0.076: v2(67.99,76.16) 68.38,76.54 69.35,76.54 69.84,76.05 69.84,75.5 71.03,74.31 71.58,74.31 72.13,73.76 72.67,73.76 73.08,73.35 74.17,73.35 74.18,73.36 74.47,73.36 74.7,73.13 U24.U48
M_B_A3: length 159.1
  TOP w0.076: U8.N7 36.44,39.88 36.08,40.25 35.72,40.25 35.4,40.57 35.4,40.7 35.39,40.7 v1(35.39,40.75) ; U2.N7 36.51,86.39 36.51,87.11 v1(35.62,88) 35.37,88 35.34,87.97 33.74,87.97 31.55,90.15 v1(31.55,90.68) 31.55,90.69 31.55,90.76 30.68,91.63 R88.2 ; U6.N7 36.67,52.7 36.59,52.62 36.3,52.62 36.25,52.67 36.25,53.45 35.18,54.52 34.55,54.52 v1(34.5,54.56) ; v1(34.5,74.35) 34.89,73.96 35.13,73.96 35.22,74.06 35.22,74.25 35.3,74.32 35.43,74.32 35.5,74.25 35.5,74.07 35.61,73.96 36.1,73.96 36.76,73.3 36.76,73.03 U4.N7
  IN1 w0.089: v1(35.39,40.75) 35.75,40.75 35.88,40.88 35.88,41.49 35.72,41.64 35.26,41.64 35.02,41.88 35.02,42.21 35.6,42.8 35.6,46.44 35.41,46.63 34.97,46.63 34.73,46.87 34.73,48.72 34.57,48.88 34.57,51.32 34.86,51.61 34.86,52.85 34.98,52.97 34.98,53.91 34.5,54.39 v1(34.5,54.56) 34.5,54.59 34.33,54.77 34.33,55.32 35.38,56.36 35.38,56.89 35.22,57.04 35.22,60.32 35.29,60.39 35.29,65.9 34.83,66.35 34.83,72.73 34.98,72.87 34.98,73.85 34.5,74.32 v1(34.5,74.35) 34.35,74.5 34.35,75.23 35.38,76.26 35.38,78.27 35.22,78.42 35.22,80.65 35.07,80.81 35.07,85.88 35.77,86.58 35.77,87.34 35.62,87.49 35.32,87.49 35.22,87.59 35.22,87.89 35.32,88 v1(35.62,88)
  IN3 w0.102: v2(65.71,76.77) 65.29,76.77 64.86,77.2 60.89,77.2 57.71,74.01 55.01,74.01 53.41,72.41 51.66,72.41 51.46,72.21 51.46,71.91 49.72,70.17 49.72,69 48.65,67.93 47.83,67.93 46.55,66.65 41.05,66.65 40.96,66.74 40.96,67.23 40.87,67.32 40.74,67.32 40.65,67.23 40.65,66.74 40.56,66.65 39.56,66.65 39.47,66.74 39.47,67.23 39.38,67.32 39.26,67.32 39.17,67.23 39.17,66.74 39.08,66.65 37.94,66.65 36.05,64.76 35.49,64.76 35.4,64.67 35.4,64.31 35.31,64.22 35.18,64.22 35.1,64.31 35.1,64.67 35.01,64.76 34.74,64.76 31.33,61.35 31.33,60.4 28.01,57.08 28.01,43.88 31.2,40.7 33.08,40.7 33.41,40.37 33.97,40.37 34.28,40.07 34.71,40.07 34.89,40.25 35.65,40.25 35.88,40.47 35.88,41.49 35.76,41.61 35.48,41.61 35.39,41.52 v1(35.39,40.75)
  BOTTOM w0.076: 67.24,76.19 67.65,75.78 68.72,75.78 70.72,73.77 71.31,73.77
  BOTTOM w0.079: 71.31,73.77 73,72.08 74.15,72.08 74.17,72.1 75.1,72.1 75.51,72.15 75.75,72.15 U24.Y45
  BOTTOM w0.127: 67.24,76.19 66.66,76.77 v2(65.71,76.77)
M_B_A4: length 157.2
  TOP w0.076: U6.N3 36.67,56.09 36.86,55.9 36.86,55.77 36.72,55.63 36.62,55.63 36.38,55.87 35.62,55.87 35.37,55.61 35.37,54.88 35.3,54.81 35.09,54.81 v1(34.76,55.14) ; v1(34.77,74.93) 35.06,75.22 35.17,75.22 35.37,75.02 35.47,75.02 35.57,75.12 35.57,75.22 35.38,75.41 35.38,75.52 35.68,75.81 36.3,75.81 36.34,75.78 36.59,75.78 36.67,75.85 U4.N3 ; v1(35.42,42.05) 35.47,42.1 35.47,42.12 36.42,43.08 U8.N3 ; U2.N3 36.42,89.43 35.62,88.63 v1(35.49,88.63) 35.08,88.21 33.84,88.21 32.04,90.01 32.04,90.76 31.49,91.3 v1(31.49,91.97) 31.49,92.02 30.77,92.75 R87.2
  IN1 w0.089: v1(35.49,88.63) 35.49,89.01 35.62,89.14 35.88,89.14 36.05,88.97 36.05,86.5 35.32,85.78 35.32,80.91 35.48,80.76 35.48,78.53 35.63,78.37 35.63,76.16 34.77,75.3 v1(34.77,74.93) 34.94,74.76 34.94,74.24 35.24,73.95 35.24,72.77 35.09,72.62 35.09,66.46 35.54,66.01 35.54,60.28 35.48,60.22 35.48,57.15 35.63,56.99 35.63,56.25 34.76,55.38 v1(34.76,55.14) 34.93,54.97 34.93,54.32 35.24,54.01 35.24,52.87 35.11,52.74 35.11,51.51 34.82,51.21 34.82,48.99 34.99,48.82 34.99,47.56 35.09,47.45 35.56,47.45 35.65,47.36 35.65,47.24 35.56,47.15 35.06,47.15 34.99,47.08 34.99,46.97 35.08,46.88 35.77,46.88 35.86,46.79 35.86,42.18 35.72,42.05 v1(35.42,42.05)
  IN3 w0.102: v1(35.42,42.05) 34.55,41.18 33.6,41.18 33.52,41.26 31.83,41.26 31.3,41.79 31.3,42.39 29.22,44.47 29.22,46.76 28.52,47.46 28.52,52.08 28.61,52.17 28.78,52.17 28.87,52.26 28.87,52.39 28.78,52.48 28.61,52.48 28.52,52.57 28.52,52.69 28.61,52.78 28.78,52.78 28.87,52.87 28.87,53 28.78,53.09 28.61,53.09 28.52,53.18 28.52,53.43 28.61,53.52 29.44,53.52 29.53,53.61 29.53,53.73 29.44,53.82 28.61,53.82 28.52,53.91 28.52,54.04 28.61,54.13 29.44,54.13 29.53,54.22 29.53,54.34 29.44,54.43 28.61,54.43 28.52,54.52 28.52,56.87 29.27,57.62 29.39,57.62 29.61,57.4 29.74,57.4 29.83,57.49 29.83,57.61 29.61,57.83 29.61,57.96 29.7,58.05 29.82,58.05 30.04,57.83 30.17,57.83 30.26,57.92 30.26,58.04 30.04,58.26 30.04,58.39 32.12,60.47 32.12,60.6 31.96,60.75 31.96,60.88 32.05,60.97 32.18,60.97 32.34,60.81 32.46,60.81 32.55,60.9 32.55,61.03 32.4,61.18 32.4,61.31 32.49,61.4 32.61,61.4 32.77,61.24 32.89,61.24 33.68,62.03 33.68,62.52 33.94,62.77 34.78,62.77 38.16,66.15 46.76,66.15 48.04,67.42 48.87,67.42 50.23,68.78 50.23,69.96 51.43,71.16 53.18,71.16 54.94,72.92 57.33,72.92 60.79,76.38 66.32,76.38 67.27,77.33 68.07,77.33 v2(68.19,77.45)
  BOTTOM w0.076: v2(68.19,77.45) 68.73,76.91 69.21,76.91 70.14,75.98 70.14,75.44 71.11,74.47 71.65,74.47 72.2,73.92 72.81,73.92 73.21,73.52 74.1,73.52 74.11,73.52 74.54,73.52 74.67,73.39 75.25,73.39 75.51,73.13
  BOTTOM w0.079: 75.51,73.13 U24.U47
M_B_A5: length 150.5
  TOP w0.076: U2.P8 35.55,85.43 35.15,85.83 34.1,85.83 33.84,86.09 33.84,86.55 v1(33.77,86.63) ; U6.P8 35.47,52.63 33.56,52.63 v1(33.25,52.94) ; R91.2 31.43,88.89 v1(31.68,88.63) ; U4.P8 35.47,72.53 33.66,72.53 v1(33.34,72.86) ; v1(35.44,39.48) 35.84,39.08 U8.P8
  IN1 w0.089: v1(33.77,86.63) 33.79,86.6 33.79,80.28 33.95,80.13 33.95,78.38 33.15,77.58 33.15,75.84 33.06,75.75 33.06,74.98 32.68,74.59 32.68,74.26 32.97,73.96 32.97,73.22 v1(33.34,72.86) 33.56,72.63 33.56,64.31 33.41,64.15 33.41,60.95 33.95,60.41 33.95,58.84 33.15,58.04 33.15,55.93 33.06,55.84 33.06,55.08 32.68,54.69 32.68,54.35 33.06,53.96 33.06,53.13 v1(33.25,52.94) 33.46,52.94 33.59,52.81 33.59,52.14 33.3,51.85 33.3,48.35 33.46,48.19 33.46,46.34 33.65,46.15 33.65,45.08 33.36,44.79 33.36,41.1 33.64,40.83 33.9,40.83 34.05,40.68 34.05,40.54 34.34,40.25 34.54,40.25 34.89,39.9 34.89,39.7 35.11,39.48 v1(35.44,39.48)
  IN3 w0.089: v1(31.68,88.63) 32.83,88.63 33.72,87.74 33.72,86.68 v1(33.77,86.63)
  IN3 w0.102: v2(66.31,77.84) 65.91,77.44 65.33,77.44 65.04,77.74 60.71,77.74 57.5,74.52 54.74,74.52 53.15,72.93 51.42,72.93 50.94,72.45 50.94,72.11 49.21,70.38 49.21,69.21 48.44,68.44 47.56,68.44 46.95,67.83 38.38,67.83 35.81,65.26 34.53,65.26 30.82,61.56 30.82,60.61 27.51,57.3 27.51,43.56 30.9,40.17 32.88,40.17 33.39,39.66 33.67,39.66 33.87,39.46 33.87,38.31 34.05,38.14 35.47,38.14 35.62,38.29 35.62,39.3 v1(35.44,39.48)
  BOTTOM w0.079: 67.24,78.59 68.29,78.59 68.82,78.06 68.82,77.81 69.21,77.42 69.42,77.42 72.41,74.43 73.02,74.43 73.3,74.71 73.61,74.71 73.81,74.51 74.19,74.51 U24.R49
  BOTTOM w0.127: 67.24,78.59 67.05,78.59 v2(66.31,77.84)
M_B_A6: length 153.3
  TOP w0.076: U4.P2 35.95,77.01 35.95,77.36 35.9,77.41 35.74,77.41 35.6,77.56 35.43,77.56 35.23,77.35 34.9,77.35 34.83,77.28 34.83,77.15 34.74,77.05 34.6,77.05 34.53,77.12 34.53,77.28 34.47,77.34 v1(33.87,77.34) ; v1(33.87,57.43) 34.69,57.43 34.73,57.39 35.19,57.39 35.37,57.57 35.65,57.57 35.87,57.35 U6.P2 ; R71.2 34.86,94.29 34.86,92.75 34.48,92.37 v1(34.15,92.37) 34.15,92.01 34.68,91.48 v1(34.68,91.47) 35.12,91.47 35.49,91.1 35.49,90.72 35.87,90.34 U2.P2 ; v1(34.66,43.48) 35.21,43.48 35.33,43.36 35.58,43.36 35.71,43.48 36.02,43.48 36.18,43.32 36.38,43.32 36.49,43.42 36.49,43.52 36.31,43.7 36.31,44.13 36.23,44.21 36.02,44.21 35.94,44.13 35.94,43.95 U8.P2
  IN1 w0.089: v1(34.68,91.47) 34.24,91.03 34.24,89.63 34.66,89.21 34.66,88.38 34.45,88.16 34.45,86.34 34.31,86.2 34.31,80.49 34.46,80.34 34.46,77.93 v1(33.87,77.34) 33.87,75.83 33.57,75.54 33.57,73.64 34.07,73.13 34.07,65.9 34.52,65.45 34.52,60.71 34.46,60.65 34.46,58.25 34.37,58.16 33.99,58.16 33.9,58.07 33.9,57.95 33.99,57.87 34.37,57.87 34.46,57.78 34.46,57.24 34.35,57.13 33.97,57.13 33.87,57.24 v1(33.87,57.43) 33.72,57.28 33.72,55.78 33.57,55.63 33.57,53.55 34.1,53.02 34.1,51.93 33.81,51.64 33.81,48.57 33.97,48.4 33.97,46.55 34.16,46.36 34.16,44.85 33.87,44.56 33.87,42.45 34.02,42.3 34.25,42.3 34.35,42.4 34.35,43.17 v1(34.66,43.48)
  IN3 w0.102: v2(68.58,76.16) 68.18,75.76 67.76,75.76 67.1,75.11 61.31,75.11 57.86,71.65 56.39,71.65 53.26,68.53 51.77,68.53 49.11,65.87 49.11,65.42 47.6,63.92 38.69,63.92 35.87,61.1 35.64,61.1 32.95,58.41 32.95,57.1 30.87,55.02 30.87,50.2 32.06,49.01 32.06,45.41 32.28,45.19 33.04,45.19 33.13,45.1 33.13,44.97 33.04,44.88 32.46,44.88 32.37,44.79 32.37,44.49 32.48,44.38 34.18,44.38 34.25,44.31 34.25,44.13 34.19,44.07 32.46,44.07 32.37,43.98 32.37,43.83 32.43,43.77 34.19,43.77 34.25,43.7 34.25,43.55 34.16,43.46 32.46,43.46 32.39,43.39 32.39,43.25 32.48,43.16 34.21,43.16 34.33,43.03 34.33,42.91 34.27,42.85 32.46,42.85 32.37,42.76 32.37,42.66 32.48,42.55 34.5,42.55 34.66,42.71 v1(34.66,43.48)
  BOTTOM w0.076: v2(68.58,76.16) 69.43,76.16 69.66,75.93 69.66,75.42 70.95,74.13 71.46,74.13 72,73.59 72.27,73.59
  BOTTOM w0.079: 72.27,73.59 72.6,73.59 73.01,73.19 74.27,73.19 U24.U49
M_B_A7: length 149.3
  TOP w0.076: U2.R8 35.01,85.43 34.63,85.05 32.04,85.05 v1(31.68,84.7) 31.56,84.57 v1(30.8,84.57) 30.67,84.57 30.06,83.96 R101.2 ; U4.R8 35.01,72.13 34.63,71.75 31.76,71.75 v1(31.53,71.52) ; v1(32.45,39.18) 32.82,39.55 33.86,39.55 33.97,39.43 34.72,39.43 U8.R8 ; v1(31.53,51.62) 31.76,51.85 34.63,51.85 35.01,52.23 U6.R8
  IN1 w0.089: v1(31.68,84.7) 31.23,84.24 31.23,81.69 32.07,80.85 32.07,78.66 31.63,78.21 31.63,76.47 31.03,75.87 31.03,72.03 v1(31.53,71.52) 31.51,71.5 31.51,63.09 31.89,62.71 31.89,60 31.63,59.73 31.63,56.57 31.03,55.97 31.03,53.34 31.54,52.83 31.54,51.63 v1(31.53,51.62) 31.45,51.54 31.44,51.54 31.44,51.53 31.44,49.64 31.76,49.32 31.76,47.73 31.81,47.68 31.81,45.35 32.09,45.07 32.09,44.92 32.01,44.83 31.9,44.83 31.81,44.75 31.81,44.63 31.9,44.54 32.01,44.54 32.09,44.46 32.09,44.33 32.01,44.25 31.9,44.25 31.81,44.16 31.81,44.04 31.9,43.96 32.01,43.96 32.09,43.87 32.09,43.75 32.01,43.66 31.9,43.66 31.81,43.58 31.81,43.46 31.9,43.37 32.01,43.37 32.09,43.29 32.09,43.09 31.2,42.2 31.2,39.46 31.48,39.18 v1(32.45,39.18)
  IN3 w0.102: v2(70.14,78.14) 69.81,78.14 69.46,78.5 60.1,78.5 57.78,76.19 54.77,76.19 53,74.41 51.28,74.41 50.61,73.73 50.61,73.27 50.1,72.76 50.1,72.35 47.14,69.39 45.47,69.39 44.67,68.59 38.06,68.59 35.5,66.03 34.18,66.03 26.74,58.59 26.74,43.19 28.64,41.3 28.64,40.42 28.86,40.19 29.34,40.19 30.13,39.4 30.84,39.4 31.07,39.18 v1(32.45,39.18)
  BOTTOM w0.076: 74.5,75.46 74.64,75.6 74.64,75.74 74.79,75.9 74.89,75.94 75.13,75.94 75.21,75.89 75.58,75.68 U24.M47
  BOTTOM w0.079: v2(70.14,78.14) 70.25,78.14 71.9,76.49 71.9,76.23 72.37,75.76 73.07,75.76 73.21,75.62 73.98,75.62 74.18,75.43 74.41,75.43 74.5,75.46
M_B_A8: length 149
  TOP w0.076: U6.R2 35.19,57.15 35.46,57.15 35.54,57.06 35.54,56.91 35.76,56.69 35.76,56.56 35.67,56.48 35.39,56.48 35.16,56.71 34.76,56.71 v1(34.68,56.63) ; U2.R2 35.07,90.23 v1(34.67,89.84) ; v1(34.33,92.95) 34.33,93.27 v1(33.76,93.84) 33.46,94.13 R70.2 ; U8.R2 35.46,43.88 35.53,43.95 35.53,44.22 35.47,44.28 v1(34.67,44.28) ; U4.R2 35.25,77.11 35.46,77.11 35.55,77.02 35.55,76.8 35.74,76.62 35.74,76.45 35.59,76.3 35.37,76.3 35.29,76.38 35.29,76.52 35.2,76.6 35.02,76.6 34.89,76.47 34.74,76.47 v1(34.67,76.54)
  IN1 w0.089: v1(34.67,44.28) 34.56,44.16 34.56,43.93 34.45,43.83 34.25,43.83 34.12,43.95 34.12,44.45 34.42,44.75 34.42,45.02 34.5,45.11 34.76,45.11 34.84,45.19 34.84,45.31 34.76,45.4 34.5,45.4 34.42,45.48 34.42,45.6 34.5,45.69 34.76,45.69 34.84,45.78 34.84,45.9 34.76,45.98 34.5,45.98 34.42,46.07 34.42,46.47 34.22,46.66 34.22,48.51 34.06,48.67 34.06,51.53 34.35,51.82 34.35,53.07 34.47,53.19 34.47,53.35 34.41,53.41 34.06,53.41 33.82,53.65 33.82,55.53 33.97,55.67 33.97,56.12 34.16,56.31 34.16,56.44 33.97,56.63 33.97,56.79 34.06,56.88 34.44,56.88 v1(34.68,56.63) 34.68,56.96 34.71,56.99 34.71,60.54 34.78,60.6 34.78,65.69 34.33,66.14 34.33,73.24 33.82,73.74 33.82,75.43 34.12,75.73 34.12,76.64 34.25,76.77 34.43,76.77 v1(34.67,76.54) 34.71,76.58 34.71,80.44 34.56,80.59 34.56,86.09 34.7,86.23 34.7,87.91 34.92,88.12 34.92,88.94 35.57,89.6 35.57,90.07 35.3,90.34 35.17,90.34 v1(34.67,89.84)
  IN3 w0.089: v1(34.33,92.95) 34.22,92.85 34.22,90.41 34.67,89.97 v1(34.67,89.84)
  IN3 w0.102: v1(34.67,44.28) 34.26,44.69 33.64,44.69 33.39,44.94 33.39,45.35 33.54,45.5 34.28,45.5 34.36,45.59 34.36,45.72 34.27,45.81 32.88,45.81 32.79,45.9 32.79,46.02 32.88,46.11 34.28,46.11 34.36,46.2 34.36,46.33 34.27,46.42 32.4,46.42 32.31,46.51 32.31,46.63 32.4,46.72 34.28,46.72 34.36,46.81 34.36,46.94 34.27,47.03 32.37,47.03 32.31,47.08 32.31,47.24 32.4,47.33 33.19,47.33 33.28,47.42 33.28,47.55 33.19,47.64 32.4,47.64 32.31,47.73 32.31,47.85 32.4,47.94 33.19,47.94 33.28,48.03 33.28,48.16 33.19,48.25 32.4,48.25 32.31,48.34 32.31,49.12 31.63,49.8 31.63,50.95 31.13,51.45 31.13,52.28 31.27,52.42 31.82,52.42 31.91,52.51 31.91,52.64 31.82,52.73 31.24,52.73 31.13,52.84 31.13,53.88 33.21,55.96 33.21,58.31 35.75,60.84 35.98,60.84 38.8,63.66 47.71,63.66 49.36,65.32 49.36,65.76 51.87,68.27 53.37,68.27 56.49,71.4 57.99,71.4 61.44,74.85 67.21,74.85 67.86,75.51 68.49,75.51 69.28,76.3 71.96,76.3 72.32,75.93 74.79,75.93 75.04,75.68 v2(76.77,75.68)
  BOTTOM w0.076: U24.M45 v2(76.77,75.68)
M_B_A9: length 154.8
  TOP w0.076: U2.R7 33.99,87.31 v1(32.83,87.31) 32.83,88.19 31.17,89.85 R90.2 ; U4.R7 34.77,72.93 34.43,73.27 34.09,73.27 33.87,73.49 31.68,73.49 v1(31.56,73.37) ; U8.R7 34.74,39.88 34.38,40.25 32.4,40.25 v1(31.89,39.74) ; v1(31.61,53.33) 32.47,53.33 32.72,53.57 33.93,53.57 34.12,53.38 34.43,53.38 34.77,53.03 U6.R7
  IN1 w0.089: v1(32.83,87.31) 32.4,86.87 32.4,85.24 32.15,84.99 32.15,82.82 31.66,82.33 31.66,81.69 32.33,81.03 32.33,78.55 31.88,78.11 31.88,76.36 31.28,75.77 31.28,73.64 v1(31.56,73.37) 31.7,73.22 31.7,71.92 31.96,71.66 31.96,71.35 31.76,71.15 31.76,69.12 32.14,68.74 32.14,59.89 31.88,59.63 31.88,56.46 31.28,55.86 31.28,53.65 v1(31.61,53.33) 31.79,53.14 31.79,51.97 31.96,51.81 31.96,51.44 31.69,51.18 31.69,49.75 32.02,49.42 32.02,47.84 32.07,47.79 32.07,45.49 32.35,45.21 32.35,42.94 31.46,42.05 31.46,41.79 31.54,41.71 31.76,41.71 31.85,41.62 31.85,41.5 31.76,41.42 31.54,41.42 31.46,41.33 31.46,41.21 31.54,41.12 31.76,41.12 31.85,41.04 31.85,40.92 31.76,40.83 31.54,40.83 31.46,40.75 31.46,40.63 31.54,40.54 31.77,40.54 31.85,40.45 31.85,40.33 31.77,40.25 31.54,40.25 31.46,40.16 31.46,39.84 31.56,39.74 v1(31.89,39.74)
  IN3 w0.102: v2(65.72,77.84) 65.57,77.99 60.6,77.99 57.4,74.79 54.11,74.79 53.22,73.9 51.49,73.9 51.22,73.62 51.22,73.11 50.68,72.57 50.68,72.21 46.56,68.08 38.27,68.08 35.71,65.52 34.39,65.52 29.34,60.46 29.34,60.34 29.67,60 29.67,59.88 29.58,59.79 29.46,59.79 29.12,60.12 29,60.12 28.91,60.03 28.91,59.91 29.24,59.57 29.24,59.44 29.15,59.35 29.03,59.35 28.69,59.69 28.57,59.69 28.48,59.6 28.48,59.47 28.81,59.14 28.81,59.01 28.72,58.92 28.6,58.92 28.26,59.26 28.13,59.26 28.04,59.17 28.04,59.04 28.38,58.71 28.38,58.58 27.25,57.45 27.25,43.4 30.92,39.74 v1(31.89,39.74)
  BOTTOM w0.079: U24.R47 75.37,74.38 75.15,74.6 75.05,74.63 74.83,74.63 74.78,74.61 74.54,74.61 74.34,74.68 73.87,74.68 73.68,74.88 73.23,74.88 72.95,74.59 72.48,74.59 69.49,77.58 69.28,77.58 68.98,77.88 68.98,78.13 68.25,78.87 67.63,78.87
  BOTTOM w0.127: 67.63,78.87 66.74,78.87 65.72,77.85 v2(65.72,77.84)
M_B_A10: length 153.9
  TOP w0.076: U4.M3 37.27,75.94 37.27,75.25 37.42,75.1 37.42,74.79 37.35,74.71 37.1,74.71 36.97,74.84 36.97,76.03 37.07,76.13 v1(37.07,76.54) ; v1(37.07,89.84) 37.47,89.44 U2.M3 ; U8.M3 37.47,41.2 37.37,41.11 37.22,41.11 36.87,41.46 v1(36.87,41.82) ; U6.M3 37.47,54.75 37.39,54.67 37.21,54.67 37.14,54.75 37.14,56 37.07,56.07 v1(37.07,56.64) ; v1(38.03,92.95) 39.06,93.98 39.14,93.98 v1(39.15,93.99) 39.14,94.01 39.14,94.06 39.25,94.17 R76.2
  IN1 w0.089: v1(37.07,89.84) 37.51,89.84 37.66,89.69 37.66,87.36 38.02,87 38.02,86.52 37.93,86.43 37.59,86.43 37.5,86.35 37.5,86.23 37.59,86.14 37.93,86.14 38.02,86.06 38.02,85.69 37.78,85.46 36.8,85.46 36.59,85.25 36.59,81.72 37.51,80.8 37.51,76.98 v1(37.07,76.54) 37.4,76.54 37.51,76.43 37.51,76.23 37.42,76.14 37.25,76.14 37.1,75.99 37.1,75.61 36.81,75.32 36.81,74.8 36.51,74.49 36.51,72.24 36.41,72.15 36.41,69.24 37.17,68.49 37.17,65.96 37.42,65.71 37.42,56.98 v1(37.07,56.64) 36.9,56.47 36.9,55.99 37.07,55.82 37.07,55.64 36.81,55.38 36.81,54.9 36.51,54.59 36.51,52.34 36.39,52.22 36.39,50.4 36.84,49.95 37.27,49.95 38.03,49.18 38.03,46.37 36.64,44.97 36.64,42.15 36.87,41.92 v1(36.87,41.82)
  IN3 w0.089: v1(37.07,89.84) 36.64,90.27 36.64,91.11 36.82,91.3 36.82,91.74 v1(38.03,92.95)
  IN3 w0.102: v2(79.06,74.92) 79.02,74.92 78.39,75.54 77.76,75.54 77.53,75.31 76.46,75.31 76.35,75.43 74.93,75.43 74.68,75.68 72.22,75.68 71.86,76.03 70.11,76.03 69.04,74.97 68.04,74.97 67.42,74.34 65.33,74.34 64.74,73.76 61.94,73.76 58.93,70.75 arc(58.84,70.69) 58.74,70.67 56.49,70.67 arc(56.49,70.67) 56.49,70.67 53.58,67.77 52.08,67.77 49.87,65.55 49.87,65.09 47.94,63.16 39.83,63.16 36.99,60.31 35.93,60.31 35.44,59.82 35.44,59.37 35.34,59.27 34.89,59.27 34.79,59.17 34.79,59.07 34.89,58.96 35.34,58.96 35.44,58.86 35.44,58.74 35.37,58.66 34.28,58.66 34.18,58.56 34.18,58.43 34.26,58.36 35.16,58.36 35.27,58.25 35.27,58.15 35.17,58.05 34.25,58.05 34.15,57.95 34.15,57.85 34.25,57.75 34.56,57.75 34.66,57.65 34.66,57.54 34.56,57.44 34.35,57.44 34.28,57.36 34.28,57.16 34.02,56.91 34.02,56.06 32.42,54.45 32.42,50.54 32.17,50.3 32.17,49.98 33.24,48.91 34.81,48.91 34.87,48.84 34.87,48.68 34.8,48.6 34,48.6 33.89,48.5 33.89,48.37 33.97,48.3 34.78,48.3 34.87,48.21 34.87,48.07 34.8,47.99 33.97,47.99 33.89,47.92 33.89,47.76 33.97,47.69 34.76,47.69 34.87,47.57 34.87,46.39 36.43,44.83 36.43,42.52 36.87,42.09 v1(36.87,41.82)
  BOTTOM w0.079: v2(79.06,74.92) 79.3,74.67 U24.P39
M_B_A11: length 155.2
  TOP w0.076: v1(30.69,57.39) 32.42,57.39 32.81,57 34.24,57 U6.T2 ; U8.T2 34.14,43.75 v1(30.52,43.75) ; U2.T2 34.15,90.23 33.46,90.92 v1(33.44,90.92) 33.01,91.35 33.01,92.91 31.53,94.38 R68.2 ; U4.T2 34.18,76.85 31.14,76.85 v1(30.69,77.29)
  IN1 w0.089: v1(30.52,43.75) 30.06,44.21 30.06,48.61 30.14,48.7 30.51,48.7 30.59,48.78 30.59,48.91 30.51,48.99 30.14,48.99 30.06,49.08 30.06,49.2 30.14,49.28 30.51,49.28 30.59,49.37 30.59,49.49 30.51,49.57 30.14,49.57 30.06,49.66 30.06,49.78 30.14,49.87 30.51,49.87 30.59,49.95 30.59,50.07 30.51,50.16 30.14,50.16 30.06,50.24 30.06,50.37 30.14,50.45 30.51,50.45 30.59,50.54 30.59,50.66 30.51,50.74 30.14,50.74 30.06,50.83 30.06,56.81 30.64,57.39 v1(30.69,57.39) 30.72,57.42 30.72,59.9 30.92,60.11 30.92,61.04 30.27,61.69 30.27,76.87 v1(30.69,77.29) 30.73,77.32 30.73,88.98 31.06,89.31 31.14,89.31 31.21,89.39 31.21,89.82 31.29,89.9 31.4,89.9 31.48,89.82 31.48,89.39 31.56,89.31 31.67,89.31 31.75,89.39 31.75,89.82 31.83,89.9 31.94,89.9 32.01,89.82 32.01,89.39 32.09,89.31 32.36,89.31 33.02,89.96 33.02,90.5 v1(33.44,90.92)
  IN3 w0.102: v1(30.52,43.75) 29.48,44.79 29.48,51.65 29.17,51.95 29.17,52.67 29.78,53.28 29.78,54.74 29.69,54.83 28.95,54.83 28.87,54.92 28.87,55.04 28.95,55.13 29.69,55.13 29.78,55.22 29.78,55.35 29.69,55.44 28.95,55.44 28.87,55.53 28.87,55.65 28.95,55.74 29.69,55.74 29.78,55.83 29.78,55.96 29.69,56.05 28.95,56.05 28.87,56.14 28.87,56.26 28.95,56.35 29.69,56.35 29.78,56.44 29.78,56.57 29.69,56.66 28.98,56.66 28.89,56.75 28.89,56.87 28.98,56.96 29.69,56.96 30.53,57.8 31.76,57.8 31.84,57.87 31.84,58.01 31.75,58.1 30.68,58.1 30.59,58.19 30.59,58.32 30.68,58.41 31.75,58.41 31.84,58.5 31.84,58.62 31.75,58.71 31.09,58.71 31,58.8 31,58.93 31.09,59.02 31.75,59.02 31.84,59.1 31.84,59.23 31.75,59.32 31.63,59.32 31.56,59.4 31.56,59.52 31.66,59.63 31.75,59.63 31.84,59.71 31.84,59.83 32.24,60.23 32.71,60.23 38.35,65.87 46.85,65.87 48.15,67.17 48.97,67.17 50.48,68.68 50.48,69.85 51.53,70.9 53.28,70.9 55.05,72.67 57.44,72.67 60.89,76.12 66.57,76.12 67.51,77.06 70.05,77.06 v2(70.32,77.33)
  BOTTOM w0.076: U24.N46 75.63,74.79 75.59,74.75 75.24,74.75 75.08,74.8 74.8,74.8 74.75,74.77 74.57,74.77
  BOTTOM w0.079: v2(70.32,77.33) 70.8,76.85 70.8,76.51 72.46,74.85 72.96,74.85 73.16,75.05 73.74,75.05 73.94,74.85 74.37,74.85 74.57,74.77
M_B_A12: length 155.4
  TOP w0.076: v1(37.23,88.12) 37.02,88.12 36.76,87.87 36.76,86.85 37.39,86.23 U2.M7 ; v1(36.82,40.42) 36.82,40.4 37.33,39.88 U8.M7 ; R72.2 35.31,94.72 35.16,94.58 35.16,93.55 v1(35.25,93.46) 35.25,93.29 v1(35.6,92.95) ; U6.M7 37.31,53.03 35.72,54.61 35.72,55.03 v1(36.13,55.43) ; U4.M7 36.2,74.2 36.03,74.2 35.7,74.54 35.7,74.9 v1(36.13,75.34)
  IN1 w0.089: v1(36.82,40.42) 36.55,40.42 36.13,40.85 36.13,45.18 36.82,45.87 36.82,49.25 35.88,50.19 35.88,52.43 36,52.55 36,54.33 35.7,54.62 35.7,55.01 v1(36.13,55.43) 36.39,55.7 36.39,57.55 36.91,58.07 36.91,65.5 36.66,65.75 36.66,68.27 35.91,69.03 35.91,72.36 36,72.45 36,74.27 35.7,74.56 35.7,74.91 v1(36.13,75.34) 36.13,75.47 36.39,75.74 36.39,76.83 37.01,77.45 37.01,80.31 36.09,81.23 36.09,85.46 36.81,86.18 36.81,87.7 v1(37.23,88.12)
  IN3 w0.089: v1(37.23,88.12) 36.89,88.47 36.89,88.78 35.32,90.36 35.32,92.14 35.6,92.42 v1(35.6,92.95)
  IN3 w0.102: v2(67.12,77.84) 67.12,77.54 66.77,77.19 65.23,77.19 64.94,77.48 60.81,77.48 57.6,74.27 54.86,74.27 53.27,72.68 51.55,72.68 51.19,72.33 51.19,72 49.46,70.27 49.46,69.1 48.55,68.19 47.66,68.19 47.05,67.58 38.48,67.58 35.92,65.01 34.63,65.01 31.08,61.45 31.08,60.51 27.76,57.19 27.76,43.72 31.05,40.44 32.98,40.44 33.4,40.02 33.82,40.02 34.28,39.56 34.28,39.13 34.45,38.95 34.86,38.95 34.93,39.02 34.93,39.56 35.34,39.97 35.85,39.97 36.31,40.42 v1(36.82,40.42)
  BOTTOM w0.079: 67.29,78.32 68.32,78.32 68.65,77.99 68.65,77.74 69.14,77.25 69.35,77.25 72.34,74.26 73.09,74.26 73.36,74.54 73.54,74.54 73.74,74.34 73.96,74.34 74.18,74.12 74.41,74.12 74.63,74.21 U24.R48
  BOTTOM w0.127: v2(67.12,77.84) 67.12,78.14 67.29,78.32
M_B_A13: length 148.2
  TOP w0.076: v1(33.34,86.09) 34,85.43 U2.T8 ; U4.T8 33.22,72.13 v1(33.08,72.27) ; U8.T8 33.61,39.08 33.54,39.15 v1(33.46,39.15) ; U6.T8 34.19,52.31 v1(33.16,52.31) ; v1(31.7,87.98) 31.63,87.92 R92.2
  IN1 w0.089: v1(33.34,86.09) 33.34,85.03 33.54,84.82 33.54,80.18 33.7,80.02 33.7,78.48 32.9,77.68 32.9,75.94 32.81,75.85 32.81,75.08 32.42,74.7 32.42,74.15 32.72,73.85 32.72,72.64 v1(33.08,72.27) 33.31,72.05 33.31,64.41 33.16,64.26 33.16,60.65 33.7,60.11 33.7,58.95 32.9,58.15 32.9,56.04 32.81,55.95 32.81,55.18 32.42,54.8 32.42,54.24 32.81,53.86 32.81,52.66 v1(33.16,52.31) 33.03,52.18 33.03,48.26 33.21,48.08 33.21,46.23 33.4,46.04 33.4,45.21 33.11,44.92 33.11,40.43 33.19,40.35 33.78,40.35 33.87,40.26 33.87,40.14 33.78,40.06 33.19,40.06 33.11,39.97 33.11,39.84 33.18,39.76 34.45,39.76 34.54,39.68 34.54,39.55 34.45,39.46 33.54,39.46 33.46,39.38 v1(33.46,39.15)
  IN3 w0.089: v1(33.34,86.09) 33.34,87.49 32.84,87.98 v1(31.7,87.98)
  IN3 w0.102: v1(33.46,39.15) 33.46,36.51 33.56,36.41 33.69,36.41 33.78,36.5 33.78,37.03 33.87,37.12 33.99,37.12 34.08,37.03 34.08,36.5 34.17,36.41 34.3,36.41 34.39,36.5 34.39,37.03 34.48,37.12 34.6,37.12 34.69,37.03 34.69,36.5 34.78,36.41 34.91,36.41 35,36.5 35,37.03 35.09,37.12 35.21,37.12 35.3,37.03 35.3,36.5 35.39,36.41 35.52,36.41 35.61,36.5 35.61,37.03 35.7,37.12 37.2,37.12 37.55,37.47 37.55,42.13 36.94,42.73 36.94,47.22 36.47,47.69 36.47,49.17 34.92,50.73 34.92,54.73 35.38,55.19 35.38,55.88 35.67,56.17 35.67,56.53 40.67,61.53 47.76,61.53 50.89,64.66 50.89,65.13 51.9,66.15 54.71,66.15 55.19,66.62 55.19,67.78 55.57,68.17 57.86,68.17 62.41,72.72 65.2,72.72 65.81,73.33 67.89,73.33 68.46,73.9 72.32,73.9 73.16,74.74 77.69,74.74 78.86,73.57 79.25,73.57 79.41,73.42 79.41,72.53 v2(79.05,72.16)
  BOTTOM w0.079: v2(79.05,72.16) 79.04,72.16 U24.Y41
M_B_ACT#: length 151.2
  TOP w0.076: U6.L3 38.59,56.23 38.67,56.15 38.67,54.74 38.75,54.66 38.97,54.66 39.05,54.74 39.05,55.74 39.13,55.82 v1(39.46,55.82) ; U4.L3 38.52,76.13 38.92,75.73 38.92,74.99 39.13,74.79 39.33,74.79 39.46,74.92 v1(39.46,75.72) ; v1(38.67,43.48) 38.67,43.48 38.28,43.08 U8.L3 ; v1(40.78,92.92) 41.55,92.92 v1(42.57,93.94) 43.11,94.49 R80.2 ; v1(39.22,88.77) 38.93,88.77 U2.L3
  IN1 w0.089: v1(39.22,88.77) 39.22,86.05 39.3,85.97 39.6,85.97 39.69,85.88 39.69,85.76 39.6,85.68 39.3,85.68 39.22,85.59 39.22,85.39 39.04,85.21 39.04,84.84 39.31,84.57 39.31,81.95 39.91,81.35 39.91,78.38 39.04,77.5 39.04,76.14 v1(39.46,75.72) 39.46,75.29 38.03,73.86 38.03,72.73 38.73,72.03 38.73,68.98 39.54,68.17 39.54,66.3 39.61,66.23 39.61,59.35 39.06,58.8 39.06,57.22 39.28,57.01 39.69,57.01 39.86,56.84 39.86,56.22 v1(39.46,55.82) 39.46,55.39 38.03,53.96 38.03,52.83 39.56,51.3 39.56,45.22 39.05,44.72 38.54,44.72 38.24,44.42 38.24,43.59 38.36,43.48 38.67,43.48 v1(38.67,43.48)
  IN3 w0.089: v1(39.22,88.77) 39.45,88.77 39.94,89.27 39.94,92.09 40.7,92.85
  IN3 w0.102: v2(77.02,72.25) 76.69,72.25 76.61,72.34 76.61,72.66 76.53,72.74 76.37,72.74 76.3,72.67 76.3,72.34 76.21,72.25 76.09,72.25 76,72.34 76,72.92 75.91,73.01 75.78,73.01 75.69,72.92 75.69,72.34 75.6,72.25 75.48,72.25 75.39,72.34 75.39,72.96 75.3,73.05 75.17,73.05 75.08,72.96 75.08,72.34 74.99,72.25 74.87,72.25 74.78,72.34 74.78,72.96 74.69,73.05 74.56,73.05 74.47,72.96 74.47,72.34 74.38,72.25 74.28,72.25 74.18,72.35 74.18,72.88 74.01,73.05 73.11,73.05 72.83,72.77 72.83,72.21 72.75,72.12 72.59,72.12 72.53,72.18 72.53,72.55 72.45,72.63 72.31,72.63 72.22,72.54 72.22,72.2 72.15,72.12 71.98,72.12 71.92,72.18 71.92,72.53 71.82,72.63 71.69,72.63 71.61,72.55 71.61,72.24 71.52,72.16 71.4,72.16 71.31,72.24 71.31,72.54 71.22,72.63 71.09,72.63 71,72.54 71,72.24 70.92,72.16 70.79,72.16 70.7,72.24 70.7,72.54 70.61,72.63 70.48,72.63 70.39,72.54 70.39,72.24 70.31,72.16 70.18,72.16 70.09,72.24 70.09,72.56 70.02,72.63 69.1,72.63 68.53,72.06 66.42,72.06 65.77,71.41 62.94,71.41 57.49,65.96 57.49,65.48 56.25,64.24 53.8,64.24 53.64,64.07 52.1,64.07 49.11,61.08 49.11,59.78 48.97,59.64 41.14,59.64 39.59,58.09 39.17,58.09 38.63,57.55 38.63,57.29 38.77,57.15 38.77,56.98 38.63,56.84 38.63,56.68 38.77,56.54 38.77,56.37 38.63,56.23 38.63,56.07 38.44,55.88 38.44,55.18 38.52,55.1 39.13,55.1 39.23,55 39.23,54.9 39.13,54.8 38.52,54.8 38.42,54.7 38.42,54.6 38.52,54.49 39.23,54.49 39.29,54.43 39.29,54.25 39.23,54.19 38.31,54.19 38.21,54.09 38.21,53.98 38.31,53.88 38.73,53.88 38.81,53.81 38.81,53.68 38.71,53.58 38.29,53.58 38.21,53.5 38.21,53.37 38.31,53.28 38.73,53.28 38.81,53.2 38.81,53.07 38.71,52.97 38.29,52.97 38.21,52.89 38.21,52.76 38.31,52.67 38.73,52.67 38.81,52.59 38.81,52.46 38.71,52.36 38.32,52.36 38.21,52.26 38.21,43.26 38.4,43.08 38.58,43.08 38.67,43.17 v1(38.67,43.48) ; v1(40.78,92.92) 40.7,92.85
  BOTTOM w0.076: v2(77.02,72.25) 77.02,72.79 77.66,73.43 77.66,74.79 77.4,75.04 77.33,75.04 77.05,75.32 75.35,75.32 74.99,75.68 U24.M48
