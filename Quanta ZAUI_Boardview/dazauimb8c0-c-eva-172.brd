# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OC3#: length 15.2
  TOP w0.102: v2(77.63,44.51) 77.61,44.49 77.46,44.49 77.04,44.07 76.63,44.07 76.26,44.44 75.75,44.44 74.1,42.79 73.47,42.79 71.08,40.4 68.41,40.4 67.88,39.86 TP32.1 66.38,39.86 65.87,39.36 R272.2
  BOTTOM w0.114: v2(77.63,44.51) 77.61,44.49 77.61,44.43 77.35,44.17 U24.CT43
USB_VBUSSENSE: length 1.2
  TOP w0.102: v2(92.34,36.38) 92.39,36.44 R287.2
  BOTTOM w0.079: U24.DL11 92.67,36.72 v2(92.34,36.38)
USBON#: length 226.8
  TOP w0.102: U13.99 196.45,28.62 196.89,28.18 196.89,26.99 196.72,26.82 196.16,26.82 194.98,25.64 194.98,24.14 194.73,23.89 194.73,23.56 196.38,21.91 196.38,20.6 196.68,20.3 v2(196.94,20.3)
  IN1 w0.089: v2(196.94,20.3) 196.94,20.57 197.32,20.95 199.2,20.95 200.72,22.47 203.13,22.47 203.36,22.24 203.36,21.61 203.6,21.36 v2(203.6,20.09)
  IN2 w0.089: v1(25.01,45.12) 24.4,44.51 24.4,36.47 27.22,33.66 27.39,33.66 31.55,29.51 34.42,29.51 35.88,28.05 39.41,28.05 42.13,25.32 45.79,25.32 46.33,24.79 46.33,24.6 48.06,22.87 48.06,21.62 48.99,20.69 50.2,20.69 51.38,21.87 52.97,21.87 54.18,20.66 57.67,20.66 58.14,20.19 60.65,20.19 64.58,16.27 70.45,16.27 70.65,16.47 73.19,16.47 73.81,17.09 80.18,17.09 84.3,21.22 88.53,21.22 90.64,19.11 91.53,19.11 92.49,18.15 104.05,18.15 104.66,18.76 111.47,18.76 112.23,19.52 116.06,19.52 116.34,19.8 116.34,20.44 116.64,20.74 119.88,20.74 120.94,21.8 126.13,21.8 126.43,21.5 133.69,21.5 133.75,21.44 138.57,21.44 139.48,20.52 154.99,20.52 155.17,20.7 162.7,20.7 163.04,20.36 167.99,20.36 168.17,20.54 170.14,20.54 170.49,20.88 172.99,20.88 173.1,21 177.22,21 177.42,21.2 178.99,21.2 179.31,20.88 180.74,20.88 181.14,21.27 182.34,21.27 183.18,20.43 190.57,20.43 191.38,19.62 193.16,19.62 193.67,20.13 196.76,20.13 v2(196.94,20.3)
  BOTTOM w0.102: v2(203.6,20.09) 203.6,20.06 203.63,20.04 203.63,20.01 203.84,19.81 203.98,19.81 204.5,20.32 U35.4 ; U28.4 v1(23,45.13) 25,45.13 v1(25.01,45.12)
USBP1+: length 151.3
  TOP w0.102: R252.1 21.3,45.1 21.11,44.91 21.11,42.95 20.34,42.19 19.53,42.19 18.23,43.48 17.6,43.48 17.12,43.97 16.61,43.97 16.44,43.8 v1(16.44,43.78)
  IN3 w0.089: v2(95.01,35.8) 94.83,35.97 94.5,35.97 94.14,36.33 93.84,36.33 93.48,36.69 93.48,37.81 93.2,38.09 89.38,38.09 89.22,37.93 89.22,35.97 89.14,35.89 89.14,33.62 88.41,32.89 88.41,31.21 87.82,30.62 83.68,30.62 82.54,29.48 82.54,27.11 81.42,26 81.42,25.43 78.2,22.21 75.75,22.21 74.03,20.48 68.85,20.48 68.08,19.71 55.14,19.71 53.2,17.77 49.52,17.77 48.02,16.26 48.02,13.92 45.81,11.71 45.39,11.71 45.01,11.33 41.5,11.33 37.78,7.61 35.65,7.61 34.99,6.95 27.16,6.95 26.99,6.77 24.42,6.77 24.24,6.95 22.63,6.95 19.54,10.04 19.54,15.14 17.24,17.45 17.24,22.5 18.22,23.48 18.22,25.28 19.42,26.47 19.42,31.19 20.68,32.45 21.92,32.45 23.24,33.77 23.9,33.77 24.42,34.28 24.42,35.18 23.81,35.79 23.81,36.28 23.58,36.51 21.7,36.51 20.13,38.09 20.13,39.74 19.87,39.99 18.81,39.99 18.32,40.47 18.32,42.7 17.03,43.99 16.66,43.99 v1(16.44,43.78)
  BOTTOM w0.102: v2(95.01,35.8) 94.91,35.8 U24.DP8
USBP1+_C: length 2.9
  TOP w0.102: R217.1 20.66,52.06 20.59,52.13 20.38,52.13 20.22,51.97 20.22,50.91 20.38,50.75 U7.10
USBP1+_C_R: length 10.8
  TOP w0.102: R252.2 v2(21.52,44.18) ; R218.1 v2(22.03,51.55)
  IN1 w0.089: v2(22.03,51.55) 22.03,52.05 21.94,52.14 21.52,52.14 21.35,51.97 21.35,45.41 20.89,44.95 20.89,44.31 21.02,44.18 v2(21.52,44.18)
USBP1+_C_R_N: length 18.6
  TOP w0.102: R218.2 21.12,51.91 21.22,52.01 22.15,52.01 22.36,51.8 23.36,51.8 v1(23.66,51.5) ; v2(20.25,55.59) 20.08,55.77 18.63,55.77 17.84,56.56 17.1,56.56 U5.7 16.94,56.56 16.43,56.56 15.77,55.9 15.77,54.76 15.3,54.29 14.74,54.29 14.6,54.15 CN5.3
  BOTTOM w0.102: v1(23.66,51.5) 23.36,51.8 23.15,51.8 22.93,52.02 22.93,52.88 22.83,52.98 22.83,55.04 22.1,55.78 20.45,55.78 v2(20.25,55.59)
USBP1+_U14: length 2.6
  TOP w0.102: R247.2 21.16,45.55 20.98,45.73 20.98,46.04 20.8,46.21 20.31,46.21 20.22,46.3 20.22,46.43 20.38,46.59 U7.3
USBP1-: length 151.3
  TOP w0.102: R246.1 20.73,45.1 20.89,44.94 20.89,43.04 20.25,42.4 19.62,42.4 18.32,43.7 17.69,43.7 17.21,44.18 16.7,44.18 v1(16.44,44.44)
  IN3 w0.089: v1(16.44,44.44) 16.69,44.2 17.12,44.2 18.53,42.79 18.53,40.56 18.89,40.19 19.96,40.19 20.33,39.82 20.33,38.17 21.79,36.71 23.67,36.71 24.01,36.37 24.01,35.88 24.62,35.27 24.62,34.2 23.99,33.57 23.33,33.57 22.01,32.24 20.76,32.24 19.62,31.1 19.62,26.39 18.43,25.19 18.43,23.4 17.44,22.41 17.44,17.53 19.75,15.23 19.75,10.12 22.72,7.15 24.33,7.15 24.5,6.97 26.9,6.97 27.08,7.15 34.9,7.15 35.56,7.81 37.7,7.81 41.42,11.53 44.92,11.53 45.3,11.91 45.72,11.91 47.81,14 47.81,16.34 49.44,17.97 53.11,17.97 55.06,19.91 68,19.91 68.77,20.69 73.94,20.69 75.67,22.41 78.12,22.41 81.21,25.51 81.21,26.08 82.33,27.2 82.33,29.56 83.59,30.82 87.74,30.82 88.21,31.29 88.21,32.97 88.94,33.7 88.94,35.98 89.01,36.05 89.01,38.01 89.29,38.29 93.29,38.29 93.69,37.89 93.69,36.78 93.93,36.54 94.22,36.54 94.58,36.18 94.85,36.18 95.01,36.33 v2(95.01,36.44)
  BOTTOM w0.102: U24.DN8 94.64,36.07 v2(95.01,36.44)
USBP1-_C: length 2.9
  TOP w0.102: U7.11 19.88,50.79 20,50.91 20,52.06 20.29,52.35 20.41,52.35 20.66,52.6 R210.1
USBP1-_C_R: length 10.8
  TOP w0.102: v2(22.03,52.82) 21.91,52.69 R211.1 ; R251.2 v2(20.25,44.18)
  IN1 w0.089: v2(22.03,52.82) 22.03,52.49 21.89,52.34 21.43,52.34 21.14,52.06 21.14,45.49 20.69,45.04 20.69,44.33 20.53,44.18 v2(20.25,44.18)
USBP1-_C_R_N: length 18.6
  TOP w0.102: CN5.2 14.6,54.74 14.83,54.51 15.21,54.51 15.56,54.85 15.56,55.99 16.34,56.78 17.93,56.78 18.72,55.98 18.82,55.98 U5.4 19.02,55.98 20.07,55.98 v2(20.25,56.17) ; R211.2 21.12,52.33 21.22,52.23 22.24,52.23 22.45,52.02 23.41,52.02 v1(23.66,52.26)
  BOTTOM w0.102: v2(20.25,56.17) 20.43,55.99 22.19,55.99 23.05,55.13 23.05,53.07 23.15,52.97 23.15,52.11 23.24,52.02 23.41,52.02 v1(23.66,52.26)
USBP1-_U14: length 2.6
  TOP w0.102: U7.2 19.88,46.59 20,46.47 20,46.21 20.22,46 20.71,46 20.76,45.95 20.76,45.66 20.66,45.55 R246.2
USBP2+: length 135.8
  TOP w0.102: v1(23.41,34.77) 23.27,34.91 23.18,34.91 22.9,34.63 22.54,34.63 22.42,34.51 R298.2
  IN3 w0.089: v1(23.41,34.77) 23.41,34.81 23.07,35.14 22.85,35.14 20.72,33.01 19.62,33.01 18.97,32.35 18.97,26.58 17.82,25.43 17.82,23.66 16.85,22.69 16.85,16.98 19.06,14.77 19.06,11.03 17.28,9.25 17.28,6.34 16.75,5.8 16.75,4.54 18.38,2.91 26.44,2.91 29.44,5.9 32.79,5.9 33.37,5.32 37.1,5.32 38.01,6.23 38.21,6.23 42.32,10.34 45.42,10.34 45.8,10.72 46.22,10.72 51.92,16.42 55.56,16.42 56.45,15.53 68.44,15.53 68.54,15.63 73.37,15.63 75.14,17.41 79.84,17.41 84.64,22.21 85.84,22.21 87.49,23.86 87.49,25.49 89.6,27.6 89.6,28.15 90.79,29.35 90.79,31.64 91.93,32.79 91.93,34.55 91.73,34.75 91.73,37.2 92.13,37.59 v2(92.13,37.69)
  BOTTOM w0.102: U24.DJ11 92.45,38.02 v2(92.13,37.69)
USBP2+_C: length 9.3
  TOP w0.102: R298.1 21.22,34.57 20.44,34.57 19.92,35.09 19.33,35.09 18.58,35.85 17.84,35.85 U11.7 17.72,35.85 17.43,35.85 15.92,34.33 14.7,34.33 14.6,34.23 CN7.3
USBP2-: length 135.8
  TOP w0.102: R293.2 22.42,34.98 22.55,34.85 22.81,34.85 23.09,35.13 23.14,35.13 23.38,35.37 v1(23.38,35.42)
  IN3 w0.089: v2(92.13,37.04) 91.93,36.85 91.93,34.83 92.14,34.63 92.14,32.7 90.99,31.56 90.99,29.26 89.8,28.07 89.8,27.51 87.69,25.4 87.69,23.78 85.92,22.01 84.72,22.01 79.92,17.21 75.23,17.21 73.45,15.43 68.62,15.43 68.52,15.33 56.37,15.33 55.48,16.22 52,16.22 46.3,10.51 45.88,10.51 45.5,10.14 42.4,10.14 38.29,6.03 38.09,6.03 37.18,5.12 33.29,5.12 32.7,5.7 29.53,5.7 26.53,2.7 18.3,2.7 16.55,4.46 16.55,5.89 17.08,6.42 17.08,9.33 18.86,11.11 18.86,14.68 16.64,16.9 16.64,22.77 17.61,23.74 17.61,25.51 18.76,26.66 18.76,32.44 19.54,33.21 20.64,33.21 22.77,35.34 23.31,35.34 v1(23.38,35.42)
  BOTTOM w0.102: v2(92.13,37.04) 92.45,37.37 U24.DK11
USBP2-_C: length 9.3
  TOP w0.102: R293.1 21.26,34.78 20.53,34.78 20.01,35.31 19.76,35.31 U11.4 19.6,35.31 19.42,35.31 18.67,36.06 17.34,36.06 15.83,34.55 14.7,34.55 14.6,34.65 CN7.2
USBP3+_TPC: length 110.9
  TOP w0.102: v1(17.97,5.45) 18.2,5.22 18.2,4.99 18.43,4.76 19.09,4.76 19.98,5.65 19.98,10.04 18.12,11.9 16.01,11.9 15.84,12.08 14.78,12.08 14.51,12.34 12.42,12.34 11.66,11.58 11.21,11.58 R486.2
  IN3 w0.089: v1(17.97,5.45) 18.02,5.5 18.02,5.99 18.88,6.84 20.74,6.84 22.19,5.4 27.95,5.4 29.09,6.54 33.08,6.54 33.69,5.93 36.63,5.93 37.72,7.02 38.15,7.02 42.07,10.94 45.17,10.94 45.55,11.31 45.97,11.31 51.69,17.03 56.25,17.03 56.69,16.6 57.14,16.6 57.52,16.22 60.86,16.22 60.99,16.34 73.09,16.34 74.75,18.01 79.42,18.01 86.8,25.39 86.8,26.59 87.58,27.37 87.81,27.37 89.9,29.46 89.9,31.82 91.32,33.24 91.32,34.28 91.11,34.49 91.02,34.49 90.67,34.84 90.67,35.28 90.96,35.57 91.17,35.57 v2(91.33,35.73)
  BOTTOM w0.102: v2(91.33,35.73) 91.67,36.07 U24.DN13
USBP3-_TPC: length 110.9
  TOP w0.102: R489.2 10.99,11.3 11.06,11.37 11.75,11.37 12.51,12.13 14.42,12.13 14.69,11.86 15.75,11.86 15.92,11.68 18.03,11.68 19.76,9.95 19.76,5.74 19,4.98 18.52,4.98 18.41,5.08 18.41,5.51 18.46,5.56 v1(18.69,5.56)
  IN3 w0.089: v1(18.69,5.56) 18.44,5.56 18.22,5.78 18.22,5.9 18.96,6.64 20.65,6.64 22.1,5.19 28.04,5.19 29.18,6.34 33,6.34 33.61,5.73 36.71,5.73 37.81,6.82 38.24,6.82 42.15,10.73 45.26,10.73 45.64,11.11 46.05,11.11 51.77,16.83 56.17,16.83 56.6,16.39 57.05,16.39 57.43,16.01 60.95,16.01 61.07,16.14 73.17,16.14 74.84,17.8 79.51,17.8 87.01,25.3 87.01,26.5 87.67,27.16 87.9,27.16 90.1,29.37 90.1,31.74 91.53,33.16 91.53,34.36 91.19,34.69 91.11,34.69 90.87,34.93 90.87,35.2 91.04,35.37 91.22,35.37 91.33,35.26 v2(91.33,35.05)
  BOTTOM w0.102: U24.DP13 91.55,35.42 91.33,35.2 v2(91.33,35.05)
USBP4+_DB: length 169.5
  IN3 w0.089: v2(93.05,37.71) 92.9,37.55 92.69,37.55 92.5,37.37 92.5,36.78 93.03,36.26 93.03,34.02 93.64,33.41 94.93,33.41 97.95,30.39 100.36,30.39 104.73,26.02 104.73,22 109.7,17.04 109.7,16.21 110.65,15.25 112.71,15.25 113.09,14.87 117.2,14.87 117.9,14.17 181.71,14.17 184,11.88 184,11.77 185.53,10.24 204.72,10.24 205.57,11.09 207.76,11.09 209.15,12.48 211.09,12.48 211.98,13.37 212.79,13.37 213.27,13.85 213.27,18.12 212.86,18.53 212.86,24.8 213.29,25.23 213.29,34.38 211.16,36.51 211.16,40.07 211.44,40.35 212.15,40.35 v1(212.36,40.14)
  BOTTOM w0.102: U24.DJ10 93.29,37.69 93.06,37.69 v2(93.05,37.71) ; v1(212.36,40.14) 212.61,40.4 CN6.16
USBP4-_DB: length 169.4
  IN3 w0.089: v2(93.08,37.06) 93.08,37.2 92.93,37.35 92.77,37.35 92.71,37.28 92.71,36.87 93.23,36.34 93.23,34.11 93.72,33.62 95.02,33.62 98.04,30.59 100.44,30.59 104.93,26.1 104.93,22.09 109.9,17.12 109.9,16.29 110.74,15.45 112.8,15.45 113.18,15.07 117.28,15.07 117.99,14.37 181.8,14.37 184.2,11.96 184.2,11.85 185.62,10.44 204.63,10.44 205.48,11.29 207.67,11.29 209.07,12.69 211.01,12.69 211.9,13.58 212.7,13.58 213.07,13.94 213.07,18.04 212.66,18.44 212.66,24.89 213.09,25.32 213.09,34.29 210.96,36.43 210.96,40.15 211.36,40.55 212.25,40.55 212.37,40.67 v1(212.37,40.79)
  BOTTOM w0.102: CN6.15 212.86,40.9 212.65,40.7 212.47,40.7 v1(212.37,40.79) ; v2(93.08,37.06) 93.03,37.11 93.03,37.27 93.08,37.32 93.19,37.32 93.37,37.5 93.48,37.5 U24.DK10
USBP5+_CAM: length 125.4
  IN1 w0.089: v2(99.05,36.09) 98.8,36.34 98.8,36.43 97.02,38.21 94.71,38.21 92.42,40.5 91.71,40.5 91.5,40.7 91.5,41.39 89.55,43.34 89.55,49.64 90.13,50.23 90.13,53.66 91.07,54.6 91.07,60.51 90.74,60.84 90.74,67.8 89.88,68.67 89.88,72.89 89.72,73.04 89.72,75.44 89.93,75.64 89.93,77.1 89.85,77.18 89.85,81.39 89.75,81.49 89.75,81.8 88.89,82.66 88.89,83.92 88.48,84.32 88.48,84.98 87.34,86.13 87.34,88.12 87.84,88.63 87.84,93.77 86.02,95.6 86.02,97.23 85.63,97.61 85.63,98.67 82.24,102.07 79,102.07 78.79,101.87 69.42,101.87 68.99,101.43 66.69,101.43 65.76,102.36 65.76,103.41 65.35,103.82 63.14,103.82 62.45,104.51 61.36,104.51 60.11,105.76 58.44,105.76 56.27,107.93 51.08,107.93 48.54,105.4 47.93,105.4 47.31,104.77 47.31,103.75 47.99,103.06 47.99,101.95 47.88,101.84 47.66,101.84 v1(47.56,101.94)
  BOTTOM w0.079: U24.DL3 96.62,36.68 96.56,36.61 96.56,36.47 96.64,36.38 96.81,36.38 96.95,36.46 97.17,36.46 97.35,36.4 97.5,36.4 97.62,36.47 97.85,36.47 97.93,36.43 98.27,36.43 98.28,36.44 98.6,36.44 98.94,36.09 v2(99.05,36.09)
  BOTTOM w0.102: R522.2 46.97,103.23 46.85,103.11 46.85,102.8 47.08,102.58 47.08,101.94 47.23,101.79 47.41,101.79 v1(47.56,101.94)
USBP5+_CAM_C: length 3.5
  BOTTOM w0.102: CN2.8 47.35,106.53 47.21,106.39 47.21,105.93 46.79,105.51 46.79,104.4 R522.1
USBP5-_CAM: length 125.4
  IN1 w0.089: v2(98.45,36.08) 98.6,36.23 98.6,36.35 96.94,38.01 94.63,38.01 92.34,40.3 91.62,40.3 91.3,40.62 91.3,41.3 89.34,43.26 89.34,49.73 89.93,50.31 89.93,53.74 90.87,54.68 90.87,60.43 90.54,60.76 90.54,67.72 89.67,68.58 89.67,72.81 89.52,72.96 89.52,75.53 89.72,75.73 89.72,77.02 89.65,77.09 89.65,81.31 89.55,81.41 89.55,81.72 88.68,82.58 88.68,83.83 88.28,84.24 88.28,84.9 87.13,86.04 87.13,88.21 87.64,88.72 87.64,93.69 85.82,95.51 85.82,97.14 85.43,97.53 85.43,98.59 82.15,101.87 79.08,101.87 78.88,101.66 69.51,101.66 69.07,101.23 66.6,101.23 65.56,102.28 65.56,103.33 65.26,103.62 63.05,103.62 62.37,104.3 61.28,104.3 60.03,105.55 58.36,105.55 56.19,107.73 51.16,107.73 48.63,105.19 48.02,105.19 47.51,104.68 47.51,103.83 48.19,103.14 48.19,101.87 47.97,101.64 47.84,101.64 47.56,101.36 v1(47.56,101.31)
  BOTTOM w0.079: U24.DL5 96.32,36.68 96.39,36.61 96.39,36.4 96.57,36.21 96.86,36.21 97,36.29 97,36.29 97.14,36.29 97.32,36.23 97.55,36.23 97.66,36.3 97.67,36.31 97.8,36.31 97.88,36.26 98.27,36.26 v2(98.45,36.08)
  BOTTOM w0.102: v1(47.56,101.31) 47.29,101.57 47.14,101.57 46.86,101.85 46.86,102.49 46.63,102.72 46.63,103.1 46.5,103.23 R521.2
USBP5-_CAM_C: length 3.5
  BOTTOM w0.102: CN2.7 46.85,106.53 46.99,106.39 46.99,106.02 46.57,105.6 46.57,104.41 R521.1
USBP6+_CR: length 169.2
  IN3 w0.089: v1(211.85,38.64) 211.85,38.87 211.95,38.98 213.16,38.98 213.8,38.33 213.8,25.01 213.32,24.53 213.32,20.27 215.12,18.47 215.12,16.78 214.29,15.94 214.29,13.84 212.5,12.05 209.45,12.05 208.05,10.65 206.06,10.65 205.24,9.84 185.37,9.84 183.61,11.6 183.61,11.71 181.55,13.77 117.67,13.77 117,14.44 110.71,14.44 108.24,16.91 108.24,17.93 104.34,21.83 104.34,25.84 100.63,29.55 96.79,29.55 94.35,31.99 94.35,32.32 93.9,32.76 93.72,32.76 92.82,33.67 92.82,35.14 92.33,35.63 v2(92.33,35.76)
  BOTTOM w0.102: v1(211.85,38.64) 211.85,38.77 212.06,38.99 212.65,38.99 212.74,38.9 CN6.19 ; v2(92.33,35.76) 92.58,35.76 92.69,35.87 U24.DN11
USBP6-_CR: length 169.3
  IN3 w0.089: v1(211.85,39.37) 212.04,39.18 213.24,39.18 214.01,38.42 214.01,24.93 213.52,24.45 213.52,20.36 215.33,18.55 215.33,16.69 214.49,15.85 214.49,13.75 212.58,11.85 209.54,11.85 208.14,10.45 206.14,10.45 205.33,9.64 185.28,9.64 183.41,11.52 183.41,11.63 181.46,13.57 117.59,13.57 116.92,14.24 110.63,14.24 108.04,16.83 108.04,17.84 104.13,21.75 104.13,25.76 100.54,29.35 96.7,29.35 94.14,31.91 94.14,32.24 93.82,32.56 93.64,32.56 92.62,33.58 92.62,35.06 92.56,35.12 92.35,35.12 v2(92.33,35.1)
  BOTTOM w0.102: U24.DP11 92.69,35.39 92.4,35.1 v2(92.33,35.1) ; v1(211.85,39.37) 212.01,39.2 212.56,39.2 212.75,39.4 CN6.18
USBP7+_FP: length 77.7
  IN3 w0.089: v2(58.13,17.87) 57.99,17.73 57.99,17.02 58.18,16.83 60.61,16.83 60.73,16.95 61.49,16.95 61.58,17.04 61.58,17.33 61.79,17.54 62.22,17.54 62.43,17.33 62.43,17.04 62.52,16.95 62.78,16.95 62.87,17.04 62.87,17.33 63.08,17.54 63.52,17.54 63.72,17.33 63.72,17.04 63.81,16.95 64.08,16.95 64.17,17.04 64.17,17.33 64.38,17.54 64.81,17.54 65.02,17.33 65.02,17.04 65.11,16.95 65.38,16.95 65.46,17.04 65.46,17.33 65.67,17.54 66.11,17.54 66.32,17.33 66.32,17.04 66.4,16.95 66.67,16.95 66.76,17.04 66.76,17.33 66.97,17.54 67.4,17.54 67.61,17.33 67.61,17.04 67.7,16.95 70.44,16.95 70.53,17.04 70.53,17.23 70.74,17.44 71.17,17.44 71.38,17.23 71.38,17.04 71.47,16.95 72.62,16.95 74.27,18.6 79.01,18.6 82.15,21.75 82.15,21.88 81.84,22.19 81.84,22.48 82.15,22.79 82.44,22.79 82.76,22.48 82.88,22.48 83.07,22.67 83.07,22.79 82.76,23.11 82.76,23.4 83.07,23.71 83.36,23.71 83.67,23.4 83.86,23.4 84.23,23.76 84.23,23.89 83.26,24.85 83.26,25.15 83.57,25.46 83.87,25.46 84.83,24.49 84.96,24.49 85.61,25.14 85.61,27.43 86.01,27.83 86.01,27.95 85.49,28.47 85.49,28.77 85.79,29.08 86.09,29.08 86.61,28.55 86.74,28.55 86.93,28.74 86.93,28.87 86.4,29.39 86.4,29.68 86.71,29.99 87,29.99 87.75,29.25 88,29.25 88.1,29.35 88.1,30.31 88.8,31.02 88.8,32.6 89.41,33.2 89.7,33.2 89.97,32.93 90.1,32.93 90.29,33.12 90.29,33.25 90.01,33.52 90.01,35.47 90.76,36.22 90.76,37.28 90.96,37.48 91.12,37.48 v2(91.34,37.69)
  BOTTOM w0.102: U24.DJ13 91.67,38.02 v2(91.34,37.69) ; v2(58.13,17.87) 58.02,17.97 58.02,18.43 58.25,18.66 61.02,18.66 61.28,18.91 61.28,21.83 59.31,23.8 58.72,23.8 57.98,23.06 57.98,22.99 EC6.2 57.95,22.08 57.95,21.65 57.45,21.15 CN13.7
USBP7-_FP: length 77.7
  IN3 w0.089: v2(57.48,17.87) 57.62,17.87 57.79,17.7 57.79,16.93 58.1,16.62 60.69,16.62 60.82,16.75 61.57,16.75 61.78,16.96 61.78,17.25 61.87,17.33 62.14,17.33 62.23,17.25 62.23,16.96 62.43,16.75 62.87,16.75 63.08,16.96 63.08,17.25 63.17,17.33 63.43,17.33 63.52,17.25 63.52,16.96 63.73,16.75 64.16,16.75 64.37,16.96 64.37,17.25 64.46,17.33 64.73,17.33 64.82,17.25 64.82,16.96 65.02,16.75 65.46,16.75 65.67,16.96 65.67,17.25 65.76,17.33 66.02,17.33 66.11,17.25 66.11,16.96 66.32,16.75 66.76,16.75 66.96,16.96 66.96,17.25 67.05,17.33 67.32,17.33 67.41,17.25 67.41,16.96 67.62,16.75 70.53,16.75 70.73,16.96 70.73,17.14 70.82,17.23 71.09,17.23 71.18,17.14 71.18,16.96 71.39,16.75 72.71,16.75 74.36,18.4 79.09,18.4 82.36,21.67 82.36,21.96 82.05,22.27 82.05,22.4 82.23,22.59 82.36,22.59 82.67,22.28 82.96,22.28 83.27,22.58 83.27,22.88 82.96,23.19 82.96,23.31 83.15,23.5 83.28,23.5 83.59,23.19 83.95,23.19 84.43,23.68 84.43,23.97 83.47,24.94 83.47,25.06 83.66,25.25 83.78,25.25 84.75,24.29 85.04,24.29 85.81,25.06 85.81,27.34 86.21,27.74 86.21,28.04 85.69,28.56 85.69,28.68 85.88,28.87 86,28.87 86.53,28.35 86.82,28.35 87.13,28.66 87.13,28.95 86.61,29.48 86.61,29.6 86.8,29.79 86.92,29.79 87.67,29.04 88.08,29.04 88.3,29.26 88.3,30.23 89.01,30.93 89.01,32.52 89.49,33 89.62,33 89.89,32.73 90.18,32.73 90.49,33.04 90.49,33.33 90.22,33.6 90.22,35.39 90.96,36.13 90.96,37.19 91.04,37.27 91.15,37.27 v2(91.34,37.08)
  BOTTOM w0.102: U24.DK13 91.65,37.37 91.37,37.08 v2(91.34,37.08) ; v2(57.48,17.87) 57.54,17.87 57.81,18.13 57.81,18.52 58.16,18.87 60.93,18.87 61.06,19 61.06,21.74 59.22,23.58 58.81,23.58 58.2,22.97 58.2,22.91 EC7.1 58.16,22.09 58.16,21.56 57.67,21.06 57.67,20.77 57.76,20.67 57.83,20.67 57.95,20.56 CN13.6
USBP8+_TS: length 127.3
  IN1 w0.089: v2(43.75,100.9) 43.93,101.08 44.13,101.08 44.84,101.78 44.84,102.42 45.05,102.63 46.61,102.63 46.85,102.39 46.85,100.9 47.13,100.62 48.12,100.62 48.8,101.31 48.8,101.9 48.92,102.02 49.36,102.02 49.53,101.84 50.03,101.84 51.5,103.31 51.5,106.08 51.98,106.56 53.32,106.56 55.31,104.58 57.72,104.58 57.88,104.41 59.47,104.41 60.82,103.06 60.82,102.52 61.83,101.51 61.83,100.74 62.61,99.96 66.91,99.96 66.99,100.04 82.08,100.04 84.97,97.14 84.97,95.49 87.01,93.46 87.01,89.29 86.5,88.78 86.5,85.81 87.62,84.7 87.62,83.98 88.07,83.52 88.07,82.1 88.96,81.21 88.96,77.49 88.63,77.16 88.63,75.7 88.83,75.49 88.83,72.63 88.99,72.48 88.99,67.54 89.37,67.16 89.37,59.98 89.67,59.68 89.67,55.09 88.5,53.92 88.5,50.39 88.33,50.21 88.33,42.75 90.36,40.72 90.36,39.31 90.69,38.98 92.52,38.98 93.46,38.04 93.46,36.73 93.83,36.36 94.08,36.36 94.42,36.02 94.42,35.3 94.68,35.05 v2(94.68,34.71)
  BOTTOM w0.079: U24.DP6 94.93,35.42 94.68,35.17 v2(94.68,34.71)
  BOTTOM w0.102: v2(43.75,100.9) 43.93,101.08 44.13,101.08 44.49,101.43 44.49,102.04 44.64,102.2 44.64,102.91 44.96,103.23 R520.2
USBP8-_TS: length 127.3
  IN1 w0.089: v2(95.16,35.04) 94.98,35.04 94.63,35.39 94.63,36.1 94.17,36.56 93.91,36.56 93.66,36.82 93.66,38.12 92.6,39.18 90.78,39.18 90.56,39.39 90.56,40.8 88.53,42.84 88.53,50.13 88.71,50.3 88.71,53.83 89.88,55 89.88,59.76 89.57,60.07 89.57,67.25 89.19,67.63 89.19,72.56 89.04,72.71 89.04,75.58 88.83,75.78 88.83,77.08 89.17,77.41 89.17,81.29 88.28,82.18 88.28,83.6 87.82,84.06 87.82,84.78 86.7,85.9 86.7,88.7 87.21,89.21 87.21,93.54 85.18,95.57 85.18,97.23 82.16,100.24 66.91,100.24 66.83,100.16 62.7,100.16 62.03,100.83 62.03,101.59 61.02,102.6 61.02,103.14 59.55,104.61 57.97,104.61 57.8,104.78 55.39,104.78 53.41,106.77 51.9,106.77 51.29,106.17 51.29,103.39 49.95,102.04 49.62,102.04 49.44,102.22 48.83,102.22 48.6,101.99 48.6,101.39 48.03,100.82 47.21,100.82 47.05,100.98 47.05,102.48 46.7,102.83 44.96,102.83 44.63,102.5 44.63,101.87 44.05,101.28 43.95,101.28 v2(43.75,101.48)
  BOTTOM w0.079: U24.DN6 95.44,35.88 95.77,35.55 95.77,35.27 95.54,35.04 v2(95.16,35.04)
  BOTTOM w0.102: R519.2 44.42,102.94 44.42,102.29 44.27,102.13 44.27,101.52 44.04,101.29 43.94,101.29 v2(43.75,101.48)
USBP8_TS+_C: length 3.7
  BOTTOM w0.102: CN2.5 45.85,106.58 45.72,106.45 45.72,105.53 44.75,104.56 44.75,104.41 R520.1
USBP8_TS-_C: length 3.7
  BOTTOM w0.102: CN2.4 45.35,106.56 45.5,106.41 45.5,105.62 44.53,104.65 44.53,104.41 R519.1
USBP10+_BT: length 122.9
  IN3 w0.089: v2(94.04,35.8) 93.86,35.62 93.69,35.62 93.46,35.39 93.46,34.57 93.91,34.12 95.41,34.12 98.15,31.38 101.06,31.38 102.07,32.39 102.07,37.14 102.69,37.76 105.4,37.76 106.72,36.44 106.72,33.47 106.56,33.32 106.56,32.11 106.76,31.91 106.76,30.36 107.28,29.85 107.28,27.84 107.9,27.22 107.9,25.03 110.44,22.49 113.33,22.49 115.31,24.47 120.64,24.47 121.98,25.82 127.15,25.82 128.26,26.94 135,26.94 135.41,26.53 137.53,26.53 138.93,27.93 139.25,27.93 139.38,28.05 146.19,28.05 146.33,27.91 153.22,27.91 154.49,26.64 156.33,26.64 156.68,26.28 160.12,26.28 160.64,25.76 165.6,25.76 165.73,25.89 168.05,25.89 168.57,26.4 168.76,26.4 168.82,26.34 v2(168.82,26.1)
  BOTTOM w0.102: CN9.3 182.32,30.63 182.21,30.75 182.21,31.3 182.46,31.56 182.46,32.98 181.53,33.91 176.99,33.91 176.48,33.4 173.68,33.4 169,28.72 169,26.66 168.95,26.6 168.95,26.22 v2(168.82,26.1) ; v2(94.04,35.8) 93.88,35.8 U24.DN10
USBP10-_BT: length 122.8
  IN3 w0.089: v2(169.4,26.1) 169.35,26.1 168.84,26.61 168.48,26.61 167.97,26.09 165.64,26.09 165.51,25.96 160.73,25.96 160.21,26.48 156.77,26.48 156.41,26.84 154.57,26.84 153.3,28.11 146.42,28.11 146.27,28.25 139.3,28.25 139.17,28.13 138.85,28.13 137.45,26.73 135.49,26.73 135.09,27.14 128.18,27.14 127.06,26.02 121.9,26.02 120.55,24.67 115.23,24.67 113.24,22.69 110.53,22.69 108.1,25.12 108.1,27.3 107.48,27.93 107.48,29.93 106.96,30.45 106.96,32 106.77,32.19 106.77,33.23 106.92,33.39 106.92,36.52 105.48,37.96 102.6,37.96 101.87,37.22 101.87,32.47 100.98,31.58 98.23,31.58 95.49,34.33 93.99,34.33 93.66,34.66 93.66,35.31 93.77,35.42 93.97,35.42 94.04,35.34 v2(94.04,35.04)
  BOTTOM w0.102: CN9.5 182.52,30.13 181.99,30.66 181.99,31.39 182.24,31.65 182.24,32.89 181.44,33.69 177.08,33.69 176.57,33.18 173.77,33.18 169.22,28.63 169.22,26.57 169.16,26.51 169.16,26.34 v2(169.4,26.1) ; U24.DP10 93.99,35.04 v2(94.04,35.04)
USBP_TYPC+_C: length 19.5
  TOP w0.102: R486.1 10.21,11.36 10.08,11.23 9.88,11.23 9.41,11.7 v1(9.41,11.73)
  IN1 w0.089: CN14.B6 7.22,16.3 8.14,17.22 8.14,17.67 8.56,18.1 9.34,18.1 10.55,16.89 10.55,15.91 10.14,15.5 v1(9,15.5) 9,15.56 8.75,15.81 8.49,15.81 8.34,15.66 8.34,14.11 9.16,13.3 9.16,12.7 8.82,12.37 8.82,11.5 8.93,11.39 9.12,11.39 9.41,11.68 v1(9.41,11.73)
  BOTTOM w0.102: v1(9,15.5) 8.79,15.71 8.04,15.71 7.96,15.78 7.61,15.78 7.47,15.65 CN14.A6 ; v1(9.41,11.73) 9.68,11.46 9.96,11.46 10.02,11.51 RV3.1
USBP_TYPC-_C: length 19.4
  TOP w0.102: v1(9.41,11.08) 9.72,11.08 9.79,11.01 10.17,11.01 10.21,10.97 R489.1
  IN1 w0.089: CN14.B7 6.12,15.65 6.57,16.1 7.31,16.1 8.34,17.13 8.34,17.59 8.65,17.89 9.26,17.89 10.35,16.8 10.35,15.99 10.05,15.7 9.43,15.7 v1(9,16.13) 8.88,16.01 8.41,16.01 8.14,15.74 8.14,14.02 8.95,13.21 8.95,12.79 8.62,12.46 8.62,11.42 8.85,11.19 9.3,11.19 v1(9.41,11.08)
  BOTTOM w0.102: v1(9,16.13) 8.79,15.92 8.13,15.92 8.05,16 7.64,16 7.49,16.15 CN14.A7 ; v1(9.41,11.08) 9.56,11.24 9.89,11.24 10.07,11.06 RV3.2
USBPWRD2:
  vias: v1(212.89,24.88)
VA: length 170.9
  TOP w0.254: v2(135.24,34.94) 135.24,35.39 134.89,35.75 133.74,35.75 132.9,34.91 130.33,34.91 PR71.1 129.38,34.82 128.79,34.23 128.79,34.07 127.2,32.49 PD4.2
  TOP w0.508: v1(42.99,122.24) 43.11,122.12 PC8.1
  IN2 w0.508: v1(123.18,47.53) 121.25,49.47 117.11,49.47 115.63,50.94 115.63,66.49 114.52,67.6 114.52,73.93 114.87,74.28 114.87,80.61 110.17,85.31 106.39,85.31 102.61,89.09 98.66,89.09 95.57,92.19 95.57,99.99 94.97,100.58 94.97,102.31 93.76,103.52 93.76,104.93 91.14,107.56 88.98,107.56 87.74,108.8 83.91,108.8 82.62,110.1 82.26,110.1 80.23,112.13 78.03,112.13 75,115.17 75,116.95 73.46,118.49 73.11,118.83 73.11,123.63 71.94,124.8 61,124.8 60.51,124.32 59.24,124.32 57.85,122.92 52.64,122.92 49.85,120.13 44.21,120.13 43.55,120.79
  IN3 w0.508: v1(123.18,47.53) 124.42,46.29 124.42,39.74 129.98,34.18 v1(129.98,33.95)
  BOTTOM w0.254: PR245.1 135.67,34.5 v2(135.24,34.94)
  vias: v1(19.62,116.57) v1(19.62,115.94) v1(20.38,116.57) v1(20.38,115.94) v1(21.14,116.57) v1(21.14,115.94) v1(21.91,116.57) v1(21.91,115.94) v1(35.85,116.39) v1(40.45,122.24) v1(41.08,122.24) v1(41.18,116.78) v1(41.72,122.24) v1(41.69,118.58) v1(41.82,116.78) v1(42.35,122.24)
VA2: length 160.3
  TOP w0.508: 44.14,119.95 PQ4.1 45.54,121.27 45.65,121.27 46.16,121.78 46.16,121.84 PC6.1
  IN2 w0.406: v1(114.16,58.3) 114.95,59.09 114.95,66.38 113.96,67.36 113.96,78.49 110.16,82.29 106.72,82.29 105.82,83.19 104.64,83.19 103.93,83.9 101.64,83.9 101.02,84.52 98.36,84.52 97.04,85.83 97.04,88.63 94.16,91.51 93.54,91.51 92.14,92.92 92.14,98.79 88.96,101.97 85.02,101.97 82.94,104.05 78.52,104.05 76.67,105.9 71.56,105.9 71.31,105.65 70.6,105.65 68.64,107.61 68.64,110.52 62.97,116.19 62.16,116.19 60.89,117.46 60.89,119.37 60.39,119.87 60.39,120 58.23,122.16 52.89,122.16 50.25,119.52 43.5,119.52 v1(43.47,119.49)
  IN3 w0.406: v1(114.16,58.3) 114.18,58.3 115.02,57.47 115.02,53.17 115.53,52.67 115.53,51.15 117.06,49.62 120.3,49.62 123.71,46.2 123.71,39.66 129.27,34.1 v2(129.27,33.9)
  BOTTOM w0.102: v1(43.04,120) 43.03,120 43.03,119.85 43.14,119.75 43.14,119.65 43.29,119.49 v1(43.47,119.49)
  BOTTOM w0.406: v2(129.27,33.9) 129.27,34.15 129.68,34.56 133.24,34.56 PR248.1
VADJ1: length 5.4
  TOP w0.102: R26.2 R27.1 C61.1 56.66,107.35 56.66,108.19 v1(56.78,108.32) 56.78,108.33 v1(56.32,108.79)
  BOTTOM w0.102: v1(56.78,108.32) 56.85,108.25 CN2.27
VGA_OVT#: length 46.1
  TOP w0.102: v1(99.55,123) 98.84,123 98.4,123.44 Q1.1 97.67,123.04 96.35,121.73 96.35,121.12 95.26,120.02 95.26,116.95 95.16,116.85 v1(95.16,115.66)
  IN2 w0.089: v2(97.59,92.05) 96.9,92.73 96.9,96.75 96.71,96.94 96.71,102.5 96.61,102.6 96.61,104.43 v2(94.55,106.49)
  IN3 w0.089: v2(94.55,106.49) 94.85,106.79 94.85,113.52 95.21,113.88 95.21,115.61 v1(95.16,115.66)
  BOTTOM w0.102: U22.A6 98.43,92.71 97.77,92.05 v2(97.59,92.05) 97.51,91.98 95.92,91.98 95.33,91.38 92.42,91.38 91.04,90.01 91.04,89.41 R564.1
VGA_RST#: length 20.6
  IN3 w0.089: v2(98.83,111.63) 98,112.46 98,115.07 97.34,115.73 97.34,116.95 98.23,117.84 98.23,119.37 96.96,120.64 96.96,121.75 v2(97.37,122.16)
  BOTTOM w0.102: R502.2 100.93,125.49 100.77,125.34 C493.1 100.65,125.34 100.14,125.84 98.69,125.84 v1(98.28,125.44) 97.5,124.65 97.5,123.96 97.7,123.76 97.7,122.72 97.37,122.39 v2(97.37,122.16)
  BOTTOM w0.127: U22.AC7 v2(98.83,111.63)
VGA_VCCSENSE: length 35.1
  TOP w0.102: PR26.2 69.88,108.67 69.83,108.61 PR28.2 69.48,108.22 v1(69.23,108.47)
  IN2 w0.089: v2(92.69,101.13) 92.28,101.54 90.64,101.54 88.25,103.93 88.25,105.42 86.9,106.77 83.53,106.77 82.58,105.83 78.02,105.83 77,106.84 72.23,106.84 71.79,107.28 70.42,107.28 v1(69.23,108.47)
  BOTTOM w0.102: v2(92.69,101.13) 92.69,101.08 92.77,100.99 92.77,98.94 94.17,97.55 94.71,97.55 U22.F2
VGA_VSSSENSE: length 39.2
  TOP w0.102: PR24.2 69,112.07 68.93,112.14 68.93,112.49 PR23.2 68.66,112.3 v2(68.51,112.15)
  IN2 w0.089: v2(92.69,101.71) 90.72,101.71 88.43,104 88.43,105.5 86.97,106.95 83.46,106.95 82.51,106 78.09,106 77.08,107.02 72.31,107.02 71.87,107.45 70.52,107.45 69.78,108.19 69.78,110.88 v2(68.51,112.15)
  BOTTOM w0.102: v2(92.69,101.71) 92.22,101.25 92.22,100.74 92.56,100.4 92.56,98.75 94.02,97.29 94.17,97.29 U22.F1
VL: length 75.1
  TOP w0.254: v2(48.6,15.02) 48.6,15.1 46.57,17.13 v1(46.47,17.13) 46.09,16.75 44.53,16.75 44.31,16.52 43.62,16.52 43.24,16.15 43.24,15.91 42.72,15.39 PR117.2
  IN2 w0.254: v1(72.17,13.32) 72.17,13.45 71.76,13.86 61.76,13.86 60.3,15.31 58.65,15.31 57.62,14.29 56.03,14.29 55.06,15.25 48.83,15.25 v2(48.6,15.02)
  IN3 w0.254: v1(72.17,13.32) 72.74,13.89 73.97,13.89 74.86,13 79.92,13 82.71,10.2 89.07,10.2 94.14,15.28 95.53,15.28 99.91,19.65 99.91,22.51 100.65,23.24 100.65,25.39 101.31,26.05 v2(101.31,26.78)
  BOTTOM w0.381: v2(101.31,26.78) 101.16,26.93 101.16,27.28 PR262.1
VMA_CLK0: length 42.1
  TOP w0.102: v2(113.73,95.87) 114.16,95.44 114.73,95.44 115.05,95.12 115.79,95.12 115.99,95.32 115.99,95.77 116.6,96.38 120.08,96.38 120.69,96.99 124.97,96.99 125.46,97.48 126.04,97.48 126.14,97.38 126.14,96.1 126.35,95.9 126.81,95.9 127.03,96.12 127.03,97.51 127.14,97.61 127.44,97.61 127.54,97.51 127.54,96.1 127.75,95.9 128.2,95.9 128.43,96.12 128.43,97.51 128.53,97.61 128.84,97.61 128.94,97.51 128.94,96.15 129.2,95.9 129.58,95.9 129.83,96.15 129.83,97.51 129.93,97.61 130.23,97.61 130.34,97.51 130.34,96.23 130.62,95.95 131.99,95.95 133.25,94.69 133.25,92.84 v2(133.01,92.61)
  BOTTOM w0.079: 134.16,94.73 134.14,94.71 134.14,94.69 133.73,94.28 133.73,92.01 133.6,91.88 133.49,91.88 133.41,91.96 VRAM2.J12
  BOTTOM w0.102: v2(113.73,95.87) 113.8,95.8 113.8,95.53 113.7,95.43 U22.D24 ; R531.2 134.85,97.13 134.85,96.84 134.75,96.74 134.75,96.2 134.3,95.76 134.3,94.87 134.16,94.73 ; v2(133.01,92.61) 133.41,92.21 VRAM2.J12
VMA_CLK0#: length 42.4
  TOP w0.102: v2(114.51,95.85) 114.73,95.63 114.81,95.63 115.12,95.31 115.71,95.31 115.8,95.4 115.8,95.85 116.52,96.57 120,96.57 120.61,97.18 124.89,97.18 125.39,97.67 126.12,97.67 126.34,97.46 126.34,96.18 126.43,96.09 126.73,96.09 126.84,96.2 126.84,97.59 127.06,97.8 127.52,97.8 127.73,97.59 127.73,96.18 127.83,96.09 128.13,96.09 128.24,96.2 128.24,97.59 128.45,97.8 128.92,97.8 129.13,97.59 129.13,96.23 129.27,96.09 129.5,96.09 129.64,96.23 129.64,97.59 129.85,97.8 130.31,97.8 130.53,97.59 130.53,96.31 130.7,96.14 132.07,96.14 133.44,94.77 133.44,92.23 v2(133.01,91.81)
  BOTTOM w0.079: 134.29,94.59 134.28,94.58 134.26,94.58 133.89,94.21 133.89,91.94 133.67,91.72 133.49,91.72 133.41,91.64 VRAM2.J11
  BOTTOM w0.102: 134.29,94.59 134.49,94.79 134.49,95.68 134.94,96.13 134.94,96.66 135.04,96.76 135.04,97.14 R531.1 ; v2(133.01,91.81) 133.01,91.8 VRAM2.J11 ; U22.D25 114.13,95.46 v2(114.51,95.85)
VMA_CLK1: length 44.4
  TOP w0.102: v2(112.11,102.49) 112.11,102.25 112.49,101.86 113.16,101.86 113.48,101.55 120.51,101.55 121.66,102.7 123.19,102.7 123.29,102.8 124.95,102.8 125.05,102.9 125.05,103.21 124.95,103.31 123.29,103.31 123.08,103.52 123.08,103.99 123.29,104.2 124.75,104.2 124.85,104.3 124.85,104.6 124.75,104.71 123.29,104.71 123.08,104.92 123.08,105.37 123.71,106 124.38,106 124.48,106.1 124.48,106.75 124.78,107.05 125.08,107.05 125.37,106.75 125.37,106.1 125.47,106 125.72,106 125.88,106.17 125.88,107.02 126.16,107.3 129.37,107.3 129.47,107.4 130.24,107.4 130.34,107.3 131.63,107.3 131.89,107.05 133.03,107.05 133.25,107.26 133.25,107.57 v2(133.01,107.81)
  BOTTOM w0.079: 134.75,104.6 134.75,104.62 134.76,104.64 134.76,105.22 134.53,105.45 134.53,106.81 134.43,106.92 133.93,106.92 133.73,107.12 133.73,107.65 133.65,107.73 133.57,107.73 133.41,107.57 VRAM1.J12
  BOTTOM w0.102: VRAM1.J12 133.41,107.21 133.31,107.11 133.11,107.11 133.01,107.21 v2(133.01,107.81) ; R524.2 133.95,102.66 134.08,102.79 134.08,103.54 134.75,104.21 134.75,104.6
  BOTTOM w0.127: U22.N22 111.69,102.73 111.93,102.49 v2(112.11,102.49)
VMA_CLK1#: length 44.7
  TOP w0.102: v2(133.01,108.62) 133.01,108.39 133.44,107.96 133.44,107.18 133.11,106.86 131.81,106.86 131.55,107.11 130.26,107.11 130.16,107.21 129.55,107.21 129.45,107.11 126.24,107.11 126.07,106.95 126.07,106.09 125.79,105.81 125.4,105.81 125.18,106.02 125.18,106.68 125,106.86 124.86,106.86 124.67,106.68 124.67,106.02 124.46,105.81 123.79,105.81 123.27,105.29 123.27,105 123.37,104.9 124.83,104.9 125.04,104.68 125.04,104.22 124.83,104.01 123.37,104.01 123.27,103.91 123.27,103.6 123.37,103.5 125.03,103.5 125.25,103.29 125.25,102.82 125.03,102.61 123.37,102.61 123.27,102.51 121.74,102.51 120.58,101.36 113.4,101.36 113.08,101.67 v2(112.11,101.67)
  BOTTOM w0.079: 134.94,104.6 134.94,104.62 134.92,104.64 134.92,105.29 134.69,105.51 134.69,106.88 134.49,107.08 134,107.08 133.89,107.19 133.89,107.72 133.71,107.89 133.54,107.89 133.41,108.02 VRAM1.J11
  BOTTOM w0.102: U22.M22 v2(112.11,101.67) ; R524.1 134.4,102.63 134.27,102.76 134.27,103.46 134.94,104.13 134.94,104.6 ; v2(133.01,108.62) 133.01,108.61 133.41,108.21 VRAM1.J11
VMA_DQ0: length 39.8
  TOP w0.127: v2(107.92,96.66) 108.51,96.07 108.51,95.38 108.36,95.24 108.36,94.81 109.28,93.89 109.28,93.33 109.44,93.17 109.44,91.75 111.62,89.57 121.86,89.57 v1(122.71,88.73) 125.16,86.28 125.16,84.57 126.3,83.43 129.47,83.43 130.83,82.07 135.23,82.07 135.81,82.65 135.81,83.4 v2(136.21,83.81)
  BOTTOM w0.165: v2(136.21,83.81) 136.61,84.2 VRAM2.E2 ; U22.E18 v2(107.92,96.66)
VMA_DQ1: length 37.5
  TOP w0.127: v2(108.72,96.63) 108.77,96.58 108.77,95.62 109.41,94.98 109.41,94.14 109.74,93.81 109.74,93.4 110.59,92.54 110.59,91.31 111.83,90.07 122.08,90.07 125.65,86.49 125.65,84.96 126.65,83.97 129.83,83.97 v1(129.86,83.94) 131.23,82.57 134.83,82.57 135,82.75 135,83.24 135.41,83.65 v2(135.41,83.81)
  BOTTOM w0.165: v2(108.72,96.63) 108.35,97.01 U22.F18 ; VRAM2.F2 135.8,84.2 v2(135.41,83.81)
VMA_DQ2: length 46.3
  TOP w0.127: v2(107.09,96.62) 106.7,96.23 106.7,95.7 106.66,95.67 106.66,93.58 107.5,92.74 107.5,91.63 108.29,90.84 108.6,90.84 110.86,88.58 121.32,88.58 123.89,86.02 123.89,84.19 127.01,81.06 138.03,81.06 140.21,83.24 v2(140.21,83.81)
  BOTTOM w0.102: U22.E16 106.68,96.23 v2(107.09,96.62)
  BOTTOM w0.165: VRAM2.A2 139.82,84.2 v2(140.21,83.81)
VMA_DQ3: length 44.9
  TOP w0.127: v2(107.88,97.52) 107.88,97.27 107.5,96.89 107.5,96.49 107.52,96.47 107.52,95.17 108.36,94.33 108.36,92.98 108.62,92.73 108.62,91.71 111.25,89.08 121.55,89.08 124.52,86.11 124.52,84.46 127.41,81.57 136.45,81.57 v1(136.61,81.73) 137.69,81.73 138.37,82.41 138.65,82.41 139.01,82.77 139.01,83.3 139.41,83.71 v2(139.41,83.81)
  BOTTOM w0.165: v2(139.41,83.81) 139.02,84.2 VRAM2.B2 ; U22.F17 107.88,97.45 v2(107.88,97.52)
VMA_DQ4: length 31.1
  TOP w0.127: v2(135.41,86.21) 135.41,86.21 135.02,86.6 135.02,87.21 134.34,87.89 126.67,87.89 v1(126.55,88) 126.53,88 122.97,91.55 112.22,91.55 111.39,92.38 111.39,92.88 110.54,93.73 110.54,94.82 v2(110.38,94.98)
  BOTTOM w0.165: v2(135.41,86.21) 135.41,86.2 135.81,85.81 VRAM2.F4 ; v2(110.38,94.98) 110.38,95.04 U22.D20
VMA_DQ5: length 34.7
  TOP w0.127: v2(139.41,85.41) 139.01,85 137.98,85 136.74,86.24 136.74,87.36 135.14,88.96 127.11,88.96 v1(125.16,90.92) 123.53,92.54 112.96,92.54 111.23,94.27 v2(111.23,95.03)
  BOTTOM w0.165: U22.D21 v2(111.23,95.03) ; v2(139.41,85.41) 139.02,85.8 VRAM2.B4
VMA_DQ6: length 33.5
  TOP w0.127: v2(110.42,96.6) 110.42,96.48 110.81,96.09 110.81,93.84 111.66,92.99 111.66,92.49 112.28,91.88 112.77,91.88 112.94,92.05 123.26,92.05 126.88,88.43 v1(130.08,88.43) 134.63,88.43 135.82,87.24 135.82,86.61 136.21,86.21 v2(136.21,86.21)
  BOTTOM w0.165: v2(136.21,86.21) 136.61,85.81 VRAM2.E4 ; v2(110.42,96.6) 109.99,97.04 U22.F20
VMA_DQ7: length 36.1
  TOP w0.127: v2(111.23,95.83) 111.23,95.71 111.63,95.3 111.63,94.29 113.03,92.89 115.87,92.89 116.03,93.04 123.96,93.04 v1(124.81,92.19) 127.53,89.47 135.45,89.47 137.35,87.57 137.35,86.09 137.63,85.81 139.79,85.81 140.19,85.41 v2(140.21,85.41)
  BOTTOM w0.165: v2(140.21,85.41) 139.82,85.8 VRAM2.A4 ; v2(111.23,95.83) 110.83,96.23 U22.E21
VMA_DQ8: length 42.9
  IN1 w0.114: v2(106.27,96.63) 106.27,97.82 107.12,98.67 109.68,98.67 110.38,97.96 114.8,97.96 115.15,98.31 121.17,98.31 121.96,99.1 136.42,99.1 138.36,97.15 138.36,93.59 139.01,92.94 139.01,91.4 v2(139.41,91.01)
  BOTTOM w0.165: U22.E15 105.89,96.23 106.27,96.61 v2(106.27,96.63) ; v2(139.41,91.01) 139.02,91.4 VRAM2.B11
VMA_DQ9: length 35.2
  IN1 w0.114: v2(106.28,95.85) 106.44,95.85 106.81,96.22 107.75,96.22 107.75,96.23 109.92,96.23 109.95,96.2 111.01,96.2 111.06,96.25 112.77,96.25 112.8,96.28 114.94,96.28 115.62,96.96 121.42,96.96 122.35,97.89 132.11,97.89 133.75,96.25 135.19,96.25 136.61,94.83 136.61,93.81 v2(136.21,93.41)
  BOTTOM w0.165: VRAM2.E13 136.61,93.01 v2(136.21,93.41) ; U22.D15 105.87,95.45 v2(106.28,95.85)
VMA_DQ10: length 45.6
  IN1 w0.114: v2(140.21,92.61) 140.64,93.04 140.64,96.51 136.99,100.17 121.51,100.17 120.99,99.66 114.4,99.66 114.34,99.6 110.3,99.6 109.29,100.61 107.38,100.61 106.93,100.16 106.93,99.66 106.78,99.5 105.59,99.5 105.19,99.1 105.19,97.64 v2(105.37,97.47)
  BOTTOM w0.165: v2(140.21,92.61) 139.82,93 VRAM2.A13 ; v2(105.37,97.47) 105.76,97.07 U22.F15
VMA_DQ11: length 49.4
  IN1 w0.114: v2(103.81,96.64) 104.2,97.03 104.2,98.47 105.98,100.25 105.98,100.44 106.4,100.86 110.68,100.86 111.13,100.42 119.04,100.42 119.34,100.72 137.2,100.72 141.29,96.63 141.29,92.08 v2(140.21,91.01)
  BOTTOM w0.165: U22.F13 104.19,97.01 v2(103.81,96.64) ; VRAM2.A11 139.82,91.4 v2(140.21,91.01)
VMA_DQ12: length 37.2
  IN1 w0.114: v2(137.01,91.81) 136.6,92.21 136.05,92.21 135.8,92.47 135.8,92.84 135.64,93 134.38,93 134.05,93.33 134.05,93.69 131.49,96.25 125.41,96.25 123.76,94.6 120.33,94.6 120.08,94.35 114.18,94.35 113.9,94.63 113.24,94.63 112.85,94.23 108.59,94.23 108.22,94.6 107.61,94.6 107.36,94.35 104.76,94.35 v2(104.65,94.23)
  BOTTOM w0.165: v2(137.01,91.81) 136.61,91.4 VRAM2.E11 ; U22.C13 104.26,94.63 v2(104.65,94.23)
VMA_DQ13: length 36.5
  IN1 w0.114: v2(103.81,93.43) 104.22,93.03 104.89,93.03 105.65,93.79 108.34,93.79 108.42,93.86 113.32,93.86 113.47,93.71 113.78,93.71 113.94,93.87 114.74,93.87 114.9,93.71 117.28,93.71 117.79,93.2 123.12,93.2 125.64,95.72 131.27,95.72 133.41,93.57 133.41,93.2 134.4,92.21 135,92.21 v2(135.41,91.81)
  BOTTOM w0.165: U22.B13 104.19,93.81 v2(103.81,93.43) ; v2(135.41,91.81) 135.81,91.41 VRAM2.F11
VMA_DQ14: length 44.9
  IN1 w0.114: v2(139.41,92.61) 139.51,92.7 139.51,93.33 139,93.84 139,97.4 136.76,99.63 121.73,99.63 121.14,99.05 116.77,99.05 116.59,98.86 115.07,98.86 115,98.78 111.18,98.78 110.81,98.41 110.29,98.41 108.99,99.71 108.29,99.71 108.27,99.69 107.66,99.69 107.37,99.39 107.37,99.27 105.85,97.76 105.85,97.19 105.73,97.06 105.22,97.06 105.04,96.89 105.04,96.22 v2(104.65,95.83)
  BOTTOM w0.165: v2(139.41,92.61) 139.02,93 VRAM2.B13 ; v2(104.65,95.83) 104.26,96.23 U22.E13
VMA_DQ15: length 35.4
  IN1 w0.114: v2(135.41,93.41) 135.01,93.8 135.01,94.46 134.74,94.73 133.77,94.73 131.7,96.8 123.85,96.8 122.82,95.77 120.36,95.77 119.57,94.98 115.22,94.98 114.84,94.6 114.28,94.6 113.9,94.98 112.96,94.98 112.56,94.58 108.61,94.58 108.33,94.86 107.5,94.86 107.25,94.6 105.08,94.6 v2(104.65,95.03)
  BOTTOM w0.165: VRAM2.F13 135.81,93.01 v2(135.41,93.41) ; U22.D13 104.26,95.43 v2(104.65,95.03)
VMA_DQ16: length 31.9
  IN1 w0.114: v2(129.83,91) 129.58,90.74 129.58,90.16 128.82,89.39 126.55,89.39 125.23,88.07 109.58,88.07 108.56,89.09 106.54,89.09 104.71,90.92 104.71,91.96 105.37,92.62 v2(105.44,92.62)
  BOTTOM w0.165: VRAM2.N11 130.21,91.37 v2(129.83,91) ; U22.B15 105.84,93.83 105.44,93.42 v2(105.44,92.62)
VMA_DQ17: length 26.6
  IN1 w0.114: v2(126.58,91.02) 124.76,89.2 109.98,89.2 109.03,90.16 107,90.16 105.98,91.17 105.98,92.06 v2(106.36,92.44)
  BOTTOM w0.165: U22.C16 106.27,94.23 106.27,92.53 v2(106.36,92.44) ; v2(126.58,91.02) 126.96,91.4 VRAM2.U11
VMA_DQ18: length 32.4
  IN1 w0.114: v2(104.19,92.32) 104.19,90.68 106.31,88.56 108.32,88.56 109.33,87.54 125.46,87.54 126.68,88.76 128.97,88.76 130.19,89.98 130.19,90.58 v2(130.61,91)
  BOTTOM w0.165: v2(104.19,92.32) U22.A13 ; v2(130.61,91) VRAM2.M11
VMA_DQ19: length 27
  IN1 w0.114: v2(105.47,92.04) 105.17,91.73 105.17,91.22 106.77,89.62 108.8,89.62 109.76,88.66 125.06,88.66 126.43,90.03 126.45,90.03 v2(127.42,90.99)
  BOTTOM w0.165: U22.A15 105.9,93 105.9,92.46 v2(105.47,92.04) ; VRAM2.T11 127.42,91.01 v2(127.42,90.99)
VMA_DQ20: length 22.9
  IN1 w0.114: v2(126.43,92.95) 125.92,92.95 123.81,90.84 110.63,90.84 109.79,91.68 v2(108.01,91.68)
  BOTTOM w0.102: U22.B18 108.35,93.67 108.01,93.33 108.01,93.05 107.51,92.55 107.51,92.18 v2(108.01,91.68)
  BOTTOM w0.165: v2(126.43,92.95) 126.96,92.95 VRAM2.U13
VMA_DQ21: length 23.1
  IN1 w0.114: v2(108.01,92.44) 108.42,92.04 110.12,92.04 110.78,91.38 123.58,91.38 126.3,94.09 127.28,94.09 v2(127.4,94.21)
  BOTTOM w0.165: v2(127.4,94.21) 127.4,93.41 VRAM2.T13 ; v2(108.01,92.44) 108.35,92.78 U22.A18
VMA_DQ22: length 26.6
  IN1 w0.114: v2(109.03,92.44) 109.59,93 110.3,93 110.46,92.85 110.46,92.47 110.61,92.32 110.91,92.32 111.07,92.47 111.07,92.85 111.22,93 112.66,93 112.96,92.7 112.96,92.57 113.63,91.91 123.35,91.91 126.07,94.63 129.99,94.63 130.25,94.37 130.25,93.83 v2(129.83,93.4)
  BOTTOM w0.165: U22.A19 109.03,92.91 v2(109.03,92.44) ; VRAM2.N13 130.21,93.03 v2(129.83,93.4)
VMA_DQ23: length 27.1
  IN1 w0.114: v2(130.61,93.4) 130.87,93.66 130.87,94.53 130.22,95.18 125.86,95.18 123.12,92.44 115.5,92.44 115,92.95 113.47,92.95 112.96,93.46 108.8,93.46 v2(108.77,93.43)
  BOTTOM w0.165: U22.C19 108.77,94.25 v2(108.77,93.43) ; VRAM2.M13 v2(130.61,93.4)
VMA_DQ24: length 21.7
  BOTTOM w0.127: U22.B24 113.33,93.6 113.73,93.2 113.73,92.44 114.06,92.11 115.91,92.11 116.5,92.7 v1(119.64,92.7) 122.79,92.7 127.62,87.87 128.84,87.87 129.54,87.17 129.54,87.04 129.81,86.78 129.81,86.2 VRAM2.N4
VMA_DQ25: length 20.9
  BOTTOM w0.127: U22.C23 112.96,94.16 112.96,91.69 113.55,91.1 116.33,91.1 116.91,91.68 v1(122.29,91.68) 122.41,91.68 126.66,87.43 126.66,86.15 VRAM2.U4
VMA_DQ26: length 21.3
  BOTTOM w0.127: VRAM2.M4 130.62,86.19 130.62,87.62 129.73,88.51 127.69,88.51 v1(123.4,92.79) 122.99,93.2 116.29,93.2 115.71,92.62 114.31,92.62 114.13,92.8 U22.A25
VMA_DQ27: length 19.1
  BOTTOM w0.127: U22.A24 113.33,92.2 113.93,91.6 116.11,91.6 116.7,92.19 122.6,92.19 v1(123.83,90.96) 127.42,87.37 127.42,86.19 VRAM2.T4
VMA_DQ28: length 23.8
  BOTTOM w0.127: VRAM2.T2 127.42,83.81 125.66,83.81 124.9,84.57 124.9,86.38 v1(122.1,89.19) 121.69,89.6 117.63,89.6 117.1,89.06 112.53,89.06 111.19,90.41 111.19,92.32 110.83,92.67 U22.A21
VMA_DQ29: length 23
  BOTTOM w0.127: VRAM2.U2 126.03,84.2 125.41,84.82 125.41,86.58 v1(124.29,87.7) 121.88,90.11 v1(120.79,90.11) 117.44,90.11 116.91,89.57 112.79,89.57 111.45,90.91 111.45,92.61 111.24,92.82 111.24,93.42 U22.B21
VMA_DQ30: length 32.8
  BOTTOM w0.127: U22.C20 109.99,94.42 109.54,93.97 109.54,92.82 109.48,92.77 109.48,92.25 110.17,91.55 110.17,89.65 111.77,88.05 117.49,88.05 118.02,88.58 121.3,88.58 123.89,86 v1(123.89,85.79) 123.89,84.16 126.33,81.72 129.62,81.72 130.62,82.71 130.62,83.81 VRAM2.M2
VMA_DQ31: length 30.2
  BOTTOM w0.127: U22.C21 110.42,94.23 110.42,92.32 110.68,92.06 110.68,90.16 112.28,88.56 117.29,88.56 117.83,89.09 121.5,89.09 v1(122.77,87.82) 124.39,86.19 124.39,84.36 126.37,82.38 129.06,82.38 129.81,83.12 129.81,83.8 VRAM2.N2
VMA_DQ32: length 39
  IN1 w0.114: v2(112.11,104.15) 112.11,103.86 112.53,103.44 112.53,102.27 113.47,101.33 116.39,101.33 116.77,100.95 118.81,100.95 119.11,101.26 120.76,101.26 121.26,101.76 135.49,101.76 135.82,102.09 139.63,102.09 141.29,103.75 141.29,107.53 v2(140.21,108.61)
  BOTTOM w0.165: VRAM1.U11 140.21,108.6 v2(140.21,108.61) ; U22.R22 v2(112.11,104.15)
VMA_DQ33: length 27.5
  IN1 w0.114: v2(113.74,104.96) 115.32,104.96 116.76,106.39 118.62,106.39 118.95,106.72 123.18,106.72 126.35,109.89 136.41,109.89 136.71,109.59 136.71,109.11 v2(136.21,108.61)
  BOTTOM w0.165: VRAM1.N11 136.61,108.21 v2(136.21,108.61) ; U22.R24 113.36,104.57 v2(113.74,104.96)
VMA_DQ34: length 34
  IN1 w0.114: v2(112.11,104.97) 112.54,104.54 112.54,103.92 112.73,103.72 113.24,103.72 113.35,103.62 113.35,103.11 113.54,102.91 113.9,102.91 114.11,102.7 114.11,102.19 114.42,101.89 118.04,101.89 118.48,102.32 120.31,102.32 120.81,102.82 134.14,102.82 134.48,103.16 138.42,103.16 139.79,104.53 139.79,105.78 v2(140.21,106.21)
  BOTTOM w0.165: v2(140.21,106.21) 139.82,106.6 VRAM1.U13
  BOTTOM w0.305: v2(112.11,104.97) 111.71,105.37 U22.T22
VMA_DQ35: length 25.5
  IN1 w0.114: v2(135.41,108.61) 135.02,108.21 126.07,108.21 124.05,106.19 119.17,106.19 118.84,105.86 117,105.86 115.74,104.61 114.39,104.61 114.29,104.51 113.32,104.51 v2(112.92,104.11)
  BOTTOM w0.165: U22.R23 112.53,104.5 v2(112.92,104.11) ; VRAM1.M11 135.81,108.21 v2(135.41,108.61)
VMA_DQ36: length 25.2
  IN1 w0.114: v2(116.56,104.38) 116.56,104.65 117.24,105.33 119.06,105.33 119.39,105.66 124.91,105.66 126.37,107.12 135.25,107.12 v2(136.21,106.16)
  BOTTOM w0.127: U22.N25 114.43,102.89 114.9,103.36 115.38,103.36 115.61,103.6 116.12,103.6 116.56,104.04 v2(116.56,104.38)
  BOTTOM w0.165: v2(136.21,106.16) 136.61,106.55 VRAM1.N13
VMA_DQ37: length 23
  IN1 w0.114: v2(135.41,106.16) 134.98,106.59 126.98,106.59 125.52,105.12 119.62,105.12 119.29,104.79 117.51,104.79 v2(117.36,104.65)
  BOTTOM w0.127: U22.N26 115.15,103.11 115.45,103.11 115.71,103.37 116.4,103.37 117.34,104.31 117.34,104.63 v2(117.36,104.65)
  BOTTOM w0.165: VRAM1.M13 135.81,106.55 v2(135.41,106.16)
VMA_DQ38: length 35.2
  IN1 w0.114: v2(112.92,103.28) 112.92,103.08 113.34,102.66 113.34,102.25 113.96,101.63 116.83,101.63 116.98,101.48 118.53,101.48 118.83,101.79 120.53,101.79 121.04,102.29 134.5,102.29 134.83,102.63 139.15,102.63 140.64,104.12 140.64,106.57 v2(139.41,107.81)
  BOTTOM w0.165: v2(139.41,107.81) 139.02,108.2 VRAM1.T11 ; U22.N23 v2(112.92,103.28)
VMA_DQ39: length 29.9
  IN1 w0.114: v2(139.41,106.21) 139.13,105.92 139.13,104.9 137.92,103.69 133.87,103.69 133.53,103.36 120.58,103.36 120.08,102.86 118.25,102.86 117.53,102.14 115.11,102.14 114.95,102.3 114.95,102.83 114.46,103.33 v2(113.74,103.33)
  BOTTOM w0.165: VRAM1.T13 139.02,106.6 v2(139.41,106.21) ; v2(113.74,103.33) 113.33,102.92 U22.N24
VMA_DQ40: length 27.4
  IN1 w0.114: v2(135.41,113.4) 135.02,113 135.02,112.28 134.92,112.18 125.08,112.18 121.76,108.86 118.05,108.86 117.73,108.53 116.03,108.53 115.28,107.78 114.09,107.78 114.02,107.86 112.52,107.86 v2(112.11,107.45)
  BOTTOM w0.165: v2(112.11,107.45) 112.51,107.05 U22.V23 ; v2(135.41,113.4) 135.41,113.41 135.81,113.8 VRAM1.M4
VMA_DQ41: length 32.1
  IN1 w0.114: v2(137.01,114.21) 137.41,113.8 137.41,113.08 137.48,113.02 137.48,112.33 136.79,111.64 125.44,111.64 122.12,108.32 118.29,108.32 117.96,107.99 116.07,107.99 115.12,107.04 113.09,107.04 112.26,106.22 112.02,106.22 111.6,106.63 v2(111.29,106.63)
  BOTTOM w0.165: VRAM1.N4 136.61,113.8 v2(137.01,114.21) ; U22.V22 111.69,107.03 v2(111.29,106.63)
VMA_DQ42: length 31.9
  IN1 w0.114: v2(140.21,113.41) 137.23,110.43 126.12,110.43 122.95,107.26 118.73,107.26 118.4,106.93 116.53,106.93 115,105.4 113.36,105.4 v2(112.93,104.97)
  BOTTOM w0.165: v2(140.21,113.41) 139.82,113.8 VRAM1.U4 ; U22.T23 v2(112.93,104.97)
VMA_DQ43: length 31.6
  IN1 w0.114: v2(139.41,113.41) 136.99,110.98 125.79,110.98 122.6,107.79 118.51,107.79 118.18,107.46 116.3,107.46 115.05,106.22 112.76,106.22 112.34,105.79 v2(112.11,105.79)
  BOTTOM w0.165: VRAM1.T4 139.02,113.8 v2(139.41,113.41) ; U22.U22 v2(112.11,105.79)
VMA_DQ44: length 30
  IN1 w0.114: v2(112.96,109.11) 113.36,109.51 114.69,109.51 114.96,109.78 114.96,110.75 116.25,112.04 120.62,112.04 126.19,117.61 132.62,117.61 133.4,116.84 135.78,116.84 136.26,116.37 136.45,116.37 v2(137.01,115.81)
  BOTTOM w0.165: v2(137.01,115.81) 136.61,115.4 VRAM1.N2 ; v2(112.96,109.11) 113.33,108.74 U22.Y24
VMA_DQ45: length 32.5
  IN1 w0.114: v2(112.93,109.93) 113.34,110.34 113.85,110.34 114.21,110.7 114.21,110.78 116,112.58 119,112.58 120.84,114.41 122.21,114.41 125.94,118.15 132.98,118.15 133.75,117.37 138.45,117.37 139.08,116.74 139.08,116.4 138.61,115.93 v2(138.61,115.81)
  BOTTOM w0.165: U22.AA24 v2(112.93,109.93) ; v2(138.61,115.81) 138.61,115.8 VRAM1.T2
VMA_DQ46: length 29.9
  IN1 w0.114: v2(112.11,108.27) 112.16,108.27 112.58,108.7 113.2,108.7 113.58,109.08 114.74,109.08 115.49,109.83 115.49,110.51 116.14,111.16 120.51,111.16 126.43,117.08 131.13,117.08 132.03,116.17 133.27,116.17 133.39,116.29 135.57,116.29 136.06,115.81 v2(136.21,115.81)
  BOTTOM w0.165: VRAM1.M2 135.81,115.41 v2(136.21,115.81) ; U22.Y22 v2(112.11,108.27)
VMA_DQ47: length 34.4
  IN1 w0.114: v2(112.08,109.93) 113.58,111.43 114.1,111.43 115.78,113.11 118.51,113.11 120.95,115.56 122.59,115.56 125.77,118.73 133.16,118.73 133.98,117.91 138.68,117.91 139.63,116.95 139.63,116.03 v2(139.41,115.81)
  BOTTOM w0.165: U22.AA23 112.48,109.53 v2(112.08,109.93) ; v2(139.41,115.81) 139.41,115.8 VRAM1.U2
VMA_DQ48: length 20.1
  TOP w0.127: v2(130.61,115.8) 130.76,115.96 130.76,117.06 129.98,117.84 128.59,117.84 128.2,118.22 123.51,118.22 v1(122.87,117.59) 122.34,117.06 121.68,117.06 v2(118.12,113.5)
  BOTTOM w0.127: v2(118.12,113.5) 118.12,113.3 116.95,112.13 116.27,112.13 116.17,112.03 U22.AD27
  BOTTOM w0.165: v2(130.61,115.8) 130.61,115.8 VRAM1.F2
VMA_DQ49: length 18.9
  TOP w0.127: v2(113.73,109.93) 113.73,110.1 114.23,110.6 114.62,110.6 116.57,112.56 119.09,112.56 120.81,114.29 121.81,114.29 v1(123.67,116.15) 124.6,117.08 126.94,117.08 127.41,116.6 v2(127.41,115.88)
  BOTTOM w0.165: v2(127.41,115.88) 127.81,115.48 VRAM1.B2 ; U22.AB25 v2(113.73,109.93)
VMA_DQ50: length 20.7
  TOP w0.127: v2(116.95,113.52) 116.95,113.35 117.23,113.07 118.73,113.07 121.22,115.56 v1(122.11,115.56) 124.27,117.72 127.82,117.72 128.36,117.18 129.92,117.18 130.26,116.84 130.26,116.24 v2(129.83,115.8)
  BOTTOM w0.127: v2(116.95,113.52) 116.95,112.94 116.6,112.59 116.27,112.59 116.13,112.44 115.34,112.44 U22.AD26
  BOTTOM w0.165: VRAM1.E2 130.21,115.43 v2(129.83,115.8)
VMA_DQ51: length 15.5
  TOP w0.127: v2(117.03,111.62) 117.52,112.11 119.56,112.11 121.1,113.66 122.1,113.66 v1(122.48,114.04) 124.39,115.96 v2(126.45,115.96)
  BOTTOM w0.165: U22.AC25 114.58,110.73 115.03,110.73 115.36,111.06 116.6,111.06 117.03,111.49 v2(117.03,111.62) ; VRAM1.A2 v2(126.45,115.96)
VMA_DQ52: length 14.7
  TOP w0.127: v2(127.42,113.4) 127.42,113.68 127.19,113.91 124.71,113.91 v1(123.35,112.54) 121.16,110.35 118.43,110.35 118.13,110.64 116.94,110.64 v2(116.52,110.22)
  BOTTOM w0.165: U22.AA27 116.42,110.22 v2(116.52,110.22) ; v2(127.42,113.4) 127.42,113.41 VRAM1.B4
