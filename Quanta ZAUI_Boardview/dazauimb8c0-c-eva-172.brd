# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CON_EQ: length 4.7
  BOTTOM w0.102: v1(21.09,24.45) 20.84,24.45 19.87,25.41 R775.1 19.75,25.06 19.9,24.9 R785.2 19.11,24.24 18.7,23.83 U34.18
CPU_C10_GATE#: length 9.9
  BOTTOM w0.079: U24.DU40 78.81,33.28 78.81,32.68
  BOTTOM w0.102: v1(80.39,25.87) R776.1 R762.2 80.9,26.43 79.67,27.67 79.67,31.82 78.81,32.68
CPU_POPI_RCOMP: length 1.7
  TOP w0.254: v2(78.99,47.27) 79.04,47.27 79.59,47.81 R230.2
  BOTTOM w0.254: U24.CJ41 78.99,47.39 v2(78.99,47.27)
CPU_PRDY#: length 1.9
  TOP w0.102: TP14.1 95.46,75.7 94.99,75.23 v2(94.99,75.2)
  BOTTOM w0.114: U24.P6 95.07,75.2 v2(94.99,75.2)
CPU_PREQ#: length 9.7
  TOP w0.102: v2(95.91,74.59) 95.91,75.01 97.95,77.05 97.95,77.28 99.38,78.7 100.8,78.7 101.41,78.09 TP12.1 R129.1
  BOTTOM w0.079: v2(95.91,74.59) 95.91,74.83 95.47,75.26 U24.M6
CPU_SVID_CLK: length 5.5
  BOTTOM w0.079: 99.63,79.49 99.31,79.16 99.31,78.52 98.17,77.39 97.73,77.39 97.45,77.67 U24.H2
  BOTTOM w0.102: R590.1 100.82,80.68 99.63,79.49
CPU_SVID_DAT: length 7.2
  BOTTOM w0.079: 99.03,79.53 98.85,79.35 98.85,78.56 98.32,78.03 97.25,78.03 96.9,77.67 U24.H3
  BOTTOM w0.102: 99.03,79.53 99.03,79.65 99.64,80.26 99.64,81.04 100.85,82.26 R586.1
CPU_VIDALERT#: length 5.3
  BOTTOM w0.079: 99.12,79.31 99.04,79.23 99.04,78.51 98.36,77.83 98.22,77.83 U24.H1
  BOTTOM w0.102: 99.12,79.31 100.04,80.23 100.04,80.71 100.82,81.49 R587.1
CSI_RCOMP: length 5.3
  BOTTOM w0.102: 95.22,81.69 95.22,81.25 95.44,81.02 95.9,81.02 U24.B4
  BOTTOM w0.254: R579.2 93.66,84.21 94.32,83.55 94.32,82.58 95.22,81.69
CTL2: length 1.8
  TOP w0.102: U7.7 23.54,48.88 R225.2
CTL3: length 2.8
  TOP w0.102: U7.8 21.73,50.06 21.97,50.3 v1(22.52,50.3) 22.72,50.1 23.34,50.1 R222.2
DBG_PMODE: length 6.6
  TOP w0.102: v2(90.36,36.97) 90.82,36.51 90.82,35.62 90.69,35.5 R290.1 90.49,35.33 91.29,34.53 TP34.1 91.88,34.4 93.56,34.4 93.69,34.28 R300.1
  BOTTOM w0.102: v2(90.36,36.97) 90.61,36.72 U24.DL15
DC-DET: length 2.9
  TOP w0.102: R375.1 205.97,28.49 v2(205.93,28.54)
  BOTTOM w0.102: U30.4 205.66,28.98 205.93,28.71 v2(205.93,28.54) R752.1
DDCCLK_RIN: length 5.1
  TOP w0.102: Q13.4 23.67,61.19 24.04,60.82 v1(24.73,60.82) 25.59,60.82 26.1,61.33 26.1,61.84 25.97,61.96 R195.2
DDCDATA_RIN: length 2.8
  TOP w0.102: Q13.1 24.97,65.49 25.27,65.8 v1(25.68,65.8) 25.97,65.51 R194.2
DDR4_DRAMRST#: length 165.5
  TOP w0.102: v1(54.43,54.71) 53.94,54.71 53.79,54.57 C293.2 ; v1(32.75,78.95) 32.78,78.98 34.62,78.98 U4.P1 ; v1(32.47,45.66) 32.52,45.6 34.95,45.6 U8.P1 ; R282.2 66.48,36.87 66.13,36.51 C353.2 65.77,35.95 65.77,33.44 65.59,33.26 64.78,33.26 64.43,32.9 v1(64.43,32.54) v1(64.43,31.89) ; U2.P1 35.87,91.11 34.88,92.1 v1(34.85,92.1) ; v1(32.75,59.32) 34.48,59.32 35.87,57.93 U6.P1
  IN1 w0.089: v1(34.85,92.1) 34.27,92.1 33.97,91.81 33.97,90.16 32.83,89.01 32.83,87.92 33.29,87.46 33.29,87.16 32.65,86.52 32.65,85.13 32.4,84.88 32.4,82.69 31.95,82.24 31.95,81.77 32.78,80.94 32.78,78.98 v1(32.75,78.95) 32.75,78.62 32.14,78 32.14,76.26 31.54,75.66 31.54,74.54 31.66,74.41 31.66,73.83 31.96,73.54 31.96,72.02 32.22,71.76 32.22,71.25 32.02,71.04 32.02,69.25 32.4,68.87 32.4,59.68 v1(32.75,59.32) 32.14,58.7 32.14,56.35 31.63,55.85 31.63,53.95 32.05,53.54 32.05,52.08 32.22,51.91 32.22,51.35 31.95,51.07 31.95,49.85 32.27,49.53 32.27,47.94 32.45,47.77 32.45,45.67 v1(32.47,45.66) ; v1(64.43,31.89) 62.32,31.89 61,30.57 51.27,30.57 50.86,30.97 50.86,53.2 51.24,53.58 53.29,53.58 v1(54.43,54.71) 53.92,54.71 53.42,54.22 50.86,54.22 50.25,53.61 50.25,37.98 v2(47.81,35.55)
  BOTTOM w0.102: v1(32.47,45.66) 32.95,45.17 32.95,37.45 36.59,33.82 46.09,33.82 v2(47.81,35.55) ; JDIM1.108 57.42,56.2 56.73,55.51 56.35,55.51 56.07,55.23 54.94,55.23 v1(54.43,54.71)
DDR4_SUSON_2V5: length 316.6
  TOP w0.102: v2(186.83,28.26) 186.8,28.29 186.8,28.46 187.25,28.9 U13.122
  IN1 w0.089: v2(62.9,111.11) 63.05,111.26 63.05,117.33 62.29,118.1 61.66,118.1 61.4,118.35 61.4,119.24 62.37,120.2 62.37,120.6 63.16,121.4 63.16,121.76 64.2,122.79 64.2,124.45 v1(65.33,125.58)
  IN2 w0.089: v2(187.1,19.79) 187.06,19.79 186.8,20.05 181.23,20.05 180.78,20.5 179.15,20.5 178.88,20.77 177.61,20.77 177.46,20.62 173.26,20.62 173.1,20.46 170.6,20.46 170.3,20.16 168.33,20.16 168.15,19.98 162.88,19.98 162.56,20.31 155.31,20.31 155.12,20.12 139.35,20.12 138.41,21.06 125.99,21.06 125.61,20.68 123.84,20.68 123.73,20.79 122.14,20.79 120.2,18.85 114.28,18.85 114,19.12 112.42,19.12 111.59,18.3 105.14,18.3 104.41,17.56 91.27,17.56 88.23,20.61 84.23,20.61 80.33,16.71 73.97,16.71 73.24,15.99 70.71,15.99 70.61,15.89 64.29,15.89 60.66,19.52 58.27,19.52 57.51,20.28 54.01,20.28 52.84,21.45 51.52,21.45 50.38,20.31 48.84,20.31 47.68,21.47 47.68,22.71 45.88,24.51 45.88,24.7 45.64,24.94 41.97,24.94 39.27,27.64 35.43,27.64 34.66,28.41 28.31,28.41 27.49,29.23 27.49,32.85 24,36.34 24,49.72 24.6,50.32 24.6,50.75 24.85,51.01 25.25,51.01 25.44,51.2 25.44,60.93 24.99,61.39 24.99,61.99 25.29,62.29 25.29,73.79 25.03,74.05 25.03,81.51 26,82.49 26,83.88 25.55,84.33 24.92,84.33 24.33,84.92 24.33,87.12 26.96,89.74 26.96,92.06 29.48,94.59 29.48,95.79 31.68,97.99 43.61,97.99 44.51,98.89 47.74,98.89 49.55,100.69 49.55,100.92 51.1,102.47 51.1,103.36 51.76,104.02 53.93,106.19 53.93,106.45 55.05,107.57 55.95,107.57 56.09,107.72 56.09,108.81 56.58,109.29 56.58,110.15 57.43,111 62.39,111 62.5,111.11 v2(62.9,111.11)
  BOTTOM w0.102: v2(186.83,28.26) 186.96,28.26 187.16,28.06 187.16,25.23 187.4,24.99 187.4,22.82 187.77,22.45 187.77,20.46 v2(187.1,19.79)
  BOTTOM w0.152: v1(65.33,125.58) 65.33,125.4 PR124.1
DDR_DRAMRST#_R: length 10.1
  TOP w0.102: v2(69.53,37.55) 69,38.09 R278.2 66.58,37.7 66.48,37.6 R282.1
  BOTTOM w0.079: U24.DK47 75.07,37.71 74.81,37.71 74.71,37.77 74.59,37.77 74.47,37.71 73.97,37.71 73.94,37.74 73.51,37.74 73.29,37.53 72.93,37.53 72.62,37.22 69.86,37.22 v2(69.53,37.55)
DDR_RCOMP0: length 8
  BOTTOM w0.102: U24.D47 75.13,79.74 74.74,79.74 74.56,79.92 74.18,79.92 73.93,80.17 72.91,80.17 72.83,80.25
  BOTTOM w0.254: 72.83,80.25 72.71,80.38 72.71,81.19 72.63,81.27 72.63,81.6
  BOTTOM w0.381: 72.63,81.6 72.5,81.72 72.5,84.77 72.77,85.04 R576.2
DDR_RCOMP1: length 10.1
  BOTTOM w0.102: U24.E46 75.78,79.39 75.63,79.25 75.11,79.25 74.89,79.46 74.64,79.46 74.49,79.31 74.02,79.31 73.69,79.64 72.45,79.64 72.35,79.74 72.2,79.74
  BOTTOM w0.254: 72.2,79.74 71.56,80.38 71.56,80.89
  BOTTOM w0.381: R575.2 71.72,84.96 71.72,81.04 71.56,80.89
DDR_RCOMP2: length 6.4
  BOTTOM w0.102: 75.12,81.71 75.12,81.23 75.28,81.08 75.28,80.52 U24.C47
  BOTTOM w0.254: 75.12,81.71 75.05,81.79 74.57,81.79 74.44,81.91
  BOTTOM w0.381: 74.44,81.91 73.51,82.85 R577.2
DDR_VTT_CTRL: length 20.2
  TOP w0.102: v2(78.95,75.81) 78.95,75.96 79.34,76.34 79.97,76.34 80.2,76.57 80.2,77.76 79.79,78.17 75.87,78.17 74.31,79.73 74.31,80.81 73.19,81.93 71.44,81.93 70.55,82.82 v2(70.55,82.84)
  BOTTOM w0.076: v2(78.95,75.81) 79.3,75.46 U24.M39
  BOTTOM w0.102: v2(70.55,82.84) 70.65,82.94 70.65,83.83 69.78,84.7 69.4,84.7 TP59.1
DE1: length 5.2
  TOP w0.102: U17.9 207.49,15.87 207.22,15.61 R466.2 207.04,15.77 206.67,16.14 205.65,16.14 v1(205.42,15.91) 205.19,16.14 204.94,16.14 204.76,15.96 R465.1
DE2: length 4.8
  TOP w0.102: R461.1 205.24,16.67 205.55,16.37 206.94,16.37 207.04,16.47 R460.2 207.33,16.75 207.71,16.37 v1(207.83,16.37) U17.8
DEVSLP0: length 147.7
  IN1 w0.089: v2(207.88,16.98) 207.88,18.53 207.66,18.76 207.66,22.75 207.52,22.89 205.38,22.89 204.81,23.46 204.23,23.46 204.18,23.51 203.39,23.51 202.96,23.07 200.62,23.07 200.19,23.51 198.1,23.51 197.84,23.25 196.74,23.25 195.16,24.84 195.16,25.26 194.19,26.22 191.5,26.22 191.16,26.57 186.92,26.57 186.07,25.72 v2(186.07,25.56)
  IN2 w0.089: v2(186.07,25.56) 185.78,25.28 183.45,25.28 182.35,26.38 179.67,26.38 178.5,27.55 177.37,27.55 177.17,27.75 175.29,27.75 174.91,28.13 171.1,28.13 170.78,28.45 160.39,28.45 160.13,28.71 158.79,28.71 158.32,29.18 155.35,29.18 155.01,29.51 151.44,29.51 150.98,29.97 141.75,29.97 141.39,30.33 140.37,30.33 140.18,30.14 135.74,30.14 135.39,30.49 132.95,30.49 132.4,31.05 130.34,31.05 128.41,29.12 125.51,29.12 124.76,28.37 113.23,28.37 110.68,25.82 107.74,25.82 107.3,25.39 105.22,25.39 105.07,25.54 101.39,25.54 101.1,25.25 101.1,24.03 100.46,23.39 95.49,23.39 94.96,23.93 93.41,23.93 93.15,24.18 v2(93.15,24.47)
  BOTTOM w0.079: 94.49,29.52 94.46,29.55 94.42,29.55 93.42,30.55 93.42,30.97 92.65,31.74 92.65,32.25 92.43,32.46 92.43,32.7 92.5,32.84 92.5,33.05 92.44,33.18 92.24,33.38 U24.DU12
  BOTTOM w0.102: v2(207.88,16.98) 208.62,16.98 209.64,15.96 209.64,15.2 v1(210.48,14.36) 210.88,13.96 211.01,13.96 211.49,13.47 R837.2 ; 94.49,29.52 94.74,29.26 R742.1 94.86,28.74 95.21,28.38 95.21,26.15 94.93,25.87 94.7,25.87 94.07,25.24 93.97,25.24 93.4,24.67 93.33,24.67 93.15,24.5 v2(93.15,24.47)
DEVSLP0_R: length 2.4
  BOTTOM w0.102: HD1.5 213.3,14.32 212.56,13.58 212.07,13.58 R837.1
DEVSLP1: length 6.5
  BOTTOM w0.079: 94.99,30.28 93.32,31.95 93.32,32.78 93.24,32.93 93.22,32.94 93.22,33.6 U24.DU11
  BOTTOM w0.102: 94.99,30.28 95.27,30.28 96.35,29.2 R737.1
DEVSLP2: length 80.1
  TOP w0.102: v1(31.94,4.69) 31.66,4.4 R498.2 ; v1(47.79,10.3) 48.37,10.88 48.37,11.49 48.47,11.59 51.23,11.59 51.84,12.2 51.84,14.35 52.92,15.43 52.92,17.84 53.4,18.33 53.4,20.35 53.61,20.55 53.61,23.93 v1(53.84,24.17) 55.31,25.64 60.4,25.64 61.45,26.7 61.45,28.15 60.51,29.09 60.51,43.42 60.84,43.75 61.58,43.75 61.88,43.45 R258.1 62.24,43.45 62.72,43.93 64.14,43.93 64.29,44.08 69.25,44.08 69.81,43.52 69.81,43.14 70.36,42.59 v2(71.33,42.59)
  IN3 w0.089: v1(47.79,10.3) 47.79,10.27 46.99,9.47 44.04,9.47 42.95,8.38 41.6,8.38 39.72,6.51 39.72,6.06 38.58,4.91 37.91,4.91 37.43,4.43 32.83,4.43 32.57,4.69 v1(31.94,4.69)
  BOTTOM w0.079: U24.CV48 74.96,43.1 74.56,43.5 74.08,43.5 73.61,43.04 72.96,43.04
  BOTTOM w0.102: v2(71.33,42.59) 72.51,42.59 72.96,43.04
DEW1: length 12.1
  TOP w0.102: U17.16 212.78,15.07 v1(212.53,14.82) ; v1(205.5,13.14) 204.89,13.14 204.76,13.01 R481.1 204.91,12.81 205.12,12.61 205.12,12.41 205.45,12.08 205.98,12.08 206.11,11.95 v2(206.64,11.95) 207.02,12.33 R485.2
  IN2 w0.089: v2(206.64,11.95) 206.64,12.43 209.03,14.82 v1(212.53,14.82)
DEW2: length 5
  TOP w0.102: R435.1 205.27,19.16 205.45,19.34 v1(205.93,19.34) 206.03,19.24 206.79,19.24 207.04,18.99 R436.2 207.33,18.88 208.52,17.69 208.52,17.47 208.62,17.37 U17.6
DGPU_EDIDCLK: length 7
  BOTTOM w0.102: U22.A9 100.93,93.02 100.93,91.78 100.3,91.15 99.87,91.15 98.81,90.09 97.22,90.09 96.79,89.66 96.79,89.34 96.69,89.24 R561.1
DGPU_EDIDDATA: length 8.5
  BOTTOM w0.102: U22.B9 100.91,93.6 100.54,93.23 100.54,92.88 100.7,92.72 100.7,91.87 100.2,91.38 99.77,91.38 98.71,90.32 97.13,90.32 96.63,89.82 96.05,89.82 R560.1
DGPU_HOLD_RST#: length 113
  TOP w0.102: v1(85.66,92.57) 85.28,92.95 83.63,92.95 83.37,93.2 83.37,94.35 83.86,94.83 83.86,95.72 84.26,96.13 86.73,96.13 87.19,96.59 88.59,96.59 88.99,96.99 90.71,96.99 93.69,99.96 v2(93.79,99.96)
  IN1 w0.089: v1(84.49,87.18) 83.75,87.92 83.75,89.6 85.66,91.5 v1(85.66,92.57)
  IN3 w0.089: v1(92.9,115.3) 92.77,115.18 92.77,112.13 91.91,111.26 91.91,106.23 93.15,104.99 93.15,100.44 93.61,99.99 93.74,99.99 93.76,99.96 v2(93.79,99.96) ; v1(84.49,87.18) 84.49,87.03 85.13,86.4 85.13,82.89 84.26,82.03 84.26,73 82.44,71.17 81.42,71.17 81.02,70.77 81.02,54.46 80.58,54.02 80.58,51.44 79.87,50.73 76.59,50.73 74.08,48.22 74.08,48.17 73.49,47.59 72.63,47.59 v2(72.6,47.61)
  BOTTOM w0.079: U24.CH48 74.49,48.31 74.41,48.34 74.17,48.34 73.47,47.64 72.63,47.64 v2(72.6,47.61) 72.44,47.44 72.44,47.37 71.44,46.38 71.34,46.38 71.33,46.37 70.75,46.37 68.98,44.6 68.64,44.6
  BOTTOM w0.102: 68.64,44.6 66.21,44.6 66,44.39 63.03,44.39 62.77,44.13 R659.2 ; v1(92.9,115.3) 92.9,116.32 91.88,117.33 91.88,118.45 95.44,122.01 v1(95.44,122.41) 95.44,122.67 95.81,123.03 U19.1
DGPU_OPP#: length 11.5
  TOP w0.102: R480.1 201.98,12.7 202.37,12.31 v2(202.37,11.82) 202.37,11.82 Q25.3 ; U13.71 199.8,18.18 v2(200.02,18.4) v1(200.63,18.4)
  IN1 w0.089: v2(200.02,18.4) 200.47,17.96 200.47,17.13 200.75,16.85 200.75,15.93 201.18,15.5 201.18,15.3 202.37,14.11 v2(202.37,11.82)
DGPU_OVT#_EC: length 216.1
  TOP w0.102: v1(96.33,122.41) 96.33,122.54 96.58,122.8 96.58,123.43 v1(96.84,123.68) 97.09,123.94 Q1.3 99.33,123.94 100.21,123.05 R3.1 ; v2(186.88,21.7) 186.57,21.4 186.57,21.31 186,20.74 184.24,20.74 184.08,20.58 U13.20
  IN2 w0.089: v2(197.57,23.96) 197.19,23.58 196.1,23.58 195.57,23.06 193.28,23.06 193.18,22.95 191.41,22.95 190.53,22.07 189.23,22.07 188.86,21.7 v2(186.88,21.7)
  IN3 w0.089: v2(197.57,23.96) 197.57,24.22 197.38,24.41 196.87,24.41 196.28,25.01 196.28,25.39 195.61,26.05 195.35,26.05 195.06,26.34 193.86,26.34 192.87,27.34 192.87,28.68 191.65,29.9 187.24,29.9 187.13,30.01 183.56,30.01 183,29.44 180.02,29.44 179.54,29.93 175.58,29.93 174.75,30.76 170.13,30.76 169.83,30.46 166.32,30.46 165.96,30.1 164.43,30.1 163.85,30.69 162.22,30.69 161.44,29.91 160.35,29.91 159.57,30.69 158.52,30.69 157.66,31.55 155.3,31.55 154.17,32.68 146.77,32.68 145.92,31.84 143.85,31.84 143.14,32.55 143.14,32.9 142.39,33.65 142.39,35.68 142.76,36.05 142.76,37.71 142.43,38.04 142.43,38.53 143.65,39.74 143.65,39.95 143.81,40.11 143.81,43.14 144.33,43.66 144.33,45.09 144.7,45.45 144.7,46.47 145.85,47.62 145.85,49.9 146.51,50.55 146.51,53.74 145.41,54.84 145.41,56.31 144.44,57.28 144.44,58.8 142.86,60.38 142.86,63.28 143.57,63.99 143.57,64.48 143.19,64.86 143.19,65.62 142.91,65.9 142.91,76.91 138.58,81.24 129.6,81.24 128.85,81.98 126.03,81.98 124.88,83.13 124.88,84.99 121.87,88 111.08,88 108.86,90.22 105.94,90.22 104.79,91.38 104.79,92.54 104.38,92.95 103.69,92.95 102.93,93.71 100.88,93.71 100.08,94.52 99.55,94.52 98.87,95.2 98.87,96.16 98.68,96.35 98.68,97.66 97.34,99 97.34,101.43 96.38,102.39 96.38,112.36 96.84,112.81 96.84,117.71 95.45,119.11 95.45,122.04 95.82,122.41 v1(96.33,122.41)
  BOTTOM w0.102: R791.1 197.85,23 197.72,23.13 197.72,23.79 197.57,23.94 v2(197.57,23.96)
DGPU_PROCHOT_EC#: length 199.8
  TOP w0.102: Q25.1 199.81,11.29 199.81,11.98 200.08,12.25 R479.1 200.69,13.55 203.01,13.55 203.24,13.78 203.24,15.45 v1(203.16,15.53) 203.24,15.61 203.24,18.05 203.11,18.17 202.58,18.17 v2(202.5,18.1)
  IN1 w0.089: v2(99.68,95.85) 99.36,95.85 98.92,95.41 98.92,91.55 97.39,90.02 97.39,87.32 97.83,86.87 97.83,85.12 98.51,84.44 103.06,84.44 104.46,85.84 110.29,85.84 111.31,86.85 115.63,86.85 116.19,86.3 116.19,82.76 118.07,80.89 122.64,80.89 123.79,82.03 124.8,82.03 125.94,80.89 128.51,80.89 129.3,80.09 140.07,80.09 143.14,77.02 143.14,65.59 143.57,65.16 143.57,61.84 144.18,61.23 144.18,59.96 144.59,59.55 144.59,56 146.24,54.34 146.24,47.92 144.59,46.26 144.59,41.95 144.92,41.62 144.92,40.75 v2(145.05,40.63)
  IN3 w0.089: v2(145.05,40.63) 144.59,40.17 144.59,38.21 143.44,37.07 143.44,35.67 143.57,35.55 143.57,34.91 143.32,34.66 143.32,33.56 143.72,33.16 143.72,32.85 144.08,32.5 145.73,32.5 146.49,33.26 154.49,33.26 155.63,32.12 158.04,32.12 158.91,31.26 167.84,31.26 168.2,31.62 174.99,31.62 175.91,30.69 179.95,30.69 180.4,30.24 182.56,30.24 183.62,31.29 184.01,31.29 184.53,31.81 186.99,31.81 188.08,32.9 189.11,32.9 189.27,33.06 189.64,33.06 190.16,32.55 192.14,32.55 194.11,30.58 194.62,30.58 196.3,28.9 196.3,28.65 197.04,27.91 197.04,27.42 197.17,27.29 201.07,27.29 203.82,24.54 203.82,23.99 203.22,23.39 203.22,22.78 203.36,22.64 203.36,21.73 204.02,21.07 204.02,19.62 202.55,18.15 202.55,18.12 202.53,18.1 v2(202.5,18.1)
  BOTTOM w0.102: v2(99.68,95.85) 99.26,95.43 U22.D7
DGPU_PSI: length 44.6
  TOP w0.254: PR13.1 70.64,115.47 v1(70.67,115.51)
  IN1 w0.089: v1(70.67,115.51) 72.3,115.51 72.58,115.23 72.58,114.31 72.15,113.88 70.6,113.88 69.68,112.96 69.68,108.5 70.44,107.74 71.76,107.74 72.55,106.95 73.03,106.95 74.68,105.3 74.68,105.2 75.72,104.16 76.45,104.16 77.01,103.6 83.32,103.6 87.56,99.35 87.56,95.44 88.83,94.18 88.83,90.52 v1(88.97,90.37)
  BOTTOM w0.102: R549.1 89.52,90.92 v1(88.97,90.37) 88.75,90.37 88.56,90.56 R550.1
DGPU_PW_CTRL#: length 24.1
  TOP w0.102: v2(80.36,44.54) 80.36,44.39 79.82,43.85 79.81,43.85 79.37,43.41 79.37,42.16 79.82,41.72 79.82,41.41 80.33,40.91 80.33,39.1 80.06,38.84 80.06,36.51 79.28,35.73 79.28,34.9 78.7,34.32 78.7,29.98 78.52,29.81 78.52,26.33 R388.2 78.56,26.02 78.42,26.02 78.29,25.89 78.29,24.67 78.39,24.57 v1(78.5,24.57) 78.29,24.37 78.29,23.72 R409.2
  BOTTOM w0.102: v2(80.36,44.54) 80.36,44.66 80.04,44.98 U24.CR38
DGPU_PWR_EN: length 188.4
  TOP w0.102: v1(68.34,45.27) 68.29,45.33 68.11,45.33 68.03,45.4 R245.1 66.36,45.08 66.2,44.92 63.2,44.92 R244.2 ; v1(83.88,93.46) 84.09,93.66 84.09,95.62 84.36,95.9 86.83,95.9 87.29,96.36 88.69,96.36 89.09,96.76 91.07,96.76 93.69,99.38 v2(93.79,99.38) ; v1(25.33,86.73) 24.95,86.73 PR38.2
  IN1 w0.089: v1(82.23,87.87) 82.48,88.12 82.48,92.06 v1(83.88,93.46) 81.09,93.46 80.33,94.22 80.33,95.11 79.89,95.54 78.88,95.54 77.66,96.77 63.69,96.77 63.68,96.77 63.56,96.89 62.16,96.89 62.1,96.82 56.66,96.82 56.43,97.05 56.07,97.05 54.91,98.21 53.88,98.21 52.84,97.17 51.39,97.17 49.08,94.86 45.1,94.86 44.11,95.85 31.41,95.85 27.54,91.98 27.54,88.6 25.66,86.73 v1(25.33,86.73)
  IN3 w0.089: v1(82.23,87.87) 82.66,87.44 83.3,87.44 83.5,87.24 83.5,85.6 84.33,84.77 84.33,83.17 83.5,82.34 83.5,76.21 82.99,75.7 82.1,75.7 81.82,75.42 81.82,75.02 81.42,74.61 81.42,74.05 80.26,72.9 80.26,55.45 80.05,55.24 78.92,55.24 78.15,54.47 76.77,54.47 76.51,54.21 76.51,53.46 76.17,53.13 76.17,52.36 71.78,47.97 71.78,47.33 69.72,45.27 v1(68.34,45.27) ; v1(93.41,114.29) 93.01,113.89 93.01,111.97 92.12,111.08 92.12,107.06 93.53,105.65 93.53,101.33 94.3,100.57 94.3,99.86 93.82,99.38 93.79,99.38 v2(93.79,99.38)
  BOTTOM w0.079: 68.64,45.33 69.18,45.33 70.6,46.75 71.33,46.75 71.92,47.33 71.92,48.12 72.32,48.51 73.08,48.51 73.33,48.77 73.75,48.77 73.93,48.95 74.54,48.95 74.68,49.09 74.79,49.09 74.86,49.01 75.25,49.01 75.59,49.35 U24.CF47
  BOTTOM w0.102: R510.1 99.78,118.22 98.1,119.9 94.25,119.9 93.79,119.44 93.79,114.54 93.53,114.29 v1(93.41,114.29) ; v1(68.34,45.27) 68.39,45.27 68.44,45.33 68.64,45.33
DGPU_PWROK: length 139.7
  TOP w0.102: R175.1 142.43,71.72 142.17,71.97 v1(139.69,71.97) 139,71.97 v1(138.73,72.24)
  IN1 w0.089: v1(138.73,72.24) 138.73,69.67 138.06,69 132.78,69 126.38,75.4 114.49,75.4 111.26,78.62 108.23,78.62 v1(108.06,78.79)
  IN2 w0.089: v1(108.06,78.79) 105.74,78.79 104.15,77.2 101.87,77.2 99.83,79.23 97.78,79.23 95.75,81.27 94.91,81.27 90.38,85.79 87.84,85.79 86.02,87.62 v1(85.48,87.62)
  IN3 w0.089: v1(85.48,87.62) 85.46,87.59 84.19,87.59 84.07,87.48 84.07,85.84 84.9,85.01 84.9,82.94 84.07,82.11 84.07,73.07 82.36,71.36 81.34,71.36 80.83,70.85 80.83,54.54 80.39,54.1 80.39,52.06 80.01,51.68 76.9,51.68 76.64,51.42 76.64,51.08 73.87,48.31 73.87,48.26 73.62,48 73.05,48 v2(73.02,48.02)
  BOTTOM w0.079: U24.CH45 76.04,48.11 75.75,48.4 74.83,48.4 74.43,48.51 74.08,48.51 73.44,47.87 73.18,47.87 v2(73.02,48.02) 72.99,48.05 72.48,48.05 72.1,47.66 72.1,47.27 71.37,46.54 71.26,46.54
  BOTTOM w0.102: R658.1 60.75,44.62 65.9,44.62 66.13,44.84 68.97,44.84 70.67,46.54 71.26,46.54 ; Q31.2 85.85,88.69 85.48,88.33 v1(85.48,87.62)
DISP_ON: length 5.5
  BOTTOM w0.102: U23.3 80.32,99.11 81.09,98.33 81.09,97.42 80.86,97.19 80.86,96.58 81.22,96.22 R535.2 R536.1
DISP_UTILS: length 8.5
  BOTTOM w0.079: U24.D2 97.82,79.93 98.17,79.93 98.55,80.31
  BOTTOM w0.102: 98.55,80.31 98.65,80.42 98.65,81.91 100.67,83.93 102.3,83.93 102.37,84.01 TP64.1
DMIC-DATA34: length 0.9
  TOP w0.102: TP36.1 209.24,30.48 209.1,30.63 R338.1
DMIC_CLK: length 1.8
  BOTTOM w0.102: U30.3 206.06,28.99 206.79,28.26 R749.2
DMIC_CLK_2: length 167.5
  TOP w0.102: v1(79.06,21.07) v1(79.84,21.86) 79.84,24.12 R395.1
  IN1 w0.089: v1(35.75,115.18) 35.76,115.19 39.19,115.19 39.82,115.82 40.39,115.82 41.58,114.63 41.58,109.04 42.71,107.91 42.71,106.97 41.59,105.85 41.59,104.17 41.22,103.8 41.22,101.68 v1(41.06,101.51) ; v2(29.27,65.24) 29.04,65.24 28.62,64.81 28.62,57 27.79,56.17 27.79,40.21 28,40 28,39.01 31.47,35.54 35.75,35.54 36.54,34.75 43.08,34.75 45.74,32.08 45.74,31.69 50.11,27.32 50.11,26.42 51.11,25.43 51.64,25.43 53.27,23.79 53.27,22.74 56.25,19.77 v1(56.25,19.24)
  IN3 w0.089: v1(79.06,21.07) 78.38,21.74 76.81,21.74 75.91,20.84 75.05,20.84 74.22,20.01 69.12,20.01 68.34,19.24 v1(56.25,19.24) ; v2(29.27,65.24) 29.08,65.43 28.75,65.43 27.83,66.35 27.83,71.73 24.68,74.88 24.68,76.01 22.75,77.94 22.75,84.41 24.08,85.73 24.08,87.35 25.54,88.81 26.27,88.81 27.03,89.57 27.03,92.01 28.74,93.72 28.74,96.01 31.81,99.09 40.26,99.09 41.11,99.94 41.11,101.46 v1(41.06,101.51)
  BOTTOM w0.102: CN1.3 35.5,115.42 v1(35.75,115.18)
DMIC_CLK_2_R: length 15.4
  TOP w0.102: R395.2 80.38,25.34 81.54,26.5 81.54,27.26 81.55,27.26 ; 81.55,27.26 81.5,27.26 81.42,27.34 81.42,28.6 C383.2 81.46,28.79 80.58,29.67 80.58,33.16 81.01,33.59 81.01,37.78 v2(80.45,38.34) ; 81.55,27.26 v1(81.85,27.26)
  BOTTOM w0.079: U24.DG36 80.78,38.67 v2(80.45,38.34)
DMIC_CLK_L: length 300.8
  IN1 w0.089: v2(87.13,119.37) 87.13,120.03 85.71,121.45 85.71,122.77 84.9,123.58 78.5,123.58 76.07,126.01 51.36,126.01 51.08,125.73 51.08,124.36 48.68,121.96 46.01,121.96 45.71,121.66 45.71,118.12 48.32,115.51 48.32,112.64 49.46,111.49 49.46,109.1 48.55,108.19 48.55,107.91 47.81,107.17 44.72,107.17 43.11,105.57 43.11,103.52 42.73,103.14 42.73,102.4 42.35,102.02 v2(42.15,102.02)
  IN3 w0.089: v2(207.35,27.27) 205.75,27.27 205.32,26.83 205.32,23.84 205.78,23.37 205.78,22.57 204.89,21.68 204.89,19.26 203.62,17.99 203.62,16.85 202.4,15.63 199.42,15.63 198.91,16.14 198.91,22.57 198.37,23.11 197.09,23.11 197,23.19 196.65,23.19 194.95,24.89 194.95,25.19 194.66,25.48 193.5,25.48 193.14,25.84 191.53,25.84 190.73,26.64 190.73,27.88 189.57,29.04 186.88,29.04 186.77,29.15 183.92,29.15 182.92,28.14 180.06,28.14 179.14,29.06 175.2,29.06 174.36,29.9 170.49,29.9 170.19,29.6 166.73,29.6 166.32,29.18 163.29,29.18 163.15,29.05 159.99,29.05 159.21,29.82 158.14,29.82 157.89,30.08 156.88,30.08 156.27,30.69 154.94,30.69 153.81,31.82 147.13,31.82 146.28,30.97 142.84,30.97 141.53,32.28 141.53,36.04 141.9,36.41 141.9,37.35 141.54,37.71 141.54,38.86 142.39,39.71 142.39,43.54 143.27,44.42 143.27,46.34 144.42,47.49 144.42,48.3 144.99,48.88 144.99,50.81 145.64,51.46 145.64,53.34 144.11,54.87 144.11,56.39 143.58,56.92 143.58,58.44 142,60.03 142,62.28 141.21,63.07 141.21,64.81 141.46,65.07 141.46,68.05 141.29,68.22 141.29,68.95 140.75,69.48 140.75,71.97 141.44,72.66 141.44,76.28 138.04,79.68 129.4,79.68 128.56,80.52 118.03,80.52 115.48,83.07 115.48,84.7 115.19,84.99 112.33,84.99 108.34,88.98 105.42,88.98 103.55,90.85 103.25,90.85 102.9,91.2 101.63,91.2 99.56,93.27 99.04,93.27 98.15,94.16 97.76,94.16 96.29,95.63 96.29,100.99 95.32,101.95 95.32,113.24 95.74,113.66 95.74,115.94 94.35,117.33 88.68,117.33 87.34,118.68 87.34,119.16 v2(87.13,119.37)
  BOTTOM w0.102: C663.2 207.83,26.78 v2(207.35,27.27) 207.02,27.6 R749.1 ; L11.2 41.34,102.83 v2(42.15,102.02)
DMIC_CLK_L_C: length 5.1
  BOTTOM w0.102: L11.1 C528.1 41.79,105.46 41.79,106.23 42.2,106.64 43.6,106.64 43.6,106.64 43.75,106.64 43.85,106.74 CN2.1
DMIC_DAT: length 2.4
  BOTTOM w0.102: U30.2 206.46,29.05 206.67,28.84 207.05,28.84 207.19,28.98 207.55,28.98 R745.1
DMIC_DAT_2: length 169.4
  TOP w0.102: v1(78.42,20.99) 78.42,21.25 78.75,21.58 78.99,21.58 79.44,22.02 79.44,24.42 R394.1
  IN1 w0.089: v1(55.59,19.24) 55.59,19.87 52.88,22.58 52.88,23.62 51.47,25.03 50.94,25.03 49.72,26.26 49.72,27.16 45.35,31.53 45.35,31.91 42.91,34.35 36.38,34.35 35.58,35.15 31.31,35.15 27.6,38.86 27.6,39.85 27.4,40.05 27.4,56.34 28.22,57.16 28.22,64.98 28.88,65.63 29.08,65.63 v2(29.27,65.82) ; v1(34.99,115.18) 35.39,115.58 39.03,115.58 39.66,116.22 40.55,116.22 41.97,114.79 41.97,109.21 43.1,108.08 43.1,106.81 41.98,105.69 41.98,104 41.62,103.64 41.62,101.66 v1(41.69,101.59)
  IN3 w0.089: v1(55.59,19.24) 56.08,18.74 56.36,18.74 56.46,18.85 68.51,18.85 69.28,19.62 74.38,19.62 75.21,20.45 76.07,20.45 76.97,21.35 78.01,21.35 78.37,20.99 v1(78.42,20.99) ; v2(29.27,65.82) 28.91,65.82 28.22,66.51 28.22,71.9 25.07,75.05 25.07,76.17 23.15,78.1 23.15,84.25 24.47,85.57 24.47,87.18 25.71,88.42 26.43,88.42 27.44,89.42 27.44,91.86 29.14,93.56 29.14,95.86 31.98,98.69 40.55,98.69 41.5,99.64 41.5,101.4 v1(41.69,101.59)
  BOTTOM w0.102: CN1.2 34.7,115.46 v1(34.99,115.18)
DMIC_DAT_2_R: length 15.9
  TOP w0.102: v2(80.45,37.04) 80.47,37.04 80.82,36.69 80.82,33.98 80.17,33.34 80.17,29.5 81.01,28.66 81.01,26.6 v1(80.82,26.41) 79.97,25.56 79.97,25.36 79.72,25.1 R394.2
  BOTTOM w0.079: U24.DG34 81.21,38.17 81.21,37.12 81.14,37.04 v2(80.45,37.04)
DMIC_DAT_L: length 299.3
  IN1 w0.089: v2(42.34,102.61) 42.3,102.65 42.3,103.44 42.61,103.75 42.61,105.62 44.56,107.58 47.59,107.58 48.14,108.14 48.14,108.34 48.83,109.03 48.83,111.49 47.92,112.41 47.92,115.35 45.31,117.96 45.31,121.83 46.82,123.33 49.49,123.33 50.68,124.52 50.68,125.89 51.2,126.41 76.23,126.41 78.66,123.98 85.06,123.98 86.1,122.93 86.1,121.61 87.74,119.98 v2(87.74,119.37)
  IN3 w0.089: v2(87.74,119.37) 87.74,118.83 88.85,117.73 94.71,117.73 96.15,116.29 96.15,113.4 95.72,112.97 95.72,102.12 96.68,101.15 96.68,95.79 97.92,94.56 98.31,94.56 99.2,93.67 99.72,93.67 101.79,91.6 103.07,91.6 103.41,91.25 103.71,91.25 105.59,89.37 108.5,89.37 112.5,85.38 115.35,85.38 115.87,84.86 115.87,83.23 118.19,80.91 128.72,80.91 129.56,80.07 138.21,80.07 141.84,76.43 141.84,72.43 141.16,71.74 141.16,69.71 141.79,69.07 141.79,68.27 141.86,68.21 141.86,64.9 141.6,64.65 141.6,63.23 142.39,62.44 142.39,60.19 143.97,58.61 143.97,57.08 144.51,56.55 144.51,55.03 146.04,53.5 146.04,51.29 145.39,50.64 145.39,48.71 144.81,48.14 144.81,47.33 143.66,46.18 143.66,44.26 142.78,43.38 142.78,39.55 141.93,38.69 141.93,37.87 142.29,37.51 142.29,36.25 141.92,35.88 141.92,32.45 143,31.37 146.12,31.37 146.96,32.21 153.98,32.21 155.11,31.08 156.43,31.08 157.04,30.47 158.05,30.47 158.3,30.22 159.38,30.22 160.15,29.44 162.99,29.44 163.12,29.58 166.16,29.58 166.57,29.99 170.02,29.99 170.33,30.29 174.53,30.29 175.37,29.46 179.3,29.46 180.22,28.54 182.75,28.54 183.76,29.54 186.93,29.54 187.04,29.43 189.73,29.43 191.13,28.04 191.13,26.8 191.69,26.24 193.31,26.24 193.67,25.87 194.82,25.87 195.34,25.35 195.34,25.05 196.81,23.58 197.17,23.58 197.25,23.5 198.54,23.5 199.31,22.73 199.31,16.3 199.58,16.03 202.23,16.03 203.21,17.01 203.21,18.15 204.49,19.43 204.49,21.84 205.39,22.74 205.39,23.13 204.91,23.61 204.91,26.98 205.59,27.66 206.4,27.66 v2(207.2,28.46)
  BOTTOM w0.102: v2(207.2,28.46) 207.2,28.26 207.72,27.74 R745.2 ; v2(42.34,102.61) 42.48,102.75 L12.2
DMIC_DAT_L_C: length 5.4
  BOTTOM w0.102: L12.1 C529.1 42.05,105.44 42.05,106.13 42.31,106.39 44.22,106.39 44.35,106.51 CN2.2
DNBSWON#: length 124.6
  TOP w0.102: v2(185.86,27.75) 185.86,27.81 185.84,27.83 185.84,28.08 186.85,29.09 U13.123
  IN1 w0.089: v2(78.34,41.78) 78.54,41.78 78.98,42.23 79.72,42.23 80.12,41.82 80.12,39.48 80.86,38.75 80.86,35.6 81.29,35.16 81.29,34.94 81.61,34.63 81.61,34.46 82.48,33.58 86.02,33.58 86.45,34.02 87.82,34.02 88.15,33.69 93.03,33.69 93.72,33 96.9,33 97.96,31.94 101.65,31.94 101.84,31.75 108.35,31.75 109.1,31 110.47,31 112.7,28.76 123.15,28.76 126.03,31.65 132.19,31.65 132.5,31.33 137.12,31.33 137.28,31.49 138.61,31.49 139.15,30.95 139.74,30.95 139.92,31.13 143.82,31.13 144.88,30.07 150.32,30.07 150.96,29.42 153.14,29.42 153.47,29.09 155.45,29.09 155.62,28.92 162.15,28.92 162.57,28.5 169.04,28.5 170.62,26.91 173.65,26.91 174.21,26.35 174.92,26.35 175.72,27.14 177.18,27.14 177.23,27.09 183.25,27.09 184.02,27.86 185.76,27.86 v2(185.86,27.75)
  BOTTOM w0.102: v2(78.34,41.78) 78.28,41.78 78,42.06 U24.CY42
DP_RCOMP: length 6.6
  BOTTOM w0.079: 100.47,74.61 100.37,74.51 99.56,74.51 99.12,74.07 98.45,74.07 98.16,73.77 97.72,73.77 97.43,74.07 U24.R2
  BOTTOM w0.102: 100.47,74.61 101.23,74.61
  BOTTOM w0.254: 101.23,74.61 101.66,74.61 101.99,74.28 101.99,73.54 102.3,73.24 R610.1
DSI_DE_TE_2: length 5.2
  BOTTOM w0.079: U24.J3 97.48,77.11 97.53,77.06 98.36,77.06 99.65,78.35 99.65,78.6 100.09,79.03
  BOTTOM w0.102: R593.1 101.03,79.62 100.44,79.03 100.09,79.03
EC_FPBACK#: length 214.8
  TOP w0.102: Q3.2 59.43,110.79 58.79,110.15 v1(58.79,109.71) ; U13.86 199.62,24.18 199.86,24.42 200.9,24.42 v2(201.38,24.9)
  IN2 w0.089: v2(201.38,24.9) 201.76,25.28 201.89,25.28 202.35,25.74 202.35,26.3 201.97,26.68 199.9,26.68 196.02,30.57 184.11,30.57 183.67,31.01 179.69,31.01 179.14,31.56 176.73,31.56 175.34,32.95 167.41,32.95 167.19,32.72 166.06,32.72 165.86,32.92 164.73,32.92 163.95,33.7 163.81,33.7 163.45,34.07 162.55,34.07 161.72,34.9 159.19,34.9 158.91,35.18 156.74,35.18 156.12,34.56 153.19,34.56 152.85,34.89 148.25,34.89 147.66,35.48 147.17,35.48 146.53,36.12 146.53,36.65 143.44,39.74 141.16,39.74 140.66,39.24 136.91,39.24 136.79,39.11 123.28,39.11 120.92,36.75 118.2,36.75 117.25,35.79 114.78,35.79 113.52,37.05 113.52,39.23 111.64,41.11 111.64,43.72 111.21,44.16 111.21,48.67 110.46,49.42 110.46,51.09 106.64,54.91 104.75,54.91 102.6,57.07 102.6,60.74 102.37,60.98 102.37,62.52 103.24,63.39 103.24,73.04 101.74,74.54 99.33,74.54 99.12,74.33 98.59,74.33 96.4,76.52 94.95,76.52 94.51,76.95 94.51,77.77 93.24,79.04 91.57,79.04 88.81,81.8 86.73,81.8 86.32,82.21 86.32,85 84.92,86.4 83.82,86.4 83.37,86.85 83.37,90.65 83.09,90.93 83.09,95.88 82.61,96.35 82.61,96.98 79.01,100.58 75.74,100.58 74.35,101.97 73.43,101.97 73.24,102.16 69.98,102.16 65.09,107.05 65.09,107.81 64.32,108.57 63.05,108.57 62.42,107.94 61.4,107.94 60.13,109.21 59.12,109.21 58.79,109.54 v1(58.79,109.71)
EC_ODD_EJ#: length 91.9
  TOP w0.102: v2(127.62,16.9) 127.62,16.55 127.44,16.37 R463.1 ; v2(203.59,23.1) 203.72,23.23 204.4,23.23 v1(204.74,23.56) 204.74,23.87 203.64,24.97 202.44,24.97 202.41,24.93 R393.1
  IN2 w0.089: v2(203.59,23.1) 203.59,22.77 203.36,22.53 203.36,21.83 203.19,21.66 200.83,21.66 199.26,20.1 199.26,18.41 198.37,17.52 196.2,17.52 195.66,16.98 194.55,16.98 194.35,17.18 194.35,17.36 194.11,17.6 193.78,17.6 193.57,17.4 191.44,17.4 190.21,18.63 189.57,18.63 188.97,18.03 188.57,18.03 188.35,17.8 187.56,17.8 187.31,18.05 186.45,18.05 185.79,18.71 180.75,18.71 180.55,18.51 174.31,18.51 174.04,18.24 172.52,18.24 171.71,17.44 161.07,17.44 160.93,17.3 157.2,17.3 156.69,17.82 155.21,17.82 155.08,17.68 155.08,17.09 154.65,16.67 150.76,16.67 150.56,16.86 142.84,16.86 142.28,17.42 139.25,17.42 138.5,16.67 127.86,16.67 v2(127.62,16.9)
  BOTTOM w0.102: v2(127.62,16.9) 127.72,16.8 128.05,16.8 128.13,16.72 129.02,16.72 129.35,17.06 CN15.16
EC_ODD_EJ_R#: length 5
  TOP w0.102: R393.2 202.12,25.56 202.25,25.69 202.25,26.24 v1(201.66,26.83) 201.27,27.21 201.04,27.21 C384.1 200.39,27.65 200.13,27.38 U13.94
EC_PECI: length 103.8
  TOP w0.102: v2(96.43,50.52) 96.8,50.52 97.34,51.07 100.34,51.07 103.36,48.04 104.76,48.04 105.65,47.15 108.27,47.15 v1(108.44,47.33) ; R354.2 179.11,29.69 178.53,30.26 178.53,30.59 178.28,30.84 177.46,30.84 174.72,33.58 171.34,33.58 v1(171.12,33.36) 167.3,33.36 v2(166.61,34.05)
  IN1 w0.089: v1(108.44,47.33) 108.06,47.33 107.49,46.77 107.49,45.56 108.32,44.73 108.32,43.24 109.32,42.24 109.32,39.21 110.54,37.98 112.09,37.98 113.06,37.01 116.29,37.01 116.35,36.96 117.55,36.96 117.89,37.3 118.15,37.3 118.78,37.93 124.5,37.93 126.1,39.53 135.88,39.53 137.12,40.78 142.05,40.78 142.78,41.52 143.44,41.52 143.85,41.11 143.85,40.27 147,37.12 147,36.55 148,35.55 153.15,35.55 153.3,35.39 155.66,35.39 156.68,36.41 159.47,36.41 160.72,35.17 161.3,35.17 162.47,34 164.04,34 164.2,33.84 166.41,33.84 v2(166.61,34.05)
  BOTTOM w0.079: U24.CD5 96.1,50.19 v2(96.43,50.52)
EC_PECR_R: length 13.8
  TOP w0.102: v2(189.01,28.66) 189.25,28.9 U13.117 ; v2(178.27,28.66) 178.86,28.66 179.11,28.91 R354.1
  IN1 w0.089: v2(178.27,28.66) 178.27,28.66 181.96,28.66 182.74,29.44 188.24,29.44 v2(189.01,28.66)
EC_PWROK: length 153.3
  TOP w0.102: v2(57.47,24.37) 57.47,23.99 57.75,23.71 v1(60.28,23.71) 61.66,23.71 61.81,23.86 63.18,23.86 63.56,24.24 63.56,24.68 64.54,25.66 64.54,26.92 64.83,27.21 64.83,28.08 65.16,28.41 R359.1 65.52,27.95 R372.1 ; v2(185.1,12.74) 185.1,12.81 184.85,13.07 U13.33
  IN1 w0.089: v2(185.1,12.74) 184.54,12.74 182.12,15.16 118.13,15.16 117.51,15.77 110.26,15.77 109.65,15.16 93.26,15.16 92,13.9 92,13.27 91.81,13.08 91.81,12.83 89.04,10.06 88.79,10.06 88.47,9.74 88.03,9.74 87.94,9.65 84.3,9.65 83.78,10.17 82.98,10.17 79.89,13.26 75.9,13.26 74.26,14.9 71.08,14.9 70.57,15.4 66.03,15.4 61.36,20.08 60.06,20.08 59.05,21.09 59.05,22.09 57.47,23.67 v2(57.47,24.37)
EC_TYPEC_CHG: length 1.6
  BOTTOM w0.102: R840.2 26.15,12.76 25.45,13.46 U36.7
EC_TYPEC_CHG_HI: length 183.1
  TOP w0.102: v2(165.42,26.99) 165.67,26.73 165.67,26.02 165.49,25.84 165.49,24.83 164.96,24.29 164.96,20.39 164.34,19.77 164.34,18.79 162.71,17.16 156.31,17.16 156.06,17.41 154.52,17.41 154.47,17.36 v2(154.44,17.36) ; v2(184.39,27.48) 184.05,27.48 183.95,27.38 U13.3
  IN2 w0.089: v1(25.07,12.99) 25.8,12.99 27.49,11.29 27.98,11.29 28.94,10.32 37.52,10.32 42.74,15.54 45.82,15.54 46.19,15.18 46.19,14.87 46.42,14.64 53.54,14.64 53.65,14.75 55.18,14.75 55.91,14.01 57.73,14.01 58.76,15.04 60.19,15.04 61.95,13.28 70.99,13.28 71.37,12.91 74.26,12.91 74.97,12.2 80.78,12.2 83.37,9.61 83.53,9.61 83.77,9.37 88.52,9.37 93.46,14.31 111.82,14.31 114.36,16.86 122.35,16.86 123.21,17.72 127.82,17.72 128.28,17.26 137.35,17.26 138,17.91 142.59,17.91 143.14,17.36 150.68,17.36 151.24,17.92 153.71,17.92 154.27,17.36 v2(154.44,17.36)
  IN3 w0.089: v2(184.39,27.48) 183.64,27.48 183.32,27.16 179.65,27.16 179.05,27.76 172.95,27.76 172.91,27.8 171.28,27.8 171.04,27.55 167.58,27.55 166.99,26.95 165.45,26.95 v2(165.42,26.99)
  BOTTOM w0.102: U36.8 24.95,13.1 v1(25.07,12.99) 24.53,12.44 R838.2
EC_TYPEC_EN: length 1.4
  TOP w0.102: R416.1 199.79,21.96 199.62,21.78 U13.80
EC_TYPEC_EN_R: length 196.2
  TOP w0.102: v2(201.23,22.06) 201.13,21.96 R416.2
  TOP w0.254: v1(26.99,14.21) 26.99,14.13 26.27,13.42 R478.1
  IN2 w0.089: v1(26.99,14.21) 26.48,13.7 26.48,12.61 27.6,11.49 28.08,11.49 29.04,10.53 37.45,10.53 42.66,15.73 44.94,15.73 46.09,16.88 54.09,16.88 56.22,14.75 57.43,14.75 58.46,15.78 60.49,15.78 61.95,14.32 73.13,14.32 74.95,12.5 81.08,12.5 84.01,9.56 88.44,9.56 93.38,14.5 109.78,14.5 110.53,15.25 112.49,15.25 114.28,17.05 121.39,17.05 122.36,18.02 127.95,18.02 128.41,17.56 137.22,17.56 137.76,18.1 142.86,18.1 143.36,17.6 150.65,17.6 151.16,18.11 154.96,18.11 155.05,18.2 156.96,18.2 157.47,17.68 160.78,17.68 161.13,18.03 171.77,18.03 172.36,18.62 173.88,18.62 174.15,18.89 178.94,18.89 179.36,19.32 180.34,19.32 180.75,18.9 185.87,18.9 186.53,18.24 187.39,18.24 187.64,17.99 188.27,17.99 188.5,18.22 188.89,18.22 189.5,18.82 190.29,18.82 191.52,17.59 193.5,17.59 193.7,17.79 195.81,17.79 195.89,17.71 198.29,17.71 199.07,18.49 199.07,20.18 200.95,22.06 v2(201.23,22.06)
  BOTTOM w0.203: U36.6 26.84,14.36 v1(26.99,14.21)
ECAGND: length 13
  TOP w0.203: v2(201.86,15.2) 202.13,15.2 202.34,15 C457.1 ; v2(202.25,20.71) 202.22,20.69 202.22,20.67 C434.1 C433.2 200.65,20.91 L9.1 199.96,20.49 199.96,20.05 199.69,19.78 U13.75
  IN1 w0.254: v2(201.86,15.2) 201.03,16.04 201.03,17.08 200.8,17.31 200.8,17.84 201.36,18.4 201.36,19.42 202.25,20.31 v2(202.25,20.71)
EMMC_RCOMP: length 2.5
  TOP w0.254: v2(84.62,32.26) 84.77,32.1 R326.1
  BOTTOM w0.152: U24.DU28 85.03,33.84 84.71,33.51 84.71,32.69 84.64,32.62 84.64,32.38 84.62,32.36 v2(84.62,32.26)
EN: length 5.6
  TOP w0.102: U17.7 208.43,16.87 208.29,17 208.29,17.41 207.94,17.77 v1(207.74,17.77) R446.2 207.04,17.49 206.94,17.39 206.44,17.39 205.8,18.02 205.42,18.02 205.04,17.64 R451.1
EQ1: length 13.9
  TOP w0.102: R476.1 204.76,13.98 204.86,14.08 205.17,14.08 205.55,13.7 206.82,13.7 207.02,13.5 R477.2 207.2,13.32 207.33,13.45 v2(207.33,13.83) ; v1(212.53,14.18) 213.55,15.2 213.55,15.73 213.41,15.87 U17.17
  IN2 w0.089: v2(207.33,13.83) 207.55,14.06 207.99,14.06 209.03,15.1 212,15.1 212.18,15.28 212.74,15.28 212.99,15.02 212.99,14.64 v1(212.53,14.18)
EQ2: length 13.8
  TOP w0.102: v1(213.73,17) 213.68,17 213.54,16.87 U17.19 ; R470.1 204.76,14.44 204.88,14.31 205.65,14.31 v1(205.75,14.41) 205.95,14.21 206.18,14.21 206.31,14.34 206.31,15 206.41,15.1 206.89,15.1 207.04,14.95 R471.2 207.2,14.72 207.71,15.23 v2(207.88,15.23)
  IN2 w0.089: v2(207.88,15.23) 208.09,15.23 208.85,15.99 208.85,17.39 209.1,17.64 212.91,17.64 213.54,17 v1(213.73,17)
ESPI_0: length 173
  TOP w0.102: U13.10 182.47,24.58 182.36,24.47 179.36,24.47 179.03,24.8 178.3,24.8 177.84,24.34 177.84,23.99 178.13,23.7 178.13,21.16 176.41,19.44 176.41,17.89 175.88,17.36 174.9,17.36 174.5,17.76 174.5,17.9 v2(174.5,17.91) ; R231.2 65.98,47.92 64.91,47.92 63.69,49.14 62.93,49.14 62.42,48.63 62.42,48.44 62.16,48.18 60.47,48.18 58.15,45.86 58.15,29.63 v1(57.97,29.45) 57.91,29.39 57.91,28.96 56.75,27.8 56.75,27.62 57.18,27.2 57.32,27.2 v2(57.34,27.21)
  IN1 w0.089: v2(174.5,17.91) 174.46,17.94 172.95,17.94 172.03,17.02 156.79,17.02 156.43,17.38 155.59,17.38 155.19,16.98 154.29,16.98 153.82,17.45 150.4,17.45 150.14,17.19 143.12,17.19 142.7,17.61 139,17.61 138.45,17.06 128.7,17.06 128.15,17.61 122.77,17.61 122.57,17.82 122.03,17.82 121.83,17.61 113.57,17.61 113.5,17.54 112.74,17.54 112.63,17.64 111.6,17.64 110.77,18.46 105.12,18.46 104.41,17.75 95.67,17.75 95.39,18.03 91.6,18.03 91.36,17.79 90.85,17.79 88.21,20.43 83.65,20.43 80.81,17.59 73.75,17.59 73.23,17.07 72.36,17.07 71.98,17.44 71.09,17.44 70.93,17.6 70.93,18.02 70.64,18.31 66.09,18.31 64.04,20.36 64.04,21.24 63.18,22.09 61.54,22.09 59.28,24.35 59.28,25.08 57.34,27.03 v2(57.34,27.21)
ESPI_0_R: length 10.8
  TOP w0.102: v2(72.58,45.71) 72.53,45.71 72.27,45.96 71.56,45.96 69.76,47.76 R231.1
  BOTTOM w0.079: v2(72.58,45.71) 72.86,45.71 73.16,46 74.56,46 74.6,45.98 74.97,45.98 75.04,45.91 75.73,45.91 76.03,45.61 U24.CN45
ESPI_1: length 176.5
  TOP w0.102: v2(175.67,17.91) 175.84,17.91 176.11,18.17 176.11,19.57 177.82,21.28 177.82,23.57 177.53,23.86 177.53,24.47 178.17,25.11 179.16,25.11 179.49,24.78 182.05,24.78 182.26,24.98 U13.9 ; v2(57.34,27.8) 57.34,27.95 58.46,29.07 58.46,45.73 60.6,47.87 62.28,47.87 62.72,48.31 62.72,48.5 63.05,48.83 63.52,48.83 v3(63.81,48.54) 64.82,47.53 R233.2
  IN1 w0.089: v2(175.67,17.91) 175.65,17.89 175.65,17.73 174.96,17.04 174.08,17.04 173.83,17.3 173.13,17.3 172.2,16.37 156.58,16.37 156.54,16.34 155.44,16.34 155.41,16.37 125.69,16.37 125.16,16.9 123.1,16.9 122.77,16.57 121.57,16.57 121.19,16.95 111.46,16.95 111.17,17.24 109.22,17.24 108.42,16.45 102.27,16.45 101.55,17.17 95.42,17.17 95.16,17.44 92.95,17.44 90.93,15.42 90.93,14.51 90.63,14.21 90.63,13.36 88.5,11.24 87.86,11.24 87.45,10.83 84.88,10.83 84.36,11.35 83.77,11.35 81.52,13.6 81.52,15.3 80.02,16.8 73.93,16.8 73.49,16.37 72.23,16.37 71.74,16.86 66.71,16.86 63.29,20.28 62.83,20.28 61.6,21.51 61.3,21.51 58.7,24.11 58.7,24.84 57.24,26.3 56.63,26.3 56.34,26.59 56.34,27.32 56.64,27.62 57.01,27.62 57.19,27.8 v2(57.34,27.8)
ESPI_1_R: length 10.7
  TOP w0.102: v2(72.17,45.25) 72.15,45.25 71.77,45.63 71.46,45.63 69.71,47.38 65.95,47.38 65.8,47.53 R233.1
  BOTTOM w0.079: v2(72.17,45.25) 72.2,45.22 72.63,45.22 73.24,45.84 74.52,45.84 U24.CN48
ESPI_2: length 171.5
  TOP w0.102: U13.8 182.29,25.38 182.08,25.59 179.44,25.59 179.26,25.41 178.04,25.41 177.23,24.6 177.23,23.74 177.52,23.44 177.52,21.41 175.8,19.7 175.8,18.45 175.7,18.35 175.51,18.35 175.09,17.93 v2(175.09,17.91) ; R236.2 65.9,47 65.75,47.15 64.77,47.15 64.05,47.87 62.71,47.87 62.41,47.57 60.72,47.57 58.76,45.61 58.76,28.94 57.8,27.98 57.8,26.91 57.69,26.81 56.98,26.81 v2(56.78,27.01)
  IN1 w0.089: v2(175.09,17.91) 175.07,17.89 175.07,17.76 174.64,17.33 174.2,17.33 173.9,17.64 173.06,17.64 172.1,16.68 156.47,16.68 156.42,16.63 155.56,16.63 155.51,16.68 142.85,16.68 142.21,17.32 139.27,17.32 138.71,16.77 128.58,16.77 128.04,17.31 122.92,17.31 122.57,16.95 121.61,16.95 121.31,17.25 112.62,17.25 112.54,17.32 111.5,17.32 110.65,18.17 105.24,18.17 104.53,17.46 95.55,17.46 95.27,17.74 91.73,17.74 91.45,17.46 90.77,17.46 88.19,20.04 84.1,20.04 81.24,17.18 73.76,17.18 73.35,16.78 72.24,16.78 71.86,17.15 70.58,17.15 69.71,18.02 65.96,18.02 63.41,20.57 62.95,20.57 61.72,21.8 61.42,21.8 58.99,24.23 58.99,24.96 56.95,27.01 v2(56.78,27.01)
ESPI_2_R: length 9
  TOP w0.102: R236.1 69.66,47 v2(71.61,45.05)
  BOTTOM w0.079: v2(71.61,45.05) 71.79,44.87 72.63,44.87 72.91,45.15 72.91,45.25 73.33,45.67 74.26,45.67 U24.CN49
ESPI_3: length 166
  TOP w0.102: v2(175.37,19.46) 175.37,19.72 177.21,21.56 177.21,23.32 176.92,23.61 176.92,24.72 177.92,25.72 179.13,25.72 179.31,25.89 182.21,25.89 182.32,25.78 U13.7 ; R237.2 64.77,46.72 63.93,47.56 62.83,47.56 62.54,47.26 60.85,47.26 59.07,45.48 59.07,28.82 58.2,27.95 v2(58.2,27.8)
  IN1 w0.089: v2(58.2,27.8) 58.2,27.77 58.66,27.32 58.66,26.67 59.87,25.46 59.87,24.6 61.79,22.68 63.42,22.68 64.62,21.48 64.62,21.03 65.93,19.72 70.67,19.72 72.17,18.22 73.81,18.22 73.86,18.17 80.16,18.17 83.01,21.03 88.44,21.03 90.25,19.23 91.25,19.23 91.86,18.62 95.63,18.62 95.91,18.34 104.04,18.34 104.93,19.23 111.61,19.23 111.81,19.02 113.23,19.02 113.96,18.29 120.63,18.29 121.3,18.95 122.26,18.95 123.01,18.2 128.39,18.2 128.95,17.65 137.18,17.65 137.92,18.38 143.03,18.38 143.51,17.9 150.02,17.9 150.16,18.04 154.81,18.04 154.88,17.96 156.93,17.96 157.29,17.6 171.73,17.6 172.87,18.74 174.14,18.74 174.2,18.81 174.71,18.81 175.37,19.46 v2(175.37,19.46)
ESPI_3_R: length 11.6
  TOP w0.102: R237.1 65.72,46.72 65.82,46.62 69.45,46.62 71.49,44.59 71.79,44.59 v2(71.89,44.49)
  BOTTOM w0.079: U24.CN47 75.4,45.38 74.17,45.38 74.04,45.5 73.42,45.5 73.09,45.17 73.09,45.07 72.5,44.49 v2(71.89,44.49)
ESPI_CLK: length 164.4
  TOP w0.102: U13.13 182.28,23.38 181.88,22.97 181.82,22.97 181.44,22.59 180.58,22.59 180.33,22.34 179.67,22.34 R419.2 178.65,21.11 177.94,20.4 v2(177.94,20.38) ; R240.2 65.7,46.24 65.59,46.34 64.72,46.34 63.86,47.2 C326.2 63.46,47.2 63.41,47.26 62.96,47.26 62.66,46.96 60.98,46.96 59.37,45.35 59.37,28.69 58.61,27.93 58.61,27.57 58.25,27.21 v2(58.2,27.21)
  IN1 w0.089: v2(58.2,27.21) 58.2,26.71 59.57,25.34 59.57,24.48 61.66,22.39 63.3,22.39 64.33,21.36 64.33,20.91 65.81,19.43 68.31,19.43 69.14,18.6 71.23,18.6 72.48,17.36 73.11,17.36 73.63,17.88 80.28,17.88 83.12,20.73 88.33,20.73 90.89,18.17 91.32,18.17 91.48,18.32 95.51,18.32 95.79,18.05 104.16,18.05 105.05,18.93 110.83,18.93 111.11,18.66 113.18,18.66 113.84,17.99 120.84,17.99 121.51,18.66 122.14,18.66 122.88,17.91 128.27,17.91 128.83,17.35 137.31,17.35 137.95,17.99 142.73,17.99 143.24,17.49 150.02,17.49 150.28,17.75 154.68,17.75 154.76,17.67 156.7,17.67 157.06,17.31 171.85,17.31 172.89,18.35 174.28,18.35 174.31,18.38 175.93,18.38 v2(177.94,20.38)
ESPI_CLK_R: length 10.3
  TOP w0.102: R240.1 69.4,46.24 71.39,44.26 v2(71.39,44.18)
  BOTTOM w0.079: v2(71.39,44.18) 71.44,44.13 72.4,44.13 73.28,45.01 73.28,45.11 73.5,45.33 73.97,45.33 74.1,45.21 75.01,45.21 75.25,44.98 U24.CR47
ESPI_CS#: length 161.6
  TOP w0.102: R254.2 63.08,44.54 62.85,44.77 62.31,44.77 62.21,44.87 61.61,44.87 61.05,45.42 R243.1 60.72,45.83 60.01,45.12 60.01,44.99 59.98,44.97 59.98,28.87 60.01,28.84 v3(60.01,28.38) 59.93,28.38 59.47,27.93 59.47,27.57 59.14,27.24 59.09,27.24 v2(59.07,27.21) ; U13.6 182.35,26.18 182.33,26.2 179.18,26.2 179.01,26.02 177.79,26.02 176.62,24.85 176.62,23.48 176.91,23.19 176.91,21.69 174.69,19.47 v2(174.53,19.47)
  IN1 w0.089: v2(59.07,27.21) 59.07,26.67 60.16,25.58 60.16,24.72 61.91,22.97 63.54,22.97 64.91,21.6 64.91,21.15 66.05,20.01 70.79,20.01 72.24,18.57 80.14,18.57 82.89,21.32 88.6,21.32 90.4,19.52 91.37,19.52 91.85,19.04 95.62,19.04 96.03,18.63 103.92,18.63 104.8,19.52 111.9,19.52 112,19.42 113.25,19.42 113.99,18.67 120.6,18.67 121.2,19.26 122.36,19.26 123.13,18.5 128.51,18.5 129.07,17.94 136.91,17.94 137.65,18.67 146.25,18.67 146.58,18.34 150.05,18.34 150.09,18.38 154.88,18.38 154.96,18.29 157.01,18.29 157.41,17.89 171.49,17.89 172.63,19.04 173.94,19.04 174.09,19.19 174.26,19.19 v2(174.53,19.47)
ESPI_CS#_R: length 13.8
  TOP w0.102: R254.1 63.94,44.54 64.02,44.61 69.48,44.61 70.55,43.55 v2(70.55,43.42)
  BOTTOM w0.079: v2(70.55,43.42) 70.78,43.66 72.42,43.66 73.22,44.45 74.05,44.45 74.18,44.58 75.45,44.58 75.57,44.64 75.83,44.64 U24.CT45
ESPI_RESET#: length 163.3
  TOP w0.102: v2(165.59,21.5) 165.59,20.23 164.87,19.51 164.87,18.82 165.03,18.66 169,18.66 v1(169.09,18.74) 169.18,18.83 169.18,19.36 169.41,19.59 170.03,19.59 170.14,19.49 170.14,17.29 171.13,16.29 177.14,16.29 178.17,17.33 178.91,17.33 179.64,18.05 R441.1 ; v2(59.07,27.8) 59.07,27.96 59.68,28.57 59.68,45.22 60.67,46.21 62.04,46.21 62.04,46.22 R239.2 63.81,46.22 64.07,45.96 R242.2
  IN1 w0.089: v2(59.07,27.8) 59.09,27.8 59.47,27.42 59.47,27.2 59.85,26.82 59.85,26.3 60.62,25.54 v1(60.62,25.01)
  IN2 w0.089: v1(60.62,25.01) 60.62,22.39 61.67,21.33 61.67,21.13 64.06,18.74 73.07,18.74 73.82,17.98 79.82,17.98 83.97,22.13 88.95,22.13 90.96,20.13 92.28,20.13 93.06,19.35 97.28,19.35 97.42,19.21 103.59,19.21 104.5,20.13 111.62,20.13 113.09,21.6 115.83,21.6 116.37,22.13 118.71,22.13 119.75,23.18 121.24,23.18 121.55,22.87 126.73,22.87 126.92,22.69 133.02,22.69 133.18,22.85 138.87,22.85 139.48,22.24 156.56,22.24 156.75,22.43 164.41,22.43 165.34,21.5 v2(165.59,21.5)
ESPI_RESET#_R: length 12.6
  TOP w0.102: v2(70.8,44.06) 70.8,44.18 69.12,45.86 65.57,45.86 65.47,45.96 R242.1
  BOTTOM w0.079: v2(70.8,44.06) 71.03,43.83 72.35,43.83 73.15,44.62 73.98,44.62 74.11,44.75 75.41,44.75 75.49,44.79 75.67,44.98 U24.CR46
EXT_PWR_GATE#: length 21
  TOP w0.102: v2(78.98,46.47) 78.95,46.44 77.89,46.44 77.48,46.85 77.48,47.08 76.95,47.61 75.5,47.61 74.74,46.85 74.48,46.85 74,46.37 72.55,46.37 v1(71.31,47.61)
  BOTTOM w0.079: v2(78.98,46.47) 79.3,46.79 U24.CL39
  BOTTOM w0.102: R654.1 62.08,46.11 62.41,45.78 62.77,45.78 63,45.55 63.79,45.55 64.27,46.04 65.22,46.04 65.32,45.93 69.2,45.93 70.42,47.15 70.85,47.15 v1(71.31,47.61)
FAN1_RPM: length 37.1
  TOP w0.102: R371.2 177.22,28.04 177.68,28.51 v2(177.68,28.66) ; U13.47 190.45,14.93 191.15,15.63 191.15,19.65 192.31,20.81 192.82,20.81 193.15,21.15 193.15,22.55 192.58,23.13 190.04,23.13 189.56,23.61 189.29,23.61 188.94,23.96 188.94,24.19 v2(188.99,24.24)
  IN2 w0.089: v2(188.99,24.24) 188.99,24.07 189.44,23.62 189.74,23.62 190.61,24.5 190.61,24.93 190.93,25.25 190.93,26.08 190.69,26.33 185.59,26.33 185.12,25.85 183.68,25.85 182.45,27.09 179.82,27.09 178.62,28.28 178.09,28.28 177.73,28.64 177.71,28.64 v2(177.68,28.66)
  BOTTOM w0.102: v2(177.68,28.66) 177.68,28.97 177.86,29.15 178.42,29.15 178.69,28.87 FAN1.2
FAN_PWM: length 39.3
  TOP w0.102: U13.32 183.93,15.78 184.26,16.12 185.41,16.12 186.07,16.78 186.07,17.74 186.32,17.99 186.85,17.99 188.45,19.59 190.77,19.59 192.22,21.04 192.7,21.04 192.92,21.27 192.92,22.46 192.48,22.9 188.77,22.9 186.68,25 186.68,26.04 187.56,26.93 v2(187.56,26.94) ; v2(175.92,28.66) Q16.1
  IN1 w0.089: v2(175.92,28.66) 176.33,28.25 177.8,28.25 177.99,28.06 182.21,28.06 182.98,28.83 187.76,28.83 188.4,28.18 188.4,27.16 188.18,26.94 v2(187.56,26.94)
FAN_PWM_C: length 7.7
  TOP w0.102: Q16.3 177.92,29.74 177.1,28.92 v2(177.1,28.66) 177.1,28.56 176.46,27.93 R370.2 176.22,27.15 v1(176.13,27.06)
  BOTTOM w0.102: FAN1.3 177.9,30.13 177.1,29.32 v2(177.1,28.66)
FB_CAL_PD_VDDQ: length 9.1
  TOP w0.381: R84.2 116.19,93.81 116.04,93.97 114.28,93.97 113.97,93.66 113.4,93.66 v2(112.03,95.03)
  BOTTOM w0.381: U22.D22 111.63,95.43 v2(112.03,95.03)
FB_CAL_PU_GND: length 7
  TOP w0.127: v2(113.73,94.22) 113.88,94.37 116.52,94.37 116.65,94.25 117.89,94.25 118.48,94.83 R82.2
  BOTTOM w0.102: U22.C24 113.73,94.23 v2(113.73,94.22)
FB_CAL_TERM_GND: length 5.9
  BOTTOM w0.203: U22.B25 114.54,94.24 116,94.24 116.33,93.9
  BOTTOM w0.508: 116.33,93.9 116.39,93.84 119.34,93.84 v1(119.59,94.09)
FBA_CMD0: length 27.1
  TOP w0.102: 135.01,94.55 135.01,93 v2(135.41,92.61)
  TOP w0.165: 135.01,94.55 135.01,94.88 130.85,99.05 v1(128.46,99.05) 125.03,99.05 124.34,98.36 120.05,98.36 119.11,97.42 v2(119.11,97.37)
  BOTTOM w0.127: U22.C27 116.11,94.63 116.33,94.41 117.16,94.41 ; v2(135.41,92.61) 135.01,92.21 VRAM2.G12
  BOTTOM w0.165: v2(119.11,97.37) 119.11,95.67 117.85,94.41 117.16,94.41
FBA_CMD1: length 32.1
  TOP w0.114: v2(134.61,90.21) 135.02,90.61 135.67,90.61 135.81,90.75 135.81,94.6
  TOP w0.165: v2(118.53,97.37) 118.53,97.6 119.82,98.89 124.09,98.89 124.78,99.58 v1(131,99.58) 131.1,99.58 135.81,94.87 135.81,94.6
  BOTTOM w0.127: U22.C26 115.31,95.01 116.17,95.01 116.32,94.86 117.16,94.86 ; v2(134.61,90.21) 134.22,90.6 VRAM2.H10
  BOTTOM w0.165: 117.16,94.86 117.54,94.86 118.53,95.85 v2(118.53,97.37)
FBA_CMD2: length 29
  TOP w0.165: v2(134.61,91.01) 134.09,91.53 v1(134.09,93.08) 134.09,95.05 130.67,98.46 125.23,98.46 124.6,97.83 120.79,97.83 119.89,96.93 116.24,96.93 115.58,96.28 114.11,96.28 114.1,96.28 113.38,96.28 v2(112.96,95.87)
  BOTTOM w0.127: v2(134.61,91.01) 134.22,91.4 VRAM2.H11 ; v2(112.96,95.87) 113.33,96.24 U22.E24
FBA_CMD3: length 28.2
  IN3 w0.14: v2(133.01,91.01) 133.44,91.43 133.44,94.37 128.18,99.63 118.76,99.63 118.55,99.43 117.28,99.43 116.7,98.84 115.56,98.84 114.67,97.95 113.33,97.95 v2(112.93,97.55)
  BOTTOM w0.127: VRAM2.K11 132.62,91.4 v2(133.01,91.01) ; v2(112.93,97.55) 113.33,97.15 U22.F24
FBA_CMD4: length 23.3
  TOP w0.102: 132.62,92.95 132.62,90.59 v2(133.01,90.21)
  TOP w0.165: v2(117.33,95.49) 117.71,95.87 120.2,95.87 120.67,96.33 124.46,96.33 125.56,95.24 131.79,95.24 132.68,94.35 132.68,93 132.62,92.95
  BOTTOM w0.127: U22.D27 116.07,95.43 116.42,95.08 116.93,95.08 v2(117.33,95.49) ; v2(133.01,90.21) 132.62,90.6 VRAM2.K10
FBA_CMD5: length 23.6
  TOP w0.102: v2(132.21,92.61) 131.81,93.01 131.81,94.35
  TOP w0.165: 131.81,94.35 131.81,94.42 131.53,94.7 125.89,94.7 125.72,94.52 125.72,94.02 125.56,93.86 125.23,93.86 125.07,94.03 v1(125.07,94.84) 124.11,95.8 120.81,95.8 120.45,95.44 117.97,95.44 117.56,95.03 117.11,95.03 v2(116.65,95.49)
  BOTTOM w0.127: v2(132.21,92.61) 131.81,92.2 VRAM2.L12 ; U22.D26 114.93,95.78 115.3,96.15 116.87,96.15 117,96.02 117,95.84 v2(116.65,95.49)
FBA_CMD6: length 25.7
  IN3 w0.14: v2(132.21,86.21) 131.81,86.61 131.81,87.21 131.07,87.95 130.41,87.95 129.98,88.38 127.77,88.38 124.83,91.32 124.83,93.18 123.25,94.75 120.43,94.75 118.78,96.4 118.32,96.4 v2(117.36,97.37)
  BOTTOM w0.102: 115.34,97.29 115.1,97.53 114.53,97.53 U22.F25
  BOTTOM w0.127: 116.86,96.87 116.69,96.7 115.6,96.7 115.34,96.96 115.34,97.29 ; VRAM2.K4 132.61,85.81 v2(132.21,86.21)
  BOTTOM w0.165: 116.86,96.87 v2(117.36,97.37)
