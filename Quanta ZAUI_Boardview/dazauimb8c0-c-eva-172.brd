# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Nets (continued)
GND: C1.2 C2.2 C5.1 C6.2 C7.1 C8.2 C13.2 C14.1 C15.2 C16.1 C17.2 C18.1 C19.2 C20.2 C21.1 C22.2 C23.2 C24.1 C25.1 C26.1 C27.1 C28.1 C29.1 C30.2 C31.2 C32.2 C33.1 C34.2 C35.2 C37.1 C38.2 C39.2 C41.1 C42.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.1 C50.2 C51.2 C52.1 C54.1 C55.1 C56.1 C57.1 C58.2 C59.2 C60.1 C61.2 C62.1 C63.1 C64.2 C65.2 C66.1 C67.1 C68.1 C69.1 C70.1 C71.1 C72.1 C73.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.2 C82.1 C83.1 C84.1 C85.1 C86.1 C87.1 C89.2 C90.1 C91.1 C92.2 C93.2 C95.1 C96.1 C97.2 C98.1 C99.1 C100.1 C101.1 C102.1 C103.2 C104.1 C105.1 C106.2 C107.1 C108.1 C109.1 C110.1 C111.1 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.1 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C126.1 C127.1 C128.2 C129.2 C130.2 C131.1 C132.1 C133.1 C134.1 C135.1 C136.1 C137.2 C138.2 C139.1 C140.2 C141.2 C142.2 C143.2 C144.2 C145.1 C146.1 C147.1 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.1 C158.1 C159.2 C160.1 C161.2 C162.2 C163.1 C164.2 C165.2 C166.1 C167.2 C168.2 C169.2 C171.2 C172.1 C173.2 C174.1 C175.1 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.1 C188.1 C189.1 C190.1 C191.2 C192.1 C193.2 C194.2 C195.2 C199.2 C202.2 C204.2 C205.1 C207.2 C208.2 C209.2 C210.2 C212.2 C213.2 C214.2 C215.1 C216.1 C217.1 C218.2 C219.1 C220.2 C221.2 C222.2 C223.1 C224.2 C225.1 C226.1 C227.2 C228.2 C229.2 C230.2 C231.1 C232.2 C233.2 C234.2 C235.2 C236.1 C237.1 C238.2 C239.2 C240.2 C241.1 C242.1 C243.1 C244.1 C245.1 C246.2 C247.1 C248.1 C249.2 C250.1 C251.2 C252.2 C253.1 C254.1 C255.1 C256.1 C257.2 C258.1 C259.1 C260.2 C261.2 C262.1 C263.1 C264.1 C265.1 C266.1 C267.1 C268.2 C269.1 C270.2 C271.2 C273.2 C274.1 C275.1 C276.2 C278.2 C279.2 C280.2 C281.2 C282.1 C283.2 C284.1 C285.2 C286.2 C287.1 C288.1 C289.2 C290.2 C291.2 C292.2 C293.1 C294.1 C295.1 C296.2 C297.1 C298.2 C299.1 C300.2 C301.2 C302.1 C303.2 C304.1 C305.1 C306.2 C307.2 C308.1 C309.1 C310.1 C311.1 C312.2 C313.1 C314.2 C315.1 C316.2 C317.1 C318.1 C319.2 C320.2 C321.2 C322.1 C324.2 C325.1 C326.1 C328.2 C329.1 C330.1 C331.1 C335.1 C336.1 C337.1 C338.1 C339.1 C341.1 C342.1 C343.2 C344.1 C345.2 C346.2 C347.2 C348.2 C350.2 C352.2 C353.1 C354.1 C355.2 C356.2 C357.1 C358.2 C359.2 C360.1 C361.2 C362.2 C363.1 C364.2 C365.2 C367.1 C368.1 C369.2 C370.2 C371.2 C372.2 C373.2 C374.1 C376.2 C377.2 C378.2 C379.1 C381.2 C382.1 C383.1 C384.2 C385.2 C386.2 C387.1 C388.2 C389.1 C390.2 C391.2 C392.2 C393.1 C394.2 C395.1 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.2 C418.2 C419.2 C420.2 C421.2 C422.2 C423.2 C424.2 C425.1 C426.1 C427.2 C432.2 C435.2 C436.2 C437.2 C438.1 C439.2 C440.1 C441.2 C442.2 C443.2 C444.1 C445.1 C446.1 C447.2 C448.2 C449.2 C450.2 C451.2 C452.1 C453.1 C454.2 C455.1 C456.1 C458.2 C459.2 C460.2 C461.2 C462.1 C463.2 C464.2 C465.2 C466.2 C467.2 C476.2 C477.2 C478.2 C479.2 C480.1 C489.1 C490.1 C491.1 C492.1 C493.2 C494.1 C495.1 C496.1 C497.1 C498.2 C499.1 C500.1 C501.1 C502.2 C503.1 C504.1 C505.1 C506.1 C507.1 C508.2 C509.1 C510.1 C511.1 C512.1 C513.1 C514.1 C515.1 C516.1 C517.1 C518.2 C519.1 C520.1 C521.2 C522.2 C523.1 C524.2 C525.1 C526.2 C527.2 C528.2 C529.2 C532.1 C539.1 C540.2 C541.1 C542.1 C543.1 C544.1 C545.1 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 C552.1 C553.1 C554.2 C555.2 C556.2 C557.2 C558.2 C559.2 C560.2 C563.2 C564.2 C565.1 C566.1 C573.2 C574.2 C575.1 C576.2 C577.2 C579.2 C580.2 C581.2 C582.2 C583.2 C584.1 C585.2 C587.2 C588.2 C589.1 C590.2 C591.2 C592.1 C593.1 C594.2 C595.2 C596.1 C597.2 C598.1 C599.1 C600.1 C601.1 C602.1 C603.1 C604.1 C605.1 C606.1 C607.1 C608.1 C609.1 C610.2 C612.1 C622.2 C624.2 C626.1 C632.1 C633.1 C634.2 C636.1 C637.2 C639.1 C640.1 C641.2 C642.1 C643.2 C644.2 C645.2 C646.2 C647.2 C648.1 C649.2 C650.2 C651.1 C652.1 C653.2 C654.1 C655.1 C656.2 C657.1 C658.1 C659.2 C661.2 C662.1 C663.1 C664.1 C665.1 C666.2 C667.1 C670.2 C671.1 C672.1 C673.1 C674.1 C676.1 C679.2 C680.2 C681.2 C682.2 C683.2 C685.2 C686.1 C687.1 C688.1 C689.1 C690.2 C691.2 C692.2 C698.2 C699.2 C703.2 C704.2 C705.1 C706.2 C707.2 C708.2 C709.1 C710.2 C711.1 C712.2 C713.1 C714.1 C715.2 C716.2 C717.2 C718.2 C719.1 C720.2 C721.2 C722.2 C723.1 C724.1 C725.1 C726.1 CN1.1 CN1.5 CN1.6 CN2.3 CN2.6 CN2.9 CN2.12 CN2.15 CN2.18 CN2.21 CN2.41 CN2.42 CN3.9 CN3.10 CN3.11 CN3.12(GND#4) CN4.2 CN4.5 CN4.8 CN4.11 CN4.17 CN4.20 CN4.21 CN4.22 CN4.23 CN5.4 CN5.7 CN5.10 CN5.11 CN5.12 CN5.13 CN6.14 CN6.17 CN6.20 CN6.27 CN6.41 CN6.42 CN7.4 CN7.7 CN7.10 CN7.11 CN7.12 CN7.13 CN8.2 CN8.29 CN8.30 CN9.1 CN9.7 CN9.13 CN9.18 CN9.19 CN9.33 CN9.39 CN9.45 CN9.51 CN9.57 CN9.63 CN9.69 CN9.75 CN9.76 CN9.77 CN10.2 CN10.29 CN10.30 CN11.5 CN11.6 CN12.4 CN12.9 CN12.10 CN13.5 CN13.9 CN13.10 CN14.5 CN14.6 CN14.7 CN14.8 CN14.9 CN14.10 CN14.A1 CN14.A12 CN14.B1 CN14.B12 CN15.1 CN15.4 CN15.7 CN15.17 CN15.18 CN15.19 CN15.20 CN16.1 CN16.5 CN16.6 CN17.1 CN17.7 CN17.8 CN18.1 CN18.3 CN18.9 CN18.15 CN18.21 CN18.27 CN18.33 CN18.39 CN18.45 CN18.51 CN18.57 CN18.71 CN18.73 CN18.75 CN18.76 CN18.77 CN19.2 D3.1 D4.1 D10.2 D16.1 D17.1 D18.2 D19.1 D20.2 D21.1 D22.1 D24.1 D25.1 D26.1 D27.1 D28.1 D29.1 D30.1 D31.1 D32.1 D38.1 D39.1 D40.2 D41.1 EC1.1 EC2.1 EC3.1 EC4.2 EC5.2 EC6.1 EC7.2 EC8.2 EC9.2 FAN1.4 FAN1.5 FAN1.6 HD1.6 HD1.9 HD1.12 HD1.13 HD1.14 HE1.3 HOLE1.1 HOLE4.1 HOLE5.1 HOLE6.1 HOLE7.1 HOLE8.1 HOLE8.2 HOLE8.3 HOLE8.4 HOLE8.5 HOLE8.6 HOLE8.7 HOLE8.8 HOLE8.9 HOLE10.1 HOLE11.1 HOLE11.2 HOLE11.3 HOLE11.4 HOLE11.5 HOLE11.6 HOLE11.7 HOLE11.8 HOLE11.9 HOLE12.1 HOLE14.1 HOLE15.1 HOLE16.1 HOLE16.2 HOLE16.3 HOLE16.4 HOLE16.5 HOLE16.6 HOLE16.7 HOLE16.8 HOLE16.9 HOLE17.1 HOLE18.1 HOLE18.2 HOLE18.3 HOLE18.4 HOLE18.5 HOLE18.6 HOLE18.7 HOLE18.8 HOLE18.9 HOLE19.1 HOLE21.1 HOLE22.1 HOLE22.2 HOLE22.3 HOLE22.4 HOLE22.5 HOLE22.6 HOLE22.7 HOLE22.8 HOLE22.9 HOLE23.1 HOLE23.2 HOLE23.3 HOLE23.4 HOLE23.5 HOLE23.6 HOLE23.7 HOLE23.8 HOLE23.9 J1.2 JDIM1.1 JDIM1.2 JDIM1.5 JDIM1.6 JDIM1.9 JDIM1.10 JDIM1.14 JDIM1.15 JDIM1.18 JDIM1.19 JDIM1.22 JDIM1.23 JDIM1.26 JDIM1.27 JDIM1.30 JDIM1.31 JDIM1.35 JDIM1.36 JDIM1.39 JDIM1.40 JDIM1.43 JDIM1.44 JDIM1.47 JDIM1.48 JDIM1.51 JDIM1.52 JDIM1.56 JDIM1.57 JDIM1.60 JDIM1.61 JDIM1.64 JDIM1.65 JDIM1.68 JDIM1.69 JDIM1.72 JDIM1.73 JDIM1.77 JDIM1.78 JDIM1.81 JDIM1.82 JDIM1.85 JDIM1.86 JDIM1.89 JDIM1.90 JDIM1.93 JDIM1.94 JDIM1.98 JDIM1.99 JDIM1.102 JDIM1.103 JDIM1.106 JDIM1.107 JDIM1.167 JDIM1.168 JDIM1.171 JDIM1.172 JDIM1.175 JDIM1.176 JDIM1.180 JDIM1.181 JDIM1.184 JDIM1.185 JDIM1.188 JDIM1.189 JDIM1.192 JDIM1.193 JDIM1.196 JDIM1.197 JDIM1.201 JDIM1.202 JDIM1.205 JDIM1.206 JDIM1.209 JDIM1.210 JDIM1.213 JDIM1.214 JDIM1.217 JDIM1.218 JDIM1.222 JDIM1.223 JDIM1.226 JDIM1.227 JDIM1.230 JDIM1.231 JDIM1.234 JDIM1.235 JDIM1.238 JDIM1.239 JDIM1.243 JDIM1.244 JDIM1.247 JDIM1.248 JDIM1.251 JDIM1.252 JDIM1.261 JDIM1.262 L9.2 PC1.1 PC2.2 PC3.2 PC4.2 PC5.2 PC7.2 PC9.2 PC10.2 PC11.2 PC12.2 PC13.2 PC14.2 PC15.1 PC16.2 PC17.2 PC18.2 PC19.2 PC20.2 PC21.2 PC22.2 PC24.2 PC25.2 PC27.2 PC29.1 PC30.2 PC31.2 PC32.2 PC33.2 PC34.2 PC35.2 PC36.2 PC37.2 PC38.2 PC39.2 PC40.2 PC41.2 PC42.2 PC43.2 PC44.2 PC45.2 PC46.2 PC47.2 PC48.2 PC50.2 PC52.2 PC54.2 PC58.2 PC60.1 PC61.2 PC62.1 PC63.2 PC64.2 PC65.2 PC66.2 PC67.2 PC68.2 PC69.2 PC71.1 PC72.2 PC73.1 PC74.2 PC75.1 PC76.1 PC77.1 PC78.2 PC79.1 PC80.2 PC81.2 PC82.2 PC83.2 PC84.2 PC85.2 PC86.2 PC87.2 PC88.2 PC89.2 PC90.2 PC92.2 PC93.2 PC94.2 PC95.2 PC96.1 PC97.2 PC98.2 PC99.2 PC101.2 PC103.2 PC104.1 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.1 PC126.1 PC127.2 PC128.2 PC129.2 PC130.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC138.1 PC140.2 PC141.2 PC142.2 PC143.2 PC144.2 PC145.2 PC146.2 PC147.2 PC148.2 PC149.2 PC150.2 PC151.2 PC152.2 PC153.2 PC154.2 PC155.2 PC156.2 PC157.2 PC158.2 PC159.2 PC160.2 PC161.2 PC162.2 PC163.2 PC164.2 PC165.2 PC166.2 PC167.2 PC168.2 PC169.2 PC170.2 PC172.2 PC173.2 PC174.2 PC176.2 PC177.2 PC179.2 PC180.2 PC181.2 PC182.1 PC184.2 PC185.2 PC186.2 PC187.2 PC188.1 PC189.2 PC190.1 PC191.1 PC192.1 PC193.2 PC194.1 PC195.2 PC196.2 PC197.2 PC198.2 PC199.1 PC200.1 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC206.1 PC207.2 PC208.2 PC209.1 PC210.2 PC211.1 PC212.2 PC215.2 PC216.2 PC218.2 PC219.2 PC221.1 PC222.2 PC223.2 PC224.2 PC225.2 PC226.2 PC227.2 PC228.2 PC230.1 PC231.2 PC232.2 PC233.2 PC234.2 PC235.1 PC236.2 PC238.2 PC239.2 PC240.2 PC241.2 PC242.2 PC244.1 PC245.2 PC246.2 PC247.2 PC248.1 PC249.2 PC250.2 PC251.2 PC252.2 PC254.1 PC255.2 PC256.1 PC257.2 PC258.2 PC259.2 PC260.2 PC261.1 PC262.2 PC263.1 PC264.2 PC265.2 PC266.2 PC267.1 PC268.2 PC269.2 PC270.2 PC271.1 PD2.2 PD5.2 PD6.2 PJ6.2 PJ6.4 PJ6.5(SPRING & SHELL(-) #3) PJ11.1 PJ11.2 PJ11.9 PJ11.10 PQ1.1(EMITTER) PQ2.1(S) PQ5.1(S) PQ6.1(S) PQ7.1(EMITTER) PQ8.1(S) PQ9.1(S) PQ12.1(S) PQ13.1(S) PQ14.10(S2) PQ15.1(S) PQ16.10(S2) PQ17.1(S) PQ18.1(S) PQ20.10(S2) PQ21.10(S2) PQ22.1 PQ22.2 PQ22.3(S3) PQ23.1(S) PQ25.1(S) PQ27.1 PQ27.2 PQ27.3(S3) PQ28.1(S) PR3.2 PR4.2 PR15.1 PR23.1 PR25.2 PR42.2 PR45.1 PR59.2 PR65.1 PR69.2 PR73.2 PR74.2 PR76.2 PR82.2 PR84.1 PR85.2 PR86.1 PR97.2 PR104.1 PR105.2 PR112.2 PR118.2 PR133.2 PR134.2 PR136.1 PR144.2 PR146.2 PR150.1 PR162.1 PR180.2 PR188.2 PR189.1 PR192.2 PR193.2 PR212.2 PR219.2 PR223.2 PR224.1 PR230.2 PR240.2 PR246.1 PR263.2 PR275.1 PU1.3 PU1.9 PU1.16 PU2.25 PU3.11 PU3.15 PU4.33 PU5.4 PU5.8 PU5.9 PU6.11 PU6.15 PU7.11 PU7.15 PU8.2 PU9.12 PU9.13 PU9.14 PU9.15 PU9.19 PU10.14 PU10.21 PU11.4 PU11.8 PU12.22 PU12.29 PU12.30 PU12.31 PU12.32 PU12.33 PU12.34 PU12.35 PU12.36 PU12.37 PU12.38 PU13.2 PU13.4 PU14.2 PU15.4 PU15.8 Q3.1(EMITTER) Q4.1(S) Q4.4 Q5.1(S) Q7.1(S) Q8.1(S) Q9.1(S) Q17.1(S) Q17.4 Q20.1(S) Q22.1(S) Q22.4 Q24.1(S) Q24.4 Q27.1(S) Q28.1(S) Q29.1(S) Q30.1(S) Q32.1(S) Q33.2 Q34.1(S) Q35.1(S) Q35.4 Q38.1(S) Q38.4 Q39.1(S) Q39.4 Q40.1(S) Q40.4 Q44.1(EMITTER) R6.1 R19.2 R22.2 R27.2 R29.2 R30.1 R35.1 R48.2 R49.1 R54.2 R58.2 R62.2 R64.1 R82.1 R86.2 R93.1 R99.1 R102.2 R104.2 R105.2 R113.2 R114.2 R120.2 R125.2 R128.2 R132.2 R140.2 R143.1 R146.2 R151.2 R154.1 R156.1 R158.2 R161.2 R165.1 R166.2 R168.2 R171.2 R173.2 R174.2 R177.2 R181.2 R186.2 R187.1 R189.2 R190.2 R191.2 R192.2 R193.2 R209.1 R223.1 R226.2 R228.2 R229.2 R230.1 R234.2 R235.1 R239.1 R243.2 R245.2 R250.2 R255.2 R256.1 R259.2 R262.2 R264.1 R275.2 R277.2 R281.2 R285.2 R286.1 R287.1 R289.2 R290.2 R291.1 R294.2 R295.2 R296.1 R301.2 R302.2 R303.2 R308.2 R311.2 R317.1 R326.2 R328.1 R334.2 R337.2 R339.1 R343.1 R345.2 R348.2 R350.2 R355.2 R359.2 R375.2 R376.1 R385.1 R386.2 R388.1 R396.2 R404.2 R405.2 R408.2 R421.1 R436.1 R439.1 R440.1 R446.1 R459.2 R460.1 R462.2 R464.1 R466.1 R471.1 R477.1 R485.1 R491.1 R496.1 R501.2 R503.1 R504.1 R508.2 R511.1 R513.2 R523.1 R526.1 R528.2 R530.1 R532.1 R534.1 R535.1 R539.1 R541.2 R543.1 R545.1 R547.1 R552.1 R553.1 R554.1 R563.2 R570.2 R572.1 R575.1 R576.1 R577.1 R579.1 R581.1 R593.2 R600.2 R603.2 R609.2 R610.2 R612.2 R618.2 R630.1 R632.1 R635.1 R640.1 R643.1 R645.1 R648.1 R651.1 R653.1 R656.2 R657.2 R662.2 R665.2 R666.2 R670.1 R672.2 R681.1 R685.1 R691.2 R698.2 R700.2 R701.1 R706.1 R708.2 R709.1 R713.2 R716.2 R718.1 R720.2 R722.2 R724.2 R725.2 R728.1 R730.1 R732.1 R736.2 R741.2 R743.2 R774.1 R778.2 R783.1 R785.1 R789.1 R817.1 R823.1 R834.2 R841.2 RV1.3 RV1.8 RV2.3 RV2.8 RV3.3 SW1.3 SW1.4 SW2.1 SW2.2 SW2.5 SW2.6 U1.33 U2.A2 U2.A8 U2.B2 U2.C9 U2.D2 U2.D8 U2.E1 U2.E3 U2.E8 U2.F1 U2.G8 U2.H1 U2.H9 U2.K1 U2.K9 U2.N1 U2.N9 U2.T1 U3.17 U3.33 U3.34 U3.35 U3.36 U3.37 U4.A2 U4.A8 U4.B2 U4.C9 U4.D2 U4.D8 U4.E1 U4.E3 U4.E8 U4.F1 U4.G8 U4.H1 U4.H9 U4.K1 U4.K9 U4.N1 U4.N9 U4.T1 U5.3 U5.8 U5.9 U5.11 U6.A2 U6.A8 U6.B2 U6.C9 U6.D2 U6.D8 U6.E1 U6.E3 U6.E8 U6.F1 U6.G8 U6.H1 U6.H9 U6.K1 U6.K9 U6.N1 U6.N9 U6.T1 U7.14 U7.17 U8.A2 U8.A8 U8.B2 U8.C9 U8.D2 U8.D8 U8.E1 U8.E3 U8.E8 U8.F1 U8.G8 U8.H1 U8.H9 U8.K1 U8.K9 U8.N1 U8.N9 U8.T1 U9.3 U10.3 U11.3 U11.8 U11.9 U11.11 U12.3 U13.1 U13.27 U13.49 U13.91 U13.104 U14.3 U15.16 U15.23 U15.33 U16.5 U16.10 U16.12 U16.13 U16.15 U16.16 U17.3 U17.13 U17.18 U17.21 U17.22 U17.23 U17.24 U17.25 U17.26 U18.3 U19.3 U20.3 U21.25 U22.A2 U22.A26 U22.AA7 U22.AB7 U22.AB11 U22.AB14 U22.AB17 U22.AB20 U22.AB24 U22.AC2 U22.AC5 U22.AC8 U22.AC22 U22.AC26 U22.AD12 U22.AD13 U22.AD15 U22.AD16 U22.AD18 U22.AD19 U22.AD21 U22.AD22 U22.AE11 U22.AE14 U22.AE17 U22.AE20 U22.AF1 U22.AF5 U22.AF8 U22.AF11 U22.AF14 U22.AF17 U22.AF20 U22.AF23 U22.AG2 U22.AG26 U22.B1 U22.B5 U22.B8 U22.B11 U22.B14 U22.B17 U22.B20 U22.B23 U22.B27 U22.E2 U22.E5 U22.E8 U22.E11 U22.E14 U22.E17 U22.E20 U22.E22 U22.E25 U22.H2 U22.H5 U22.H23 U22.H25 U22.K11 U22.K13 U22.K15 U22.K17 U22.L2 U22.L5 U22.L10 U22.L12 U22.L14 U22.L16 U22.L18 U22.L23 U22.L25 U22.M11 U22.M13 U22.M15 U22.M17 U22.N10 U22.N12 U22.N14 U22.N16 U22.N18 U22.P2 U22.P5 U22.P11 U22.P13 U22.P15 U22.P17 U22.P23 U22.P26 U22.R10 U22.R12 U22.R14 U22.R16 U22.R18 U22.T11 U22.T13 U22.T15 U22.T17 U22.U2 U22.U5 U22.U10 U22.U12 U22.U14 U22.U16 U22.U18 U22.U23 U22.U26 U22.V11 U22.V13 U22.V15 U22.V17 U22.Y2 U22.Y5 U22.Y23 U22.Y26 U23.2 U24.A3 U24.A11 U24.A16 U24.A17 U24.A31 U24.A34 U24.A36 U24.A39 U24.A42 U24.A44 U24.A46 U24.A48 U24.A49 U24.AA45 U24.AA47 U24.AB3 U24.AB5 U24.AB6 U24.AB11 U24.AB38 U24.AB39 U24.AB41 U24.AB42 U24.AB43 U24.AC45 U24.AC49 U24.AD10 U24.AD11 U24.AD34 U24.AD37 U24.AE6 U24.AF37 U24.AF45 U24.AF47 U24.AG1 U24.AG3 U24.AG5 U24.AG9 U24.AG11 U24.AG38 U24.AG39 U24.AG41 U24.AG42 U24.AG43 U24.AH2 U24.AH37 U24.AH45 U24.AH49 U24.AJ2 U24.AJ3 U24.AK37 U24.AL2 U24.AL6 U24.AL45 U24.AL47 U24.AM2 U24.AM37 U24.AN2 U24.AN6 U24.AN38 U24.AN39 U24.AN41 U24.AN42 U24.AN43 U24.AN45 U24.AN49 U24.AR1 U24.AR2 U24.AR3 U24.AR7 U24.AR9 U24.AR11 U24.AT3 U24.AT5 U24.AT6 U24.AT7 U24.AT45 U24.AT47 U24.AU37 U24.AV3 U24.AV7 U24.AV11 U24.AV38 U24.AV39 U24.AV41 U24.AV42 U24.AV43 U24.AV45 U24.AV49 U24.AY3 U24.AY7 U24.B2 U24.B3 U24.B17 U24.B21 U24.B24 U24.B31 U24.B48 U24.BA1 U24.BA2 U24.BA45 U24.BA47 U24.BB3 U24.BB7 U24.BB11 U24.BC37 U24.BD3 U24.BD5 U24.BD6 U24.BD7 U24.BD38 U24.BD39 U24.BD41 U24.BD42 U24.BD43 U24.BD45 U24.BD49 U24.BE1 U24.BE2 U24.BF3 U24.BF7 U24.BF45 U24.BF47 U24.BG3 U24.BG7 U24.BG41 U24.BH37 U24.BJ1 U24.BJ2 U24.BJ3 U24.BJ7 U24.BJ41 U24.BJ43 U24.BJ45 U24.BJ49 U24.BM3 U24.BM5 U24.BM6 U24.BM7 U24.BM11 U24.BM45 U24.BM47 U24.BP1 U24.BP2 U24.BP3 U24.BP7 U24.BP43 U24.BR45 U24.BR49 U24.BT3 U24.BT7 U24.BT39 U24.BT41 U24.BT42 U24.BT43 U24.BU45 U24.BU47 U24.BV1 U24.BV2 U24.BV3 U24.BV7 U24.BV11 U24.BW3 U24.BW5 U24.BW6 U24.BW7 U24.BW37 U24.BY37 U24.BY45 U24.BY49 U24.C6 U24.C11 U24.C13 U24.C14 U24.C16 U24.C17 U24.C21 U24.C24 U24.C31 U24.C34 U24.C39 U24.C48 U24.C49 U24.CA3 U24.CA7 U24.CA38 U24.CA41 U24.CA42 U24.CA43 U24.CB37 U24.CB45 U24.CB47 U24.CC3 U24.CC7 U24.CE9 U24.CE37 U24.CE45 U24.CE49 U24.CG9 U24.CG37 U24.CG39 U24.CG43 U24.CG45 U24.CG47 U24.CH3 U24.CH5 U24.CJ9 U24.CJ37 U24.CJ42 U24.CK9 U24.CK45 U24.CK49 U24.CL37 U24.CL42 U24.CL49 U24.CM9 U24.CM45 U24.CM47 U24.CN3 U24.CN5 U24.CN37 U24.CN39 U24.CP9 U24.CR32 U24.CR37 U24.CR45 U24.CR49 U24.CT9 U24.CT37 U24.CT39 U24.CT42 U24.CU45 U24.CU47 U24.CU49 U24.CV3 U24.CV5 U24.CV9 U24.CV34 U24.CV35 U24.CY9 U24.CY41 U24.CY45 U24.CY49 U24.D13 U24.D17 U24.D31 U24.D44 U24.D49 U24.DA9 U24.DA10 U24.DA33 U24.DB32 U24.DB35 U24.DB38 U24.DB45 U24.DB47 U24.DB49 U24.DC3 U24.DC5 U24.DC6 U24.DC49 U24.DD37 U24.DD42 U24.DE6 U24.DE10 U24.DE13 U24.DE15 U24.DE17 U24.DE18 U24.DE20 U24.DE22 U24.DE23 U24.DE26 U24.DE28 U24.DE29 U24.DE33 U24.DE45 U24.DF13 U24.DF22 U24.DF28 U24.DF33 U24.DF35 U24.DF39 U24.DG6 U24.DG10 U24.DG12 U24.DG13 U24.DG15 U24.DG22 U24.DG23 U24.DG47 U24.DH1 U24.DH3 U24.DH5 U24.DH45 U24.DJ19 U24.DJ21 U24.DJ27 U24.DJ31 U24.DJ33 U24.DJ36 U24.DJ42 U24.DK3 U24.DK4 U24.DK6 U24.DK8 U24.DK49 U24.DL10 U24.DL13 U24.DL44 U24.DL47 U24.DM47 U24.DN15 U24.DN19 U24.DN24 U24.DN31 U24.DN36 U24.DN42 U24.DP45 U24.DR49 U24.DT1 U24.DT3 U24.DT6 U24.DT7 U24.DT8 U24.DT10 U24.DT15 U24.DT20 U24.DT27 U24.DT32 U24.DT37 U24.DT42 U24.DT49 U24.DU1 U24.DU2 U24.DU7 U24.DU10 U24.DU15 U24.DU20 U24.DU27 U24.DU32 U24.DU37 U24.DU47(VSS_432) U24.DU48 U24.DU49 U24.DV2 U24.DV8 U24.DV44 U24.DV48 U24.DW1 U24.DW2 U24.DW7 U24.DW10 U24.DW20 U24.DW27 U24.DW44 U24.DW46 U24.DW48 U24.DW49 U24.E6 U24.E11 U24.E34 U24.E36 U24.E39 U24.E42 U24.F8 U24.F11 U24.F31 U24.F45 U24.F47 U24.G3 U24.G5 U24.G21 U24.G24 U24.G31 U24.G36 U24.G49 U24.H17 U24.H21 U24.H24 U24.H31 U24.H33 U24.H36 U24.H45 U24.H49 U24.J6 U24.J10 U24.J13 U24.J15 U24.J16 U24.J36 U24.K8 U24.K11 U24.K15 U24.K33 U24.L36 U24.L39 U24.L41 U24.L42 U24.L43 U24.L45 U24.L47 U24.M3 U24.M5 U24.M10 U24.M36 U24.N45 U24.N49 U24.P8 U24.P11 U24.P41 U24.R3 U24.R37 U24.T11 U24.T36 U24.T41 U24.T43 U24.T45 U24.T47 U24.U3 U24.U5 U24.U37 U24.V9 U24.V11 U24.V36 U24.V45 U24.V49 U24.W37 U24.Y9 U24.Y36 U24.Y38 U24.Y43 U25.3 U26.3 U27.3 U28.2 U29.3 U30.49 U31.2 U32.4 U33.4 U34.3 U34.19 U35.2 U36.12 U36.21 U36.22 U36.23 U36.24 U36.25 U36.26 U36.27 VC1.2 VRAM1.A1 VRAM1.A3 VRAM1.A12 VRAM1.A14 VRAM1.B5 VRAM1.B10 VRAM1.C1 VRAM1.C3 VRAM1.C4 VRAM1.C11 VRAM1.C12 VRAM1.C14 VRAM1.D10 VRAM1.E1 VRAM1.E3 VRAM1.E12 VRAM1.E14 VRAM1.F5 VRAM1.F10 VRAM1.G5 VRAM1.G10 VRAM1.H1 VRAM1.H2 VRAM1.H13 VRAM1.H14 VRAM1.J1 VRAM1.J10 VRAM1.K1 VRAM1.K2 VRAM1.K13 VRAM1.K14 VRAM1.L5 VRAM1.L10 VRAM1.M5 VRAM1.M10 VRAM1.N1 VRAM1.N3 VRAM1.N12 VRAM1.N14 VRAM1.P10 VRAM1.R1 VRAM1.R3 VRAM1.R4 VRAM1.R11 VRAM1.R12 VRAM1.R14 VRAM1.T5 VRAM1.T10 VRAM1.U1 VRAM1.U3 VRAM1.U12 VRAM1.U14 VRAM2.A1 VRAM2.A3 VRAM2.A12 VRAM2.A14 VRAM2.B5 VRAM2.B10 VRAM2.C1 VRAM2.C3 VRAM2.C4 VRAM2.C11 VRAM2.C12 VRAM2.C14 VRAM2.D10 VRAM2.E1 VRAM2.E3 VRAM2.E12 VRAM2.E14 VRAM2.F5 VRAM2.F10 VRAM2.G5 VRAM2.G10 VRAM2.H1 VRAM2.H2 VRAM2.H13 VRAM2.H14 VRAM2.J1 VRAM2.J10 VRAM2.K1 VRAM2.K2 VRAM2.K13 VRAM2.K14 VRAM2.L5 VRAM2.L10 VRAM2.M5 VRAM2.M10 VRAM2.N1 VRAM2.N3 VRAM2.N12 VRAM2.N14 VRAM2.P10 VRAM2.R1 VRAM2.R3 VRAM2.R4 VRAM2.R11 VRAM2.R12 VRAM2.R14 VRAM2.T5 VRAM2.T10 VRAM2.U1 VRAM2.U3 VRAM2.U12 VRAM2.U14 Y1.2 Y1.4 Y2.2 Y2.4 Y4.2 Y4.4
V3A_BOOT: PR239.2 PU11.1
V3A_BOOT_R: PC229.1 PR239.1
V3A_EN: PC79.2 PR77.1 PR83.2 PU11.6
V3A_PWRGD: PR244.1 PU11.7
V3A_VBYP: PC227.1 PR68.1 PR70.2 PU11.11
V3A_VOUT: PC71.2 PR72.2 PR78.2 PR236.2 PU11.10(VOUT)
V5P5A_BOOT: PR115.2 PU15.1
V5P5A_BOOT_R: PC116.1 PR115.1
V5P5A_EN: PC271.2 PR276.1 PR279.2 PU15.6
V5P5A_PWRGD: PR273.1 PU15.7
V5P5A_VOUT: PC267.2 PR274.2 PR277.1 PR278.2 PU15.10(VOUT)
VCC1P8A: C278.1 C282.2 R219.1 U24.BG9 U24.BJ9 U24.BM9 U24.BW1 U24.BW2
VCC_AUX_SENSE: PR243.2 U24.BF9
VCCA_CLKLDO_1V8: C651.2 R748.1 U24.DW15
VCCAUX_VID0: PD3.2 PR212.1 PR218.2 PR222.1 R270.2 U10.2
VCCAUX_VID0_R: R266.2 R270.1 U24.CL38
VCCAUX_VID1: PD3.1 PR217.2 PR219.1 PR221.1 R271.2 U10.1
VCCAUX_VID1_R: R269.2 R271.1 U24.CJ38
VCCDSW_3P3: C342.2 R268.1 U24.DE31
VCCPLL_OC_DIS1: Q17.5 Q17.6 R386.1 R387.2
VCCPLL_OC_DIS2: Q17.3 R332.2
VCCPLL_OC_EN_1: C380.1 Q14.2 Q17.2 R352.1
VCCPLL_OC_EN_2: R352.2 R456.1 R457.1 R614.2 U18.4(Y)
VCCSENSE: PR159.2 PR184.2 U24.F17
VCCSPI: R283.2 U24.DB34
VCCST_EN: D6.1(CATHODE) D7.1(CATHODE) PD3.3(COMMON ANODE) Q39.5 R674.1 R675.2 R676.1 R680.2 R681.2 U25.1 U25.2
VCCST_OR_TCSS: D7.2 Q40.5 R668.2 R669.2 R670.2
VCCST_OVERRIDE: R661.2 R669.1 U24.CE4
VCCST_PWRGD: C601.2 C605.2 D33.2 D43.2 R637.1 R638.2 U26.4(Y)
VCCST_PWRGD_EN: R636.1 R641.1 R642.2 U27.2
VCCST_PWRGD_EN_L: C600.2 C607.2 R642.1 U26.2 U27.4
VCCST_PWRGD_TCSS: R660.2 R668.1 U24.CE3
VCCSTG_EN2: C586.1 Q35.2 Q36.2 R614.1
VCCSTPLL_DIS1: Q38.5 Q38.6 R618.1 R624.2
VCCSTPLL_DIS2: Q38.3 R620.2
VDDQ_BOOT: PR132.2 PU1.18
VDDQ_PG: PR128.2 PU1.8
VDDQ_SLP_S4: PC125.2 PR124.2 PR126.2 PU1.11
VDDQ_SW: PC139.2 PL2.1 PR129.1 PU1.17
VDDQ_SW_VPP: PL1.1 PU1.15
VDDQ_VCC: PC1.2 PC2.1 PC3.1 PR2.1 PU1.13 PU1.14
VDDQ_VDDQSNS: PR7.2 PU1.5
VDDQ_VLDOIN: PC16.1 PR6.2 PU1.1
VDDQ_VTT: PC18.1 PC142.1 PR8.1 PR130.1 PU1.2
VDDQ_VTT_CNTL: PC126.2 PR125.2 PU1.10(VTT_CNTL)
VDDQ_VTTREF: PC15.2 PR9.1 PU1.6
VDDQ_VTTSNS: PR8.2 PU1.4
VSS_AUX_SENSE: PR242.2 U24.BD9
VSSSENSE: PR162.2 PR185.2 U24.G17
1.03_GFX_PGD: PR147.2 PR148.1 PR166.1
2ND_MBCLK: Q15.3 R315.1 R380.1 R746.2 U13.115
2ND_MBDATA: Q15.6 R314.1 R381.1 R754.2 U13.116
17SZ_EN2: C463.1 Q24.5 R457.2 R467.2 R473.2 U18.1 U18.2
27M_XTAL_IN: C555.1 U22.C11 Y2.3
27M_XTAL_OUT: C554.1 U22.B10 Y2.1
80PORT_CLK: CN17.3 R831.1 U13.31
80PORT_DAT: CN17.4 R830.1 U13.83
5213EN_1.8V: PC94.1 PR94.1 PU5.7
5213FB_1.8V: PC100.2 PR103.2 PR104.2 PU5.1
5213FB_1.8V_S: PC100.1 PR95.1 PR103.1
5213LX_1.8V: PL3.1 PR79.1 PU5.6
5213PG_1.8V: PR91.2 PU5.2
5447_CC1_CON: C438.2 CN14.A5 D38.2 U36.11
5447_CC2_CON: C711.2 CN14.B5 D41.2 U36.13
8813BOOT1: PC23.2 PU2.1
8813BOOT2: PC28.2 PU2.18
8813EN: PC20.1 PD1.2 PR11.1 PR17.2 PU2.3
8813ILIM: PC147.1 PR144.1 PU2.12
8813ISEN1: PC29.2 PR31.2 PU2.15
8813ISEN2: PR30.2 PU2.14
8813LGAT1: PQ14.8 PR134.1 PU2.23
8813LGAT2: PQ16.8 PU2.20
8813PG: PR29.2 PR32.2 PU2.16
8813PHASE1: PC23.1 PL4.1 PQ14.5 PQ14.6 PQ14.7 PR10.2 PU2.24
8813PHASE2: PC28.1 PL5.1 PQ16.5 PQ16.6 PQ16.7 PR27.2 PU2.19
8813PSI: PR13.2 PR14.2 PR15.2 PU2.4
8813PVCC: PC25.1 PR143.2 PU2.21
8813REFADJ: PR139.2 PU2.6
8813REFIN: PC22.1 PR137.2 PR138.1 PU2.7
8813RGN: PC24.1 PC26.2 PR24.1 PU2.10
8813TON: PR21.1 PU2.9
8813UGATE1: PR135.1 PU2.2
8813UGATE1_1: PQ14.1 PR135.2
8813UGATE2: PR33.1 PU2.17
8813UGATE2_1: PQ16.1 PR33.2
9336ADJ: PR149.2 PR150.2 PU8.5
9336DRV: PD7.1(CATHODE) PQ19.4 PR152.1 PU8.6
24780_ACDET: PQ9.3 PR245.2 PR246.2 PU12.6
24780_ACDRV: PR247.2 PU12.4
24780_ACN: PC74.1 PC237.2 PR19.2 PU12.1
24780_ACP: PC76.2 PC237.1 PR18.2 PU12.2
24780_BATDRV: PR99.2 PU12.18
24780_BATSRC: PR108.2 PU12.17
24780_BM#: PR264.1 PU12.16
24780_BST: PR254.1 PU12.25
24780_CMPIN: PR85.1 PU12.13
24780_CMPOUT: PR265.1 PU12.14
24780_CMSRC: PR248.2 PU12.3
24780_DH: PQ26.4 PU12.26
24780_DL: PQ27.4 PU12.23
24780_ILIM: PC96.2 PR97.1 PR98.1 PU12.21
24780_LX: PC243.1 PL11.1 PQ26.1 PQ26.2 PQ26.3(S3) PQ27.5 PR268.1 PU12.27
24780_SRN: PC253.1 PC254.2 PR267.2 PR271.1
24780_SRP: PC248.2 PC253.2 PR261.2 PR270.1
24780_VCC: PC238.1 PR81.1 PU12.28(VCC)
25810_AUO#: R821.2 U36.17
25810_DBG#: R829.2 U36.16
25810_FAULT#: R826.2 U36.1
25810_LD_DET#: R815.2 U36.20
25810_POL#: R808.2 R809.2 R813.1 U36.18
25810_REF: R839.1 U36.10
25810_REF_RTN: R839.2 U36.9
25810_UFP#: Q22.2 Q42.3 R499.1 R814.2 U36.19
+1.03_GFX: C38.1 C48.1 C497.2 C499.2 C500.2 C503.2 C504.2 PJ7.2 PR149.1 U22.AA22 U22.AB23 U22.AC24 U22.AD25 U22.AE26 U22.AE27
+601_VCC: C449.1 C450.1 C451.1 C466.1 C476.1 C479.1 R435.2 R451.2 R461.2 R465.2 R470.2 R476.2 R481.2 R488.1 U17.10 U17.20(VCC#2)
+AZA_VDD: C624.1 C656.1 C666.1 R364.2 R780.2 U30.1 U30.36
+FB_PLLAVDD: C95.2 C114.1 C136.2 C139.2 L3.2 L4.2 U22.F16 U22.H22 U22.P22
+G_SEN_PW: C436.1 C447.1 R431.2 R468.1 R483.1 U16.1(VDD_IO) U16.8 U16.14
+SMDDR_VREF_DIMM: C208.1 C209.1 JDIM1.164 R149.2 R158.1 R159.2
+SMDDR_VREF_DQ1_M1: C130.1 C131.2 C132.2 C189.2 C190.2 C258.2 C259.2 C318.2 C319.1 R47.2 R51.2 R54.1 R65.2 U2.M1 U4.M1 U6.M1 U8.M1
+TYPEC_VBUS: C426.2 C452.2 C462.2 CN14.A4 CN14.A9 CN14.B4 CN14.B9(VBUS_4) D40.1 Q23.1 Q23.2 Q23.3(S3) Q26.1 R472.1 R493.1 R494.2
+TYPEC_VBUS_C: C706.1 C709.2 Q23.5 U36.14 U36.15
+USBPWR0: C304.2 C310.2 C593.2 C599.2 CN5.1 R646.1 R649.1 U5.2(VDD) U7.12(VOUT)
+USBPWR1: C604.2 C608.2 C609.2 C612.2 CN7.1 R646.2 R649.2 U11.2(VDD) U28.1(OUT)
+VGPU_CORE: C1.1 C2.1 C5.2 C6.1 C7.2 C8.1 C13.1 C14.2 C44.1 C55.2 C56.2 C60.2 C66.2 C70.2 C71.2 C72.2 C73.2 C74.2 C76.2 C77.2 C82.2 C83.2 C84.2 C85.2 C86.2 C98.2 C99.2 C100.2 C101.2 C102.2 C104.2 C107.2 C108.2 C109.2 C110.2 C494.2 C496.2 C505.2 C506.2 C507.2 C509.2 C510.2 C511.2 C512.2 C513.2 C517.2 C519.2 C522.1 PC9.1 PC135.1 PC141.1 PC144.1 PC150.1 PL4.2 PL5.2 PR28.1 U22.K10 U22.K12 U22.K14 U22.K16 U22.K18 U22.L11 U22.L13 U22.L15 U22.L17 U22.M10 U22.M12 U22.M14 U22.M16 U22.M18 U22.N11 U22.N13 U22.N15 U22.N17 U22.P10 U22.P12 U22.P14 U22.P16 U22.P18 U22.R11 U22.R13 U22.R15 U22.R17 U22.T10 U22.T12 U22.T14 U22.T16 U22.T18 U22.U11 U22.U13 U22.U15 U22.U17 U22.V10 U22.V12 U22.V14 U22.V16 U22.V18
+VNN_EXT: R255.1 U24.CY34
+VREF06_RT3612: PR57.1 PR178.1 PR190.1 PR191.1 PR199.1 PR201.1 PR208.1 PU4.12
AC_PRESENT_EC: R317.2 R330.2 U13.84 U24.DE46
ACCEL_INT2: D15.1(CATHODE) R835.2
ACCEL_INT2_R: D15.2 U16.9
ACCEL_INTA: C395.2 D14.1(CATHODE) R733.1 U24.DP21
ACCEL_INTA_R: D14.2 U16.11
ACIN: PR74.1 PR75.2 PR80.1 U13.72
ACZ_BCLK: R687.2 U24.CY46
ACZ_RST#: R684.2 R685.2 U24.DA47
ACZ_SDOUT: R677.2 R679.2 R683.2 U24.CY47
ACZ_SPKR: D34.2 R664.2 R665.1 U24.CH47
ACZ_SYNC: R682.2 U24.CV49
ADOGND: C323.1 C327.1 C332.1 C340.1 C343.1 C366.2 C375.1 C616.1 C619.2 C620.2 C623.2 C627.2 C629.1 C635.2 C643.1 CN6.1 CN6.3 CN6.5 CN6.12 R224.2 R249.2 R275.1 R281.1 R289.1 R345.1 R686.1 R691.1 R720.1 U30.25 U30.38
ADP_ID: PJ6.3 PQ9.2 PR69.1 PR71.2
ALERT: R56.1 U22.F8
AMP_MUTE#: D36.1(CATHODE) U13.108
AP_EQ: R817.2 R824.1 U34.9
AUX_PWRGD: PR227.1 TP78.1
BAT-V: PC236.1 PC241.1 PC246.1 PC256.2 PC258.1 PD4.1 PJ11.7 PJ11.8 PR266.2 PR271.2
BATLED0#: CN6.24 U13.29
BATLED1#: CN6.23 U13.25
BATLOW#: R397.1 U24.DH48
BI: PJ11.6 PR112.1 R622.1 SW3.1 SW3.2
BIOS_WP#: R351.1 R363.2 U32.3(WP#) U33.3
BL#: Q4.2 Q4.3 R24.1
BL_ON: CN2.26 D1.2 Q3.3 Q4.6 R13.1
BOARD_ID0: R639.1 R640.2 U24.CC45
BOARD_ID1: R631.1 R632.2 U24.CC48
BOARD_ID2: R634.1 R635.2 U24.CC49
BOARD_ID3: R629.1 R630.2 U24.CC47
BOARD_ID4: C541.2 R517.1 R650.1 R651.2 U24.CF45
BOARD_ID5: R644.1 R645.2 U24.CE47
BOARD_ID6: C532.2 R516.1 R647.1 R648.2 U24.CE46
BOARD_ID7: R652.1 R653.2 U24.CF49
BRIGHT: R21.2 R25.2 R26.1
BT_EN: CN9.54(W_DISABLE2#) R402.2 R825.1
BXTALOUT: R562.1 R563.1 U22.C10
C_IN_CLK: C561.2 CN4.10 R111.1 R115.2 R589.1
C_IN_CLK#: C562.2 CN4.12 R117.1 R118.2 R589.2
C_IN_CLK#_R: C196.2 U3.31
C_IN_CLK_R: C187.2 U3.32
C_TX0_HDMI+: C571.2 CN4.7 R150.2 R153.1 R606.1
C_TX0_HDMI+_R: C203.2 U3.26
C_TX0_HDMI-: C572.2 CN4.9 R157.1 R160.2 R606.2
C_TX0_HDMI-_R: C206.2 U3.25
C_TX1_HDMI+: C569.2 CN4.4 R137.2 R138.1 R601.1
C_TX1_HDMI+_R: C200.2 U3.28
C_TX1_HDMI-: C570.2 CN4.6 R144.1 R145.2 R601.2
C_TX1_HDMI-_R: C201.2 U3.27
C_TX2_HDMI+: C567.2 CN4.1 R121.1 R122.2 R595.1
C_TX2_HDMI+_R: C197.2 U3.30
C_TX2_HDMI-: C568.2 CN4.3 R124.1 R130.2 R595.2
C_TX2_HDMI-_R: C198.2 U3.29
CFG_RCOMP: R173.1 U24.AD6
CHA_SA0: JDIM1.256 R57.2 R58.1
CHA_SA1: JDIM1.260 R62.1 R63.2
CHA_SA2: JDIM1.166 R605.2 R609.1
CLK_24M_DEBUG_R: CN9.60 R831.2
CLK_BIASREF: R308.1 U24.DU6
CLK_PCIE_LANN: U1.16 U24.CJ2
CLK_PCIE_LANP: U1.15 U24.CJ1
CLK_PCIE_REQ2#: R391.1 TP38.1 U24.DP34
CLK_PCIE_REQ3#: R729.1 TP94.1 U24.DP36
CLK_PCIE_SSDN: R848.1 U24.CL2
CLK_PCIE_SSDN_C: CN18.53 R848.2
CLK_PCIE_SSDP: R847.1 U24.CL1
CLK_PCIE_SSDP_C: CN18.55 R847.2
CLK_PCIE_WLANN: CN9.49 U24.CF5
CLK_PCIE_WLANP: CN9.47 U24.CF3
CLK_VGA_N: U22.AD8 U24.CJ3
CLK_VGA_P: U22.AE8 U24.CJ5
CLR_CMOS: Q28.2 Q29.2 R496.2 U13.19
CNV_BRI_DT: CN9.36 R329.2 R337.1 R353.2 R799.2
CNV_BRI_DT_R: R329.1 U24.DL31
CNV_BRI_RSP: R761.2 U24.DL29
CNV_BRI_RSP_L: CN9.22 R761.1
CNV_RF_RESET#: R349.1 R396.1 R672.1 U12.1 U12.2 U24.CT48
CNV_RF_RESET#_L: CN9.10 R349.2 R350.1 U12.4
CNV_RGI_DT: CN9.32 R307.2 R328.2 R786.2
CNV_RGI_DT_R: R307.1 U24.DP31
CNV_RGI_RSP: R793.2 U24.DN29
CNV_RGI_RSP_L: CN9.34 R793.1
CNV_WR_CLK_DN: CN9.21 U24.DK44
CNV_WR_CLK_DP: CN9.23 U24.DJ44
CNV_WR_LANE0_DN: CN9.15 U24.DP44
CNV_WR_LANE0_DP: CN9.17 U24.DN44
CNV_WR_LANE1_DN: CN9.9 U24.DG42
CNV_WR_LANE1_DP: CN9.11 U24.DG44
CNV_WT_CLK_DN: CN9.71 U24.DL42
CNV_WT_CLK_DP: CN9.73 U24.DK42
CNV_WT_LANE0_DN: CN9.65 U24.DV45
CNV_WT_LANE0_DP: CN9.67 U24.DU45
CNV_WT_LANE1_DN: CN9.59 U24.DU44
CNV_WT_LANE1_DP: CN9.61 U24.DT44
CNV_WT_RCOMP: R724.1 U24.DT45
CODEC_VREF: C616.2 U30.28(VREF)
CON_DE: R774.2 R781.1 U34.15
CON_EQ: R775.1 R785.2 U34.18
CPU_C10_GATE#: R762.2 R776.1 U24.DU40
CPU_POPI_RCOMP: R230.2 U24.CJ41
CPU_PRDY#: TP14.1 U24.P6
CPU_PREQ#: R129.1 TP12.1 U24.M6
CPU_SVID_CLK: R590.1 U24.H2
CPU_SVID_DAT: R586.1 U24.H3
CPU_VIDALERT#: R587.1 U24.H1
CSI_RCOMP: R579.2 U24.B4
CTL2: R225.2 U7.7
CTL3: R222.2 U7.8
DBG_PMODE: R290.1 R300.1 TP34.1 U24.DL15
DC-DET: R375.1 R752.1 U30.4
DDCCLK_RIN: Q13.4 R195.2
DDCDATA_RIN: Q13.1(S) R194.2
DDR4_DRAMRST#: C293.2 C353.2 JDIM1.108 R282.2 U2.P1 U4.P1 U6.P1 U8.P1
DDR4_SUSON_2V5: PR124.1 U13.122
DDR_DRAMRST#_R: R278.2 R282.1 U24.DK47
DDR_RCOMP0: R576.2 U24.D47
DDR_RCOMP1: R575.2 U24.E46
DDR_RCOMP2: R577.2 U24.C47
DDR_VTT_CTRL: TP59.1 U24.M39
DE1: R465.1 R466.2 U17.9
DE2: R460.2 R461.1 U17.8
DEVSLP0: R742.1 R837.2 U24.DU12
DEVSLP0_R: HD1.5 R837.1
DEVSLP1: R737.1 U24.DU11
DEVSLP2: R258.1 R498.2 U24.CV48
DEW1: R481.1 R485.2 U17.16
DEW2: R435.1 R436.2 U17.6
DGPU_EDIDCLK: R561.1 U22.A9
DGPU_EDIDDATA: R560.1 U22.B9
DGPU_HOLD_RST#: R659.2 U19.1 U24.CH48
DGPU_OPP#: Q25.3 R480.1 U13.71
DGPU_OVT#_EC: Q1.3 R3.1 R791.1 U13.20
DGPU_PROCHOT_EC#: Q25.1(S) R479.1 U22.D7
DGPU_PSI: PR13.1 R549.1 R550.1
DGPU_PW_CTRL#: R388.2 R409.2 U24.CR38
DGPU_PWR_EN: PR38.2 R244.2 R245.1 R510.1 U24.CF47
DGPU_PWROK: Q31.2 R175.1 R658.1 U24.CH45
DIS_VCCSTG1: Q35.5 Q35.6 R612.1 R613.2
DIS_VCCSTG2: Q35.3 R611.2
DISP_ON: R535.2 R536.1 U23.3
DISP_UTILS: TP64.1 U24.D2
DMIC-DATA34: R338.1 TP36.1
DMIC_CLK: R749.2 U30.3
DMIC_CLK_2: CN1.3 R395.1
DMIC_CLK_2_R: C383.2 R395.2 U24.DG36
DMIC_CLK_L: C663.2 L11.2 R749.1
DMIC_CLK_L_C: C528.1 CN2.1 L11.1
DMIC_DAT: R745.1 U30.2
DMIC_DAT_2: CN1.2 R394.1
DMIC_DAT_2_R: R394.2 U24.DG34
DMIC_DAT_L: L12.2 R745.2
DMIC_DAT_L_C: C529.1 CN2.2 L12.1
DNBSWON#: U13.123 U24.CY42
DP_RCOMP: R610.1 U24.R2
DSI_DE_TE_2: R593.1 U24.J3
EC_FPBACK#: Q3.2 U13.86
EC_ODD_EJ#: CN15.16 R393.1 R463.1
EC_ODD_EJ_R#: C384.1 R393.2 U13.94
EC_PECI: R354.2 U24.CD5
EC_PECR_R: R354.1 U13.117
EC_PWROK: R359.1 R372.1 U13.33
EC_TYPEC_CHG: R840.2 U36.7
EC_TYPEC_CHG_HI: R838.2 U13.3 U36.8
EC_TYPEC_EN: R416.1 U13.80
EC_TYPEC_EN_R: R416.2 R478.1 U36.6
ECAGND: C433.2 C434.1 C457.1 L9.1 U13.75
EMMC_RCOMP: R326.1 U24.DU28
EN: R446.2 R451.1 U17.7
EQ1: R476.1 R477.2 U17.17
EQ2: R470.1 R471.2 U17.19
ESPI_0: R231.2 U13.10
ESPI_0_R: R231.1 U24.CN45
ESPI_1: R233.2 U13.9
ESPI_1_R: R233.1 U24.CN48
ESPI_2: R236.2 U13.8
ESPI_2_R: R236.1 U24.CN49
ESPI_3: R237.2 U13.7
ESPI_3_R: R237.1 U24.CN47
ESPI_CLK: C326.2 R240.2 R419.2 U13.13
ESPI_CLK_R: R240.1 U24.CR47
ESPI_CS#: R243.1 R254.2 U13.6
ESPI_CS#_R: R254.1 U24.CT45
ESPI_RESET#: R239.2 R242.2 R441.1
ESPI_RESET#_R: R242.1 U24.CR46
EXT_PWR_GATE#: R654.1 U24.CL39
FAN1_RPM: FAN1.2 R371.2 U13.47
FAN_PWM: Q16.1(EMITTER) U13.32
FAN_PWM_C: FAN1.3 Q16.3 R370.2
FB_CAL_PD_VDDQ: R84.2 U22.D22
FB_CAL_PU_GND: R82.2 U22.C24
FB_CAL_TERM_GND: R541.1 U22.B25
FBA_CMD0: U22.C27 VRAM2.G12
FBA_CMD1: U22.C26 VRAM2.H10
FBA_CMD2: U22.E24 VRAM2.H11
FBA_CMD3: U22.F24 VRAM2.K11
FBA_CMD4: U22.D27 VRAM2.K10
FBA_CMD5: U22.D26 VRAM2.L12
FBA_CMD6: U22.F25 VRAM2.K4
FBA_CMD7: U22.F26 VRAM2.K5
FBA_CMD8: U22.F23 VRAM2.J4
FBA_CMD9: U22.G22 VRAM2.J5
FBA_CMD10: U22.G23 VRAM2.H4
FBA_CMD11: U22.G24 VRAM2.H5
FBA_CMD12: U22.F27 VRAM2.G3
FBA_CMD13: R526.2 U22.G25 VRAM2.J2
FBA_CMD14: R527.2 U22.G27 VRAM2.J3
FBA_CMD15: U22.G26 VRAM2.L3
FBA_CMD16: U22.M24 VRAM1.G12
FBA_CMD17: U22.M23 VRAM1.H10
FBA_CMD18: U22.K24 VRAM1.H11
FBA_CMD19: U22.K23 VRAM1.K11
FBA_CMD20: U22.M27 VRAM1.K10
FBA_CMD21: U22.M26 VRAM1.L12
FBA_CMD22: U22.M25 VRAM1.K4
FBA_CMD23: U22.K26 VRAM1.K5
FBA_CMD24: U22.K22 VRAM1.J4
FBA_CMD25: U22.J23 VRAM1.J5
FBA_CMD26: U22.J25 VRAM1.H4
FBA_CMD27: U22.J24 VRAM1.H5
FBA_CMD28: U22.K27 VRAM1.G3
FBA_CMD29: R29.1 U22.K25 VRAM1.J2
FBA_CMD30: R525.1 U22.J27 VRAM1.J3
FBA_CMD31: U22.J26 VRAM1.L3
FBA_DBI0: U22.D19 VRAM2.D2
FBA_DBI1: U22.D14 VRAM2.D13
FBA_DBI2: U22.C17 VRAM2.P13
FBA_DBI3: U22.C22 VRAM2.P2
FBA_DBI4: U22.P24 VRAM1.P13
FBA_DBI5: U22.W24 VRAM1.P2
FBA_DBI6: U22.AA25 VRAM1.D2
FBA_DBI7: U22.U25 VRAM1.D13
FBA_EDC0: U22.E19 VRAM2.C2
FBA_EDC1: U22.C15 VRAM2.C13
FBA_EDC2: U22.B16 VRAM2.R13
FBA_EDC3: U22.B22 VRAM2.R2
FBA_EDC4: U22.R25 VRAM1.R13
FBA_EDC5: U22.W23 VRAM1.R2
FBA_EDC6: U22.AB26 VRAM1.C2
FBA_EDC7: U22.T26 VRAM1.C13
FBA_VREFC_1: C137.1 R43.2 R45.2 R49.2 VRAM2.J14
FBA_VREFC_2: C92.1 R35.2 R36.2 R40.2 VRAM1.J14
FBVDD_EN: R504.2 R505.1 U20.4(Y)
FBVDDQ_EN: PR163.2 R505.2
G5335-AGND-2: PC175.2 PC178.2 PR44.2 PR45.2 PR169.2 PU9.4
G5335-BST-2: PR154.2 PU9.20
G5335-EN-2: PC178.1 PQ6.2 PR163.1 PR166.2 PU9.2
G5335-FB-2: PC183.1 PR167.2 PR169.1 PU9.5
G5335-LX-2: PC171.1 PL6.1 PR156.1 PU9.10 PU9.11 PU9.16 PU9.17 PU9.18 PU9.25
G5335-PFM-2: PR43.1 PR44.1 PU9.3
G5335-PWRGD-2: PR157.1 PU9.1
G5335-SS-2: PC175.1 PU9.23
G5335-TON-2: PR168.1 PU9.6
G5335-VCC-2: PC170.1 PR155.2 PU9.21(VCC)
G5719LX1.5V: PL12.1 PU14.3
G_MBCLK_R: C467.1 R483.2 R484.2 U16.4
G_MBDATA_R: C464.1 R468.2 R475.2 U16.6
GC6_FB_EN: Q9.2 R81.1 R86.1
GC6_FB_EN_N17: R81.2 U22.B2
GC6_FB_EN_Q: Q8.3 R261.2 R262.1 U20.1 U24.CL47
GC6FBEN_Q_EC: TP39.1 U13.2
GPD7: R405.1 R413.2 U24.DC47
GPIO10_VREF: Q5.2 R64.2 U22.C5
GPP_B18: R655.2 R656.1 R657.1 U24.CF48
GPP_B23: R663.2 R666.1 U24.CL48
GPP_C2: R303.1 R346.2 U24.DL24
GPP_C5: R334.1 R347.2 U24.DP22
GPP_E6: R736.1 R760.1 U24.DT12
GPP_E10: R725.1 R735.2 R747.2 U24.DW16
GPP_E11: R728.2 R739.2 R750.2 U24.DV16
GPP_E19: R301.1 R304.2 U24.DK17
GPP_H2: R408.1 R415.2 U24.DJ38
GPPC_D19: TP37.1 U24.DP33
GPU_CHOKE_THERMAL: PR30.1 R325.1 U13.126
GPU_EVENT#: D2.1(CATHODE) R673.2 U24.CK46
GPU_EVENT#_GPU: D2.2 R50.1 R53.1
GPU_GPIO0: R551.2 U22.C6
GPU_GPIO2: R53.2 U22.D6
GPU_GPIO6: R549.2 U22.A4
GPU_GPIO21: R548.1 U22.C4
GPU_PEX_RST_HOLD#: R555.1 U22.D5
GPU_PWR_GD: PR29.1 PR153.2 R509.1
GPUT_CLK_L: Q15.4(S2) R341.1 U22.D9
GPUT_DATA_L: Q15.1 R340.1 U22.D8
H_CATERR#: R591.1 U24.J4
H_PROCHOT#: C725.2 D23.2 PR60.1 PR203.1 PR252.1 PU12.10 Q20.3 R571.2 R582.1 R583.1
H_VCCST_PWRGD: R633.2 R637.2 U24.CF2
HDMI_EQ0: R102.1 R103.1 U3.8
HDMI_EQ1: R100.1 R105.1 U3.2
HDMI_HPD: Q10.3 R93.2 R98.1 U3.21 VC1.1
HDMI_HPD_C: C183.1 CN4.19 R98.2
HDMI_HPD_CON: R97.1 U24.CV42
HDMI_MB_HPD_R: Q10.1(S) R96.1 R97.2 U3.5
HDMI_SCLK: C239.1 CN4.15 D3.2 Q13.3 R163.2 U3.19
HDMI_SDATA: C249.1 CN4.16 D4.2 Q13.6 R164.2 U3.20
HOLD#: R324.2 R335.1 U32.7 U33.7
HP-L2: C333.2 R238.2 R248.2 R249.1 U30.32
HP-L3: C327.2 CN6.4 R238.1
HP-R2: C334.2 R224.1 R227.2 R232.2 U30.33
HP-R3: C323.2 CN6.2 R232.1
HP_JD#: CN6.13 R715.2
HWPG: D8.2 D9.2 D11.2 D12.2 D33.1(CATHODE) R336.2 R369.1 R636.2 U13.21
HWPG_1.5V: PR102.2 PR109.1 R336.1
HWPG_1.8VS5: D11.1(CATHODE) PR91.1 PR101.2
HWPG_1.35VGFX: PR157.2 PR158.2 R175.2
HWPG_VDDR: D8.1(CATHODE) D12.1(CATHODE) PR128.1 PR131.1
I2CA_SCL: R556.1 U22.B7
I2CA_SDA: R557.1 U22.A7
ICMNT: C457.2 PC235.2 PR249.1 U13.67
IDCHG_R: C453.2 PC73.2 PR250.1 U13.68
ILIM_HI: R235.2 U7.16
ILIM_LO: R223.2 U7.15
IMONCPU_1: PR161.2 PR191.2
IMVP_PWRGD: PR53.1 PR55.2 Q12.2 R702.2
IN_CLK: C187.1 R110.1 U24.AC2
IN_CLK#: C196.1 R116.1 U24.AC1
IN_CLK#_R: C562.1 D26.2 R116.2
IN_CLK_R: C561.1 D25.2 R110.2
IN_D0: C203.1 R148.1 U24.AC3
IN_D0#: C206.1 R155.1 U24.AC5
IN_D0#_R: C572.1 D32.2 R155.2
IN_D0_R: C571.1 D31.2 R148.2
IN_D1: C200.1 R131.1 U24.AE1
IN_D1#: C201.1 R142.1 U24.AE2
IN_D1#_R: C570.1 D30.2 R142.2
IN_D1_R: C569.1 D29.2 R131.2
IN_D2: C197.1 R119.1 U24.AE5
IN_D2#: C198.1 R123.1 U24.AE3
IN_D2#_R: C568.1 D28.2 R123.2
IN_D2_R: C567.1 D27.2 R119.2
INPUT3VSEL: R705.2 R706.2 U24.DN49
INT_AMIC-VREFO: C620.1 R686.2 U30.27
INT_EDP_AUXN: C43.2 U24.W4
INT_EDP_AUXN_C: C43.1 CN2.22 R18.1
INT_EDP_AUXP: C53.2 U24.W3
INT_EDP_AUXP_C: C53.1 CN2.23 R22.1
INT_EDP_TXN0: C537.2 U24.Y5
INT_EDP_TXN0_C: C537.1 CN2.19
INT_EDP_TXN1: C535.2 U24.Y1
INT_EDP_TXN1_C: C535.1 CN2.16
INT_EDP_TXN2: C533.2 U24.V2
INT_EDP_TXN2_C: C533.1 CN2.13
INT_EDP_TXN3: C530.2 U24.V3
INT_EDP_TXN3_C: C530.1 CN2.10
INT_EDP_TXP0: C538.2 U24.Y3
INT_EDP_TXP0_C: C538.1 CN2.20
INT_EDP_TXP1: C536.2 U24.Y2
INT_EDP_TXP1_C: C536.1 CN2.17
INT_EDP_TXP2: C534.2 U24.V1
INT_EDP_TXP2_C: C534.1 CN2.14
INT_EDP_TXP3: C531.2 U24.V5
INT_EDP_TXP3_C: C531.1 CN2.11
INT_HDMICLK+_OUT: R118.1 U3.10
INT_HDMICLK-_OUT: R115.1 U3.9
INT_HDMITX0N_OUT: R150.1 U3.15
INT_HDMITX0P_OUT: R160.1 U3.16
INT_HDMITX1N_OUT: R137.1 U3.13
INT_HDMITX1P_OUT: R145.1 U3.14
INT_HDMITX2N_OUT: R122.1 U3.11
INT_HDMITX2P_OUT: R130.1 U3.12
INTRUDER#: C642.2 R712.2 R713.1 U24.DR47
ISEN1N: PC51.1 PC186.1 PR48.2 PR49.1 PR164.2
ISEN1P: PR165.2 PR171.2
ISEN1P_1: PR171.1 PR174.2
ISEN2N: PC49.1 PC187.1 PR50.1 PR51.2 PR182.2
ISEN2P: PR175.2 PR183.2
ISEN2P_1: PR175.1 PR176.2
ISOLATEB: R30.2 R31.1 U1.20
IST_TP_0: R199.2 U24.BF11
IST_TP_1: R197.1 U24.BD11
IST_TRIG_0: R197.2 U24.BE10
IST_TRIG_1: R199.1 U24.BF10
JTAG_TCK: TP51.1 U22.AE5
JTAG_TDI: TP52.1 U22.AE6
JTAG_TDO: TP53.1 U22.AF6
JTAG_TMS: TP50.1 U22.AD6
JTAG_TRST#: R508.1 U22.AG4
KB_BL_LED: Q44.2 U13.113
KL_NO_EC: PR96.2 PR122.2 U13.70
L_SPK+: R442.1 U30.42
L_SPK+_1: C396.1 CN11.4 R442.2
L_SPK-: R443.1 U30.43
L_SPK-_1: C397.1 CN11.3 R443.2
LAD0_R: CN9.58 R830.2
LAD1: CN9.66 R836.2
LAD2: CN9.68 TP101.1
LAD3: CN9.70 TP100.1
LAN_AMBLED#: TP4.1 U1.27
LAN_LED1: TP2.1 U1.26
LAN_LED2: TP3.1 U1.25
LAN_MCTG0: R11.2 U21.24
LAN_MCTG1: R10.2 U21.21
LAN_MCTG2: R8.2 U21.18
LAN_MCTG3: R9.2 U21.15
LAN_XTAL1: C33.2 R16.1 Y1.1
LANPWR#: R5.2 R14.1 U13.16
LCD_PRIVACY_PCH: TP29.1 U24.DK38
LFRAME#_R: CN9.62 R832.2
LID#: C498.1 D1.1(CATHODE) D21.2 HE1.1 R23.2 R368.2
LID#_C: C381.1 D10.1 R368.1 U13.118
LINE1-L: C333.1 U30.22
LINE1-R: C334.1 U30.21
LINE1-VREFO-L: R248.1 U30.31
LINE1-VREFO-R: R227.1 U30.30
M_A_A0: JDIM1.144 U24.BB48
M_A_A1: JDIM1.133 U24.BL49
M_A_A2: JDIM1.132 U24.BG38
M_A_A3: JDIM1.131 U24.BL45
M_A_A4: JDIM1.128 U24.BJ46
M_A_A5: JDIM1.126 U24.BG48
M_A_A6: JDIM1.127 U24.BE45
M_A_A7: JDIM1.122 U24.BG45
M_A_A8: JDIM1.125 U24.BG47
M_A_A9: JDIM1.121 U24.BE47
M_A_A10: JDIM1.146 U24.BJ38
M_A_A11: JDIM1.120 U24.BB47
M_A_A12: JDIM1.119 U24.BE48
M_A_A13: JDIM1.158 U24.BM39
M_A_ACT#: JDIM1.114 U24.BE49
M_A_ALERT#: JDIM1.116 U24.BD46
M_A_BG#0: JDIM1.115 U24.BB49
M_A_BG#1: JDIM1.113 U24.BD47
M_A_BS#0: JDIM1.150 U24.BM43
M_A_BS#1: JDIM1.145 U24.BG39
M_A_CAS#: JDIM1.156 U24.BJ42
M_A_CB0: JDIM1.92 R213.2
M_A_CB1: JDIM1.91 R212.2
M_A_CB2: JDIM1.101 R203.2
M_A_CB3: JDIM1.105 R201.2
M_A_CB4: JDIM1.88 R220.2
M_A_CB5: JDIM1.87 R216.2
M_A_CB6: JDIM1.100 R207.2
M_A_CB7: JDIM1.104 R206.2
M_A_CKE0: JDIM1.109 U24.BG49
M_A_CKE1: JDIM1.110 U24.BF41
M_A_CLKN0: JDIM1.139 U24.BL48
M_A_CLKN1: JDIM1.140 U24.BF42
M_A_CLKP0: JDIM1.137 U24.BL47
M_A_CLKP1: JDIM1.138 U24.BF43
M_A_CS#0: JDIM1.149 U24.BM38
M_A_CS#1: JDIM1.157 U24.BG42
M_A_DIM0_ODT0: JDIM1.155 U24.BJ39
M_A_DIM0_ODT1: JDIM1.161 U24.BB45
M_A_DQ0: JDIM1.46 U24.CA48
M_A_DQ1: JDIM1.45 U24.CA47
M_A_DQ2: JDIM1.49 U24.CA49
M_A_DQ3: JDIM1.59 U24.BV49
M_A_DQ4: JDIM1.50 U24.CA45
M_A_DQ5: JDIM1.63 U24.BV47
M_A_DQ6: JDIM1.58 U24.BV45
M_A_DQ7: JDIM1.62 U24.BV48
M_A_DQ8: JDIM1.17 U24.CC42
M_A_DQ9: JDIM1.16 U24.CC39
M_A_DQ10: JDIM1.21 U24.CC43
M_A_DQ11: JDIM1.8 U24.CE38
M_A_DQ12: JDIM1.20 U24.CC38
M_A_DQ13: JDIM1.4 U24.CE39
M_A_DQ14: JDIM1.3 U24.CE42
M_A_DQ15: JDIM1.7 U24.CE43
M_A_DQ16: JDIM1.67 U24.BT48
M_A_DQ17: JDIM1.70 U24.BT47
M_A_DQ18: JDIM1.71 U24.BT49
M_A_DQ19: JDIM1.84 U24.BN49
M_A_DQ20: JDIM1.66 U24.BT45
M_A_DQ21: JDIM1.80 U24.BN47
M_A_DQ22: JDIM1.79 U24.BN45
M_A_DQ23: JDIM1.83 U24.BN48
M_A_DQ24: JDIM1.37 U24.BV42
M_A_DQ25: JDIM1.42 U24.BV39
M_A_DQ26: JDIM1.41 U24.BV43
M_A_DQ27: JDIM1.28 U24.BW38
M_A_DQ28: JDIM1.38 U24.BV38
M_A_DQ29: JDIM1.24 U24.BW39
M_A_DQ30: JDIM1.25 U24.BW42
M_A_DQ31: JDIM1.29 U24.BW43
M_A_DQ32: JDIM1.187 U24.AY48
M_A_DQ33: JDIM1.186 U24.AY47
M_A_DQ34: JDIM1.182 U24.AY49
M_A_DQ35: JDIM1.174 U24.AU45
M_A_DQ36: JDIM1.183 U24.AY45
M_A_DQ37: JDIM1.170 U24.AU47
M_A_DQ38: JDIM1.169 U24.AU48
M_A_DQ39: JDIM1.173 U24.AU49
M_A_DQ40: JDIM1.225 U24.AY42
M_A_DQ41: JDIM1.228 U24.AY38
M_A_DQ42: JDIM1.229 U24.AY43
M_A_DQ43: JDIM1.211 U24.BB39
M_A_DQ44: JDIM1.224 U24.AY39
M_A_DQ45: JDIM1.215 U24.BB38
M_A_DQ46: JDIM1.216 U24.BB42
M_A_DQ47: JDIM1.212 U24.BB43
M_A_DQ48: JDIM1.190 U24.AR48
M_A_DQ49: JDIM1.195 U24.AR47
M_A_DQ50: JDIM1.208 U24.AR49
M_A_DQ51: JDIM1.207 U24.AM45
M_A_DQ52: JDIM1.194 U24.AR45
M_A_DQ53: JDIM1.191 U24.AM47
M_A_DQ54: JDIM1.204 U24.AM48
M_A_DQ55: JDIM1.203 U24.AM49
M_A_DQ56: JDIM1.233 U24.AT42
M_A_DQ57: JDIM1.236 U24.AT39
M_A_DQ58: JDIM1.245 U24.AR43
M_A_DQ59: JDIM1.232 U24.AT38
M_A_DQ60: JDIM1.250 U24.AR38
M_A_DQ61: JDIM1.246 U24.AR39
M_A_DQ62: JDIM1.249 U24.AR42
M_A_DQ63: JDIM1.237 U24.AT43
M_A_DQSN0: JDIM1.53 U24.BY47
M_A_DQSN1: JDIM1.11 U24.CC41
M_A_DQSN2: JDIM1.74 U24.BR47
M_A_DQSN3: JDIM1.32 U24.BV41
M_A_DQSN4: JDIM1.177 U24.AV46
M_A_DQSN5: JDIM1.219 U24.AY41
M_A_DQSN6: JDIM1.198 U24.AN46
M_A_DQSN7: JDIM1.240 U24.AR41
M_A_DQSN8: JDIM1.95 R208.1
M_A_DQSP0: JDIM1.55 U24.BY46
M_A_DQSP1: JDIM1.13 U24.CE41
M_A_DQSP2: JDIM1.76 U24.BR46
M_A_DQSP3: JDIM1.34 U24.BW41
M_A_DQSP4: JDIM1.179 U24.AV47
M_A_DQSP5: JDIM1.221 U24.BB41
M_A_DQSP6: JDIM1.200 U24.AN47
M_A_DQSP7: JDIM1.242 U24.AT41
M_A_DQSP8: JDIM1.97 R205.1
M_A_PARITY: JDIM1.143 U24.BF39
M_A_RAS#: JDIM1.152 U24.BM41
M_A_WE#: JDIM1.151 U24.BG43
M_B1_ZQ0: R113.1 U2.F9(ZQ)
M_B2_ZQ0: R189.1 U4.F9(ZQ)
M_B3_ZQ0: R228.1 U6.F9(ZQ)
M_B4_ZQ0: R294.1 U8.F9(ZQ)
M_B_A0: R85.2 U2.P3 U4.P3 U6.P3 U8.P3 U24.P42
M_B_A1: R89.2 U2.P7 U4.P7 U6.P7 U8.P7 U24.Y49
M_B_A2: R66.2 U2.R3 U4.R3 U6.R3 U8.R3 U24.U48
M_B_A3: R88.2 U2.N7 U4.N7 U6.N7 U8.N7 U24.Y45
M_B_A4: R87.2 U2.N3 U4.N3 U6.N3 U8.N3 U24.U47
M_B_A5: R91.2 U2.P8 U4.P8 U6.P8 U8.P8 U24.R49
M_B_A6: R71.2 U2.P2 U4.P2 U6.P2 U8.P2 U24.U49
M_B_A7: R101.2 U2.R8 U4.R8 U6.R8 U8.R8 U24.M47
M_B_A8: R70.2 U2.R2 U4.R2 U6.R2 U8.R2 U24.M45
M_B_A9: R90.2 U2.R7 U4.R7 U6.R7 U8.R7 U24.R47
M_B_A10: R76.2 U2.M3 U4.M3 U6.M3 U8.M3 U24.P39
M_B_A11: R68.2 U2.T2 U4.T2 U6.T2 U8.T2 U24.N46
M_B_A12: R72.2 U2.M7 U4.M7 U6.M7 U8.M7 U24.R48
M_B_A13: R92.2 U2.T8 U4.T8 U6.T8 U8.T8 U24.Y41
M_B_ACT#: R80.2 U2.L3 U4.L3 U6.L3 U8.L3 U24.M48
M_B_ALERT#: R112.1 U2.P9 U4.P9 U6.P9 U8.P9 U24.M49
M_B_BG#0: R75.2 U2.M2 U4.M2 U6.M2 U8.M2 U24.R45
M_B_BG#1: R267.1 U24.N47
M_B_BG#1_R: R120.1 R139.2 R267.2 U2.M9 U4.M9 U6.M9 U8.M9
M_B_BS#0: R74.2 U2.N2 U4.N2 U6.N2 U8.N2 U24.T38
M_B_BS#1: R109.2 U2.N8 U4.N8 U6.N8 U8.N8 U24.T42
M_B_CAS#: R108.2 U2.M8 U4.M8 U6.M8 U8.M8 U24.Y42
M_B_CKE0: R79.2 U2.K2 U4.K2 U6.K2 U8.K2 U24.U45
M_B_CLKN0: C176.1 R95.1 U2.K8 U4.K8 U6.K8 U8.K8 U24.Y48
M_B_CLKP0: C176.2 R94.1 U2.K7 U4.K7 U6.K7 U8.K7 U24.Y47
M_B_CS#0: R77.2 U2.L7 U4.L7 U6.L7 U8.L7 U24.V42
M_B_DIM0_ODT0: R78.2 U2.K3 U4.K3 U6.K3 U8.K3 U24.V43
M_B_DQ0: U8.F7 U24.AK48
M_B_DQ1: U8.J7 U24.AK45
M_B_DQ2: U8.H7 U24.AK49
M_B_DQ3: U8.J3 U24.AG47
M_B_DQ4: U8.H8 U24.AK47
M_B_DQ5: U8.G2 U24.AG45
M_B_DQ6: U8.H2 U24.AG48
M_B_DQ7: U8.H3 U24.AG49
M_B_DQ8: U8.C2 U24.AJ38
M_B_DQ9: U8.C8 U24.AL39
M_B_DQ10: U8.C3 U24.AJ39
M_B_DQ11: U8.B8 U24.AL43
M_B_DQ12: U8.C7 U24.AL38
M_B_DQ13: U8.A3 U24.AJ42
M_B_DQ14: U8.D7 U24.AL42
M_B_DQ15: U8.D3 U24.AJ43
M_B_DQ16: U6.C3 U24.AB49
M_B_DQ17: U6.C2 U24.AB48
M_B_DQ18: U6.D7 U24.AE49
M_B_DQ19: U6.C8 U24.AE47
M_B_DQ20: U6.B8 U24.AE48
M_B_DQ21: U6.A3 U24.AB47
M_B_DQ22: U6.C7 U24.AB45
M_B_DQ23: U6.D3 U24.AE45
M_B_DQ24: U6.G2 U24.AD38
M_B_DQ25: U6.H2 U24.AD39
M_B_DQ26: U6.H8 U24.AE39
M_B_DQ27: U6.H7 U24.AE43
M_B_DQ28: U6.F7 U24.AE38
M_B_DQ29: U6.J3 U24.AD43
M_B_DQ30: U6.H3 U24.AD42
M_B_DQ31: U6.J7 U24.AE42
M_B_DQ32: U4.F7 U24.J48
M_B_DQ33: U4.H7 U24.J45
M_B_DQ34: U4.J7 U24.J49
M_B_DQ35: U4.H3 U24.G47
M_B_DQ36: U4.H8 U24.J47
M_B_DQ37: U4.H2 U24.G45
M_B_DQ38: U4.G2 U24.G48
M_B_DQ39: U4.J3 U24.E48
M_B_DQ40: U4.C2 U24.J38
M_B_DQ41: U4.D3 U24.G39
M_B_DQ42: U4.A3 U24.G38
M_B_DQ43: U4.C3 U24.G42
M_B_DQ44: U4.D7 U24.J39
M_B_DQ45: U4.B8 U24.J42
M_B_DQ46: U4.C7 U24.G43
M_B_DQ47: U4.C8 U24.J43
M_B_DQ48: U2.C7 U24.B43
M_B_DQ49: U2.D3 U24.D43
M_B_DQ50: U2.B8 U24.A43
M_B_DQ51: U2.C3 U24.C40
M_B_DQ52: U2.C8 U24.C43
M_B_DQ53: U2.D7 U24.D40
M_B_DQ54: U2.C2 U24.B40
M_B_DQ55: U2.A3 U24.A40
M_B_DQ56: U2.J3 U24.B35
M_B_DQ57: U2.H2 U24.D35
M_B_DQ58: U2.G2 U24.A35
M_B_DQ59: U2.J7 U24.D38
M_B_DQ60: U2.H3 U24.C35
M_B_DQ61: U2.H8 U24.C38
M_B_DQ62: U2.H7 U24.B38
M_B_DQ63: U2.F7 U24.A38
M_B_DQSN0: U8.F3 U24.AH46
M_B_DQSN1: U8.A7 U24.AJ41
M_B_DQSN2: U6.A7 U24.AC47
M_B_DQSN3: U6.F3 U24.AE41
M_B_DQSN4: U4.F3 U24.H47
M_B_DQSN5: U4.A7 U24.G41
M_B_DQSN6: U2.A7 U24.C42
M_B_DQSN7: U2.F3 U24.D36
M_B_DQSP0: U8.G3 U24.AH47
M_B_DQSP1: U8.B7 U24.AL41
M_B_DQSP2: U6.B7 U24.AC46
M_B_DQSP3: U6.G3 U24.AD41
M_B_DQSP4: U4.G3 U24.H46
M_B_DQSP5: U4.B7 U24.J41
M_B_DQSP6: U2.B7 U24.D42
M_B_DQSP7: U2.G3 U24.C36
M_B_PARITY: R67.2 U2.T3 U4.T3 U6.T3 U8.T3 U24.P38
M_B_RAS#: R69.2 U2.L8 U4.L8 U6.L8 U8.L8 U24.V47
M_B_WE#: R73.2 U2.L2 U4.L2 U6.L2 U8.L2 U24.V41
MAIND: PC68.1 PQ8.3 PQ10.2 PR67.2
MAINON: PQ7.2 PR59.1 PR89.1 PR92.2 PR116.2 PR121.2 PR125.1 PR214.1 PR259.1 R288.1 R462.1 U13.30
MAINON_ON_G: PQ7.3 PQ8.2 PQ23.2 PQ25.2 PQ28.2 PR64.2 PR73.1
MBCLK: PC123.1 PD6.1 PR120.2 PR255.1 R805.1 U13.110
MBDATA: PC122.1 PD5.1 PR119.2 PR253.1 R811.1 U13.111
MBP0#: R134.2 U24.T9
MBP1#: R135.2 U24.T7
MBP2#: R127.2 U24.T10
MBP3#: R136.2 U24.T6
MDI0+: U1.1 U21.9
MDI0+_1: CN3.1 U21.16
MDI0-: U1.2 U21.8
MDI0-_1: CN3.2 U21.17
MDI1+: U1.4 U21.12(TD4-)
MDI1+_1: CN3.3 U21.13
MDI1-: U1.5 U21.11
MDI1-_1: CN3.6 U21.14
MDI2+: U1.6 U21.2
MDI2+_1: CN3.4 U21.23
MDI2-: U1.7 U21.3
MDI2-_1: CN3.5 U21.22
MDI3+: U1.9 U21.6
MDI3+_1: CN3.7 U21.19
MDI3-: U1.10 U21.5
MDI3-_1: CN3.8 U21.20
ME_WR#: R679.1 U13.109
MEM_VREF_CTL_QA: Q5.3 R40.1 R43.1
MIC2-VREFO: R257.1 R260.1 U30.29
MINICAR_PME#: CN9.55 Q46.1(S) R833.1
MIPI60_CFG0#: R170.1 U24.AG6
MIPI60_CFG0#_R: R168.1 R169.2 R170.2 TP17.1
MIPI60_CFG1#: R171.1 R172.2 U24.AE7
MIPI60_CFG2#: R180.2 R181.1 U24.AG7
MIPI60_CFG3#: R161.1 R162.2 U24.AD9
MIPI60_CFG4#: R166.1 R167.2 U24.AE9
MIPI60_CFG5#: R151.1 R152.2 U24.AB9
MIPI60_CFG6#: R174.1 R176.2 U24.AJ6
MIPI60_CFG7#: R146.1 R147.2 U24.AB7
MIPI60_CFG8#: R125.1 R126.2 U24.V10
MIPI60_CFG9#: R185.2 R186.1 U24.AJ5
MIPI60_CFG10#: R132.1 R133.2 U24.Y10
MIPI60_CFG11#: R177.1 R179.2 U24.AJ7
MIPI60_CFG12#: R140.1 R141.2 U24.AB10
MIPI60_CFG13#: R182.2 R193.1 U24.AL7
MIPI60_CFG14#: R184.2 R192.1 U24.AL9
MIPI60_CFG15#: R183.2 R191.1 U24.AJ9
MIPI60_CFG16_STB_DN: R156.2 U24.V6
MIPI60_CFG17_STB_DP: TP13.1 U24.V7
MIPI60_CFG18_STB_DN: R143.2 U24.Y6
MIPI60_CFG19_STB_DP: TP16.1 U24.Y7
MODEM_CLKREQ: R256.2 R439.2 R455.1 U14.1 U14.2 U24.CT47
MODEM_CLKREQ_L: CN9.14 R404.1 R455.2 U14.4
MX0: C412.1 CN8.10 CN10.10 U13.58
MX1: C424.1 CN8.9 CN10.9 U13.59
MX2: C406.1 CN8.8 CN10.8 U13.60
MX3: C404.1 CN8.7 CN10.7 U13.61
MX4: C405.1 CN8.6 CN10.6 U13.62
MX5: C401.1 CN8.5 CN10.5 U13.63
MX6: C402.1 CN8.4 CN10.4 TP47.1 U13.64
MX7: C403.1 CN8.3 CN10.3 TP44.1 U13.65
MY0: C407.1 CN8.26 CN10.26 U13.36
MY1: C408.1 CN8.25 CN10.25 U13.37
MY2: C409.1 CN8.24 CN10.24 U13.38
MY3: C410.1 CN8.23 CN10.23 U13.39
MY4: C411.1 CN8.22 CN10.22 U13.40
MY5: C414.1 CN8.21 CN10.21 U13.41
MY6: C415.1 CN8.20 CN10.20 U13.42
MY7: C416.1 CN8.19 CN10.19 U13.43
MY8: C417.1 CN8.18 CN10.18 U13.44
MY9: C419.1 CN8.17 CN10.17 U13.45
MY10: C418.1 CN8.16 CN10.16 U13.46
MY11: C420.1 CN8.15 CN10.15 U13.51
MY12: C421.1 CN8.14 CN10.14 U13.52
MY13: C422.1 CN8.13 CN10.13 U13.53
MY14: C423.1 CN8.12 CN10.12 U13.54
MY15: C427.1 CN8.11 CN10.11 U13.55
MY16: C400.1 CN8.28 CN10.28 U13.56
MY17: C394.1 CN8.27 CN10.27 U13.57
N12E_SCL: R559.1 U22.C9
N12E_SDA: R558.1 U22.C8
NBSWON#: C676.2 CN8.1 D17.2 R362.1 R430.2 SW1.1 SW1.2 U13.107
NGFF_SATA_DET: R253.2 R495.1 U24.CR43
NTC1N_R: PR58.1 PR161.1 PR190.2
NV_PLLVDD: C68.2 C105.2 L2.2 U22.L6
ODD_PRSNT#: C703.1 R306.2 R812.2 U24.DK21
ODD_PRSNT#_C: C699.1 CN15.8 R806.1 R812.1
PBA_FP_PWREN#: R418.1 U13.76
PBA_PWR: C425.2 Q19.1(S) R422.2 R438.1
PBA_PWR_C: CN13.8 R804.2
PBA_PWR_R: C455.2 C456.2 Q19.3 R438.2 R804.1
PCBEEP_EC: D35.2 U13.34
PCBEEP_EC_C: C638.2 C648.2 C660.2 R707.1 R718.2
PCH_AZ_CODEC_BITCLK: C667.2 R687.1 U30.6
PCH_AZ_CODEC_RST#: Q45.1(S) R684.1 R782.2
PCH_AZ_CODEC_SDIN0: R751.2 U24.CV45
PCH_AZ_CODEC_SDIN0_R: R751.1 U30.8
PCH_AZ_CODEC_SDOUT: R683.1 U30.5
PCH_AZ_CODEC_SYNC: R682.1 U30.10
PCH_BLON_C: Q4.5 R12.2 R19.1 R20.2 R28.2
PCH_BLON_EC: R28.1 U13.88
PCH_DISP_ON: R536.2 U24.DN21
PCH_DPST_PWM: R25.1 U24.DU19
PCH_DSWROK: R708.1 R711.1 R717.1 U24.DR48
PCH_IST_TP_0: TP24.1 U24.CW33
PCH_IST_TP_1: TP22.1 U24.CY32
PCH_JTAGX: R604.1 U24.N2
PCH_LVDS_BLON: R20.1 U24.DL19
PCH_OPI_RCOMP: R296.2 U24.DU3
PCH_PWROK: R641.2 R703.2 U13.78
PCH_PWROK_R: R702.1 R703.1 U24.DN47
PCH_SLP_SUS#: R701.2 U24.DM49
PCH_SPI0_CLK: R777.2 R783.2 U24.DB42
PCH_SPI0_MISO: R744.2 U24.DF43
PCH_SPI0_MOSI: R759.2 U24.DD43
PCH_SPI1_CLK: C373.1 R312.1 R319.1 R403.1 R777.1 R789.2
PCH_SPI1_CLK_R: R312.2 U32.6 U33.6
PCH_SPI1_SI: R321.1 R323.1 R417.1 R698.1 R755.1 R759.1
PCH_SPI1_SI_R: R323.2 U32.5 U33.5
PCH_SPI1_SO: R320.1 R382.1 R448.1 R458.1 R700.1 R744.1
PCH_SPI1_SO_R: R382.2 U32.2 U33.2
PCH_SPI_CS0#: R322.1 R384.2 U24.DB43
PCH_SPI_CS0#_R: R384.1 U32.1 U33.1
PCH_SPI_IO2: R363.1 R723.1 U24.DF42
PCH_SPI_IO3: R335.2 R721.1 R722.1 U24.DD41
PCH_SUSPWRDNACK: R379.1 R383.2 U13.15
PCH_TCK: R128.1 TP15.1 U24.R5
PCH_TDI: R592.1 R594.1 U24.K1
PCH_TDO: R597.1 R598.1 U24.K2
PCH_TMS: R607.1 R608.1 U24.N3
PCH_TRST#: R600.1 R602.1 U24.N5
PCH_TYPEC_UPFB#: Q42.1(S) R766.1 R767.1 U24.DT14
PCIE_CLKREQ_LAN#: Q6.3 R44.1 R52.1 R414.1 U24.DN40
PCIE_CLKREQ_SSD#: CN18.52 R390.1 U24.DN34
PCIE_CLKREQ_VGA#: Q31.3 R342.1 R542.1 U24.DK33
PCIE_CLKREQ_WLAN#: Q18.3 R377.1 U24.DP40
PCIE_RCOMPN: R292.2 U24.DN1
PCIE_RCOMPP: R292.1 U24.DN3
PCIE_REQ_LAN#_R: Q6.1(S) R44.2 R55.1 U1.12
PCIE_RXN9_LAN: C88.2 U24.CP7
PCIE_RXN10_WLAN: CN9.43 U24.CM7
PCIE_RXN13_SSD: R852.1 U24.CG7
PCIE_RXN13_SSD_C: CN18.5 R852.2
PCIE_RXN14_SSD: R846.1 U24.CE6
PCIE_RXN14_SSD_C: CN18.17 R846.2
PCIE_RXN15_SSD: R844.1 U24.CC5
PCIE_RXN15_SSD_C: CN18.29 R844.2
PCIE_RXN16_SSD: R849.1 U24.CA6
PCIE_RXN16_SSD_C: CN18.43 R849.2
PCIE_RXN_LAN_L: C88.1 U1.18
PCIE_RXP9_LAN: C94.2 U24.CP6
PCIE_RXP10_WLAN: CN9.41 U24.CM6
PCIE_RXP13_SSD: R851.1 U24.CG6
PCIE_RXP13_SSD_C: CN18.7 R851.2
PCIE_RXP14_SSD: R845.1 U24.CE7
PCIE_RXP14_SSD_C: CN18.19 R845.2
PCIE_RXP15_SSD: R843.1 U24.CC6
PCIE_RXP15_SSD_C: CN18.31 R843.2
PCIE_RXP16_SSD: R850.1 U24.CA5
PCIE_RXP16_SSD_C: CN18.41 R850.2
PCIE_RXP_LAN_L: C94.1 U1.17
PCIE_TXN9_LAN: C611.2 U1.14
PCIE_TXN9_LAN_C: C611.1 U24.DA2
PCIE_TXN10_WLAN: C677.2 U24.CY3
PCIE_TXN10_WLAN_C: C677.1 CN9.37
PCIE_TXN13_SSD: C486.1 U24.CT3
PCIE_TXN13_SSD_C: C486.2 CN18.11
PCIE_TXN14_SSD: C484.1 U24.CT2
PCIE_TXN14_SSD_C: C484.2 CN18.23
PCIE_TXN15_SSD: C482.1 U24.CR3
PCIE_TXN15_SSD_C: C482.2 CN18.35
PCIE_TXN16_SSD: C488.1 U24.CP1
PCIE_TXN16_SSD_C: C488.2 CN18.47
PCIE_TXP9_LAN: C613.2 U1.13
PCIE_TXP9_LAN_C: C613.1 U24.DA1
PCIE_TXP10_WLAN: C678.2 U24.CY4
PCIE_TXP10_WLAN_C: C678.1 CN9.35
PCIE_TXP13_SSD: C485.1 U24.CT5
PCIE_TXP13_SSD_C: C485.2 CN18.13
PCIE_TXP14_SSD: C483.1 U24.CT1
PCIE_TXP14_SSD_C: C483.2 CN18.25
PCIE_TXP15_SSD: C481.1 U24.CR4
PCIE_TXP15_SSD_C: C481.2 CN18.37
PCIE_TXP16_SSD: C487.1 U24.CP2
PCIE_TXP16_SSD_C: C487.2 CN18.49
PCIE_WAKE#: EC9.1 Q46.3 R406.1 U1.21 U24.DL45
PD#: C377.1 D36.2 D37.2 R355.1 R364.1 U30.47
