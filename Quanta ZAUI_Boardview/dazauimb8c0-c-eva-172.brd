# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCIN_AUX on BOTTOM (solid shape): 119.15,47.2 119.15,40.64 118.74,40.22 118.74,36.12 118.28,35.66 118.28,35.17 118.15,35.04 117.61,35.04 117.47,35.17 117.47,35.49 116.23,36.74 114.17,36.74 113.82,36.39 113.82,35.67 113.73,35.55 113.7,35.41 113.72,35.32 113.75,35.24 113.77,35.2 113.71,35.14 113.51,35.14 113.17,35.47 112.33,35.47 112.29,35.51 112.29,38.6 112.52,38.83 112.52,38.91 112.84,39.23 112.84,40.99 113,41.13 113.07,41.34 113.04,41.47 112.97,41.59 112.95,41.66 112.98,41.73 113.06,41.85 113.09,42 113.07,42.13 113,42.24 112.98,42.31 113.01,42.38 113.08,42.5 113.11,42.63 113.04,42.84 112.87,42.98 112.84,42.99 112.84,43.06 112.41,43.5 111.29,43.5 111.03,43.75 111.03,46.2 111.26,46.43 113.17,46.43 114.47,47.73 117.9,47.73 117.94,47.76 118.59,47.76
+VCCIN_AUX on BOTTOM (solid shape): outline of 89 points within 97.86,63.49 105.14,68.21
+VCCIN_AUX on BOTTOM (solid shape): outline of 178 points within 92.26,60.62 94.25,64.25
+VCCIN_AUX on IN2 (solid shape): 120.15,46.44 120.15,40.11 118,37.96 118,37.7 117.92,37.62 117.67,37.62 117.18,37.14 115.71,37.14 115.64,37.07 115,37.07 113.82,38.24 113.82,39.35 113.7,39.47 113.7,46.75 114.06,47.1 119.49,47.1
+VCCIN_AUX on IN2 (solid shape): outline of 8348 points within 85.6,43.8 104.13,74.87
+VCCIN_AUX on SVCC (solid shape): 103.73,48.75 103.86,48.58 104.07,48.51 104.29,48.58 104.42,48.75 123.16,48.75 123.43,48.63 123.7,48.75 124.48,48.75 124.83,48.47 125.17,48.75 125.75,48.75 126.3,48.2 126.3,36.29 125.94,35.93 108.19,35.93 107.83,36.23 107.48,35.93 105.32,35.93 105.22,36.18 104.96,36.28 104.78,36.23 104.65,36.09 104.52,36.23 104.33,36.28 104.08,36.18 103.97,35.93 96.89,35.93 96.58,36.13 96.28,35.93 95.31,35.93 95.01,36.13 94.7,35.93 94.35,35.93 94.04,36.13 93.74,35.93 93.13,35.93 92.67,36.39 92.57,36.62 92.34,36.71 92.19,36.87 92.11,36.92 92.01,36.94 91.92,36.94 91.63,37.23 91.63,37.24 91.63,37.53 91.66,37.61 91.67,37.69 91.66,37.77 91.63,37.85 91.63,47.25 92.12,47.74 93.28,47.74 93.38,47.76 93.46,47.81 94.4,48.75
+VCCIN_AUX on IN3 (solid shape): 119.47,44.89 119.47,38.39 117.94,36.87 117.03,36.87 114.31,39.59 114.31,41.12 113.85,41.58 113.85,45.32 114.49,45.96 118.4,45.96
+VCCIO_OUT on TOP (solid shape): 107.63,78.22 107.63,69.96 107.88,69.71 108.39,69.71 108.65,69.46 108.65,69.07 108.52,68.95 108.42,68.95 108.41,68.95 108.12,68.95 108.11,68.95 107.66,68.95 107.65,68.95 107.36,68.95 107.35,68.95 106.89,68.95 106.89,68.95 106.59,68.95 106.59,68.95 106.11,68.95 105.98,69.07 105.98,69.35 105.98,69.35 105.98,69.46 106.23,69.71 106.23,69.76 106.24,69.76 106.24,70.24 106.23,70.24 106.23,70.65 106.24,70.65 106.24,70.95 106.23,70.95 106.23,71.56 106.24,71.57 106.24,72.14 106.23,72.15 106.23,73.37 106.24,73.37 106.24,73.67 106.23,73.67 106.23,74.08 106.24,74.08 106.24,74.53 106.23,74.53 106.23,74.99 106.24,75 106.24,75.5 106.23,75.5 106.23,75.96 106.24,75.96 106.24,76.49 106.23,76.49 106.23,78.22 106.36,78.35 107.5,78.35
+VCCIO_OUT on TOP (solid shape): outline of 111 points within 94.3,77.71 97.98,79.74
+VCCPLL_OC on TOP (solid shape): outline of 1382 points within 61.28,46.93 81.02,52.63
+VCCPRIM_3P3 on BOTTOM (solid shape): 102.3,33.77 102.3,32.37 102.04,32.12 102.04,31.23 101.75,30.94 101.19,30.94 100.14,31.99 100.14,33.77 100.24,33.87 101.43,33.87 101.55,33.89 101.65,33.96 101.69,34 102.07,34
+VCCPRIM_3P3 on IN2 (solid shape): outline of 2152 points within 85.02,33.34 101.65,39.34
+VCCRTC on BOTTOM (solid shape): outline of 124 points within 63.46,24.37 67.6,26.96
+VCCST on TOP (solid shape): 111.21,64.25 111.21,62.6 110.96,62.34 109.61,62.34 109.52,62.41 109.38,62.51 109.23,62.6 109.07,62.69 108.91,62.78 108.75,62.85 108.67,62.89 108.67,63.49 109.78,63.49 109.78,63.43 109.79,63.38 109.81,63.33 109.84,63.28 109.87,63.24 109.91,63.2 109.95,63.17 110,63.15 110.05,63.13 110.11,63.12 110.16,63.12 110.21,63.12 110.26,63.14 110.31,63.16 110.36,63.19 110.4,63.22 110.44,63.26 110.47,63.31 110.49,63.35 110.51,63.41 110.51,63.46 110.51,63.51 110.51,63.57 110.49,63.62 110.47,63.67 110.44,63.71 110.4,63.75 110.36,63.79 110.31,63.81 110.26,63.84 110.21,63.85 110.16,63.86 110.11,63.85 110.05,63.84 110,63.83 109.95,63.8 109.91,63.77 109.87,63.73 109.84,63.69 109.81,63.64 109.79,63.59 109.78,63.54 109.78,63.49 108.67,63.49 108.67,64.25 109.21,64.78 110.68,64.78
+VCCST on BOTTOM (solid shape): 102.93,58.66 102.93,58.03 102.91,58 100.37,58 99.94,57.57 99.94,54.96 99.64,54.66 99.64,52.7 98.24,51.31 97.93,51.31 97.86,51.38 97.86,51.76 97.96,51.87 98.28,51.87 99.24,52.83 99.24,55.03 99.36,55.14 99.36,58.28 99.86,58.79 102.8,58.79
+VCCST on BOTTOM (solid shape): 109.7,63.29 109.76,63.23 109.82,63.17 109.97,63.03 109.97,61.53 110.22,61.28 111.54,61.28 111.75,61.07 111.75,60.27 111.66,60.15 111.63,60.01 111.63,59.99 111.52,59.88 109.67,59.88 108.89,60.98 107.71,61.63 107.71,63 107.83,63.13 108.29,63.13 108.49,63.33 109.66,63.33
+VCCST_S2 on BOTTOM (solid shape): 113.93,65.44 113.93,65.01 113.55,64.63 113.55,64.18 113.5,64.1 113.41,64.09 113.33,64.12 113.26,64.12 112.99,64.02 112.89,63.75 112.91,63.61 113,63.49 112.53,63.03 112.53,61.89 112.2,61.56 110.81,61.56 110.63,61.73 110.63,63.54 111.16,64.07 111.16,64.65 111.82,65.31 112.81,65.31 113.04,65.54 113.83,65.54
+VCCSTG on BOTTOM (solid shape): 106.44,65.31 106.28,65.16 105.47,65.16 105.47,69.02 105.62,69.18 106.44,69.18
+VCCSTG on BOTTOM (solid shape): 105.32,62.72 105.88,62.72 105.92,62.77 105.99,62.81 106.03,62.88 106.23,63.08 107.12,63.08 107.2,63 107.2,62.01 107.1,61.91 105.55,61.91 103.77,60.13 102.98,60.13 102.86,60.26 99.63,60.26 99.38,60.51 99.38,60.74 99.71,61.07 102.47,61.07 102.55,61 103.39,61 104.41,62.01 104.41,63.03 104.56,63.18 104.86,63.18
+VCCSTG_OUT_FUSE on TOP (solid shape): 84.03,78.3 84.03,69.79 83.9,69.66 83.15,69.66 83.13,69.68 83.13,70.31 83.43,70.61 83.43,71.07 83.44,71.12 83.44,71.17 83.44,71.22 83.43,71.27 83.43,71.42 82.83,72.03 82.83,74.24 82.81,74.25 82.81,77.33 82.74,77.4 82.74,78.54 82.87,78.66 83.67,78.66
+VCCSTG_OUT_LGC on TOP (solid shape): outline of 168 points within 95.76,79.23 104.71,81.19
+VCCSTG_OUT_LGC on BOTTOM (solid shape): 104.96,79.35 104.96,78.85 104.71,78.6 104.05,78.6 103.91,78.74 103.91,79.5 103.87,79.54 103.87,80.05 103.94,80.12 104.2,80.12
+VCCSTG_TERM on BOTTOM (solid shape): 103.64,78.8 103.64,78.6 104.06,78.18 104.79,78.18 104.79,77.47 104.61,77.29 103.78,77.29 103.66,77.18 103.01,77.18 103.01,77.51 103.01,77.51 103.01,78.24 103.02,78.25 103.02,78.89 103.14,79.01 103.44,79.01
+VDDQ_VTT on TOP (solid shape): 60.89,97.27 60.89,94.6 60.64,94.35 60.39,94.35 60.36,94.38 60.36,94.42 60.37,94.47 60.26,94.73 60,94.83 59.95,94.83 59.91,94.82 59.75,94.98 57.21,94.98 57.08,95.11 57.08,95.62 57.21,95.74 58.99,95.74 59.5,96.25 59.5,97.14 59.88,97.52 60.64,97.52
+VDDQ_VTT on TOP (solid shape): outline of 115 points within 26.99,81.65 43.5,99.05
+VIN on TOP (solid shape): 74.04,125.66 74.04,119.11 73.81,118.88 72.84,118.88 71.92,119.8 68.55,119.8 68.34,120 67.92,120 67.63,119.7 67.44,119.7 67.33,119.74 67.24,119.75 67.05,119.69 66.91,119.55 66.89,119.52 66.58,119.52 65.95,120.15 65.37,120.15 65.23,120.01 65.19,120.04 65.15,120.06 65.09,120.07 64.94,120.07 64.88,120.06 64.83,120.03 64.77,120.01 64.7,120.03 64.65,120.06 64.59,120.07 64.44,120.07 64.39,120.06 64.34,120.03 64.32,120.02 64.21,120.02 64.21,120.04 64.16,120.04 64.12,120.05 64.09,120.05 63.94,120.05 63.87,120.04 63.73,120.18 63.69,120.18 63.69,120.51 63.69,120.51 63.69,120.67 63.72,120.7 65.46,120.7 65.47,120.68 66.16,120.68 66.21,120.64 66.61,120.64 67.04,121.07 69.8,121.07 70.28,121.55 70.28,122.11 70.69,122.52 70.69,124.95 70.37,125.27 70.37,125.61 70.62,125.87 73.82,125.87
+VIN on TOP (solid shape): outline of 6549 points within 52.31,7.52 141.68,118.32
+VIN on BOTTOM (solid shape): 79.17,105.48 83.74,105.48 83.88,105.34 83.88,105.09 83.88,105.09 83.88,104.41 83.75,104.28 82.1,104.28 81.8,103.97 81.8,103.34 82.05,103.08 84.06,103.08 84.19,102.96 84.19,102.93 84.31,102.81 84.31,102.03 84.11,101.83 82.43,101.84 78.88,101.84 78.86,101.83 78.79,101.83 78.68,101.94 78.68,103.59 77.74,104.53 77.74,105.09 77.3,105.52 77.3,105.78 77.38,105.85 78.8,105.85
+VIN on BOTTOM (solid shape): 127.13,34.54 127.22,34.48 127.2,34.37 127.14,34.26 127.11,34.12 127.22,33.85 127.49,33.74 127.67,33.79 127.81,33.91 127.84,33.88 127.86,33.88 127.9,33.86 128.13,33.63 128.13,32.66 128.1,32.64 126.12,32.64 125.55,32.07 123.24,32.07 123.24,32.11 122.94,32.41 122.44,32.41 121.84,31.81 119.27,31.81 118.87,32.21 118.87,33.01 119.52,33.65 122.23,33.65 123.12,34.54
+VIN on BOTTOM (solid shape): 137.48,39.1 137.48,38.16 138.31,37.32 142.99,37.32 143.07,37.24 143.09,37.21 143.09,36.16 142.99,36.05 142.99,35.93 142.68,35.62 142.68,33.83 142.68,33.82 142.68,33.28 142.68,33.1 142.65,33.09 142.47,32.96 142.4,32.75 142.45,32.58 142.57,32.45 142.61,32.39 142.6,32.32 142.57,32.23 142.55,32.13 142.62,31.92 142.78,31.78 142.84,31.74 142.92,31.71 143.01,31.62 143.92,31.62 144.03,31.72 145.62,31.72 145.62,31.59 145.56,31.53 145.56,31.28 145.54,31.24 145.51,31.23 143.39,31.23 143.32,31.23 142.68,30.59 141.46,30.59 141.16,30.9 141.16,31.94 140.74,32.36 140.74,33.18 140.73,33.22 140.71,33.26 140.7,33.27 140.7,34.62 140.71,34.62 140.71,35.03 140.45,35.29 140.2,35.29 139.34,35.29 139.33,35.29 137.15,35.29 136.97,35.34 136.78,35.29 136.23,35.29 136.18,35.29 136.08,35.39 136.08,39.23 136.21,39.36 137.22,39.36
+VIN on BOTTOM (solid shape): outline of 216 points within 127.79,47.55 140.4,69.81
+VIN on BOTTOM (solid shape): outline of 719 points within 53.27,109.1 73.34,125.95
+VIN on BOTTOM (solid shape): outline of 952 points within 43.67,12.05 79.86,19.39
+VIN_BLIGHT on BOTTOM (solid shape): 68.51,108.32 68.51,106.54 68.39,106.41 66.48,106.41 66.33,106.26 66.25,106.26 65.63,105.65 63.43,105.65 62.67,106.41 62.67,106.68 62.7,106.71 63.2,106.71 63.2,107.54 63,107.54 63,106.71 62.7,106.71 62.7,107.54 62.69,107.56 63.81,107.56 63.82,107.5 63.83,107.44 63.85,107.39 63.88,107.34 63.91,107.3 63.95,107.26 64,107.23 64.05,107.2 64.1,107.19 64.16,107.18 64.21,107.17 64.27,107.18 64.32,107.19 64.37,107.22 64.42,107.24 64.46,107.28 64.5,107.32 64.53,107.37 64.55,107.42 64.57,107.47 64.58,107.53 64.58,107.58 64.57,107.64 64.55,107.69 64.53,107.74 64.5,107.79 64.46,107.83 64.42,107.87 64.37,107.9 64.32,107.92 64.27,107.93 64.21,107.94 64.16,107.94 64.1,107.92 64.05,107.91 64,107.88 63.95,107.85 63.91,107.81 63.88,107.77 63.85,107.72 63.83,107.67 63.82,107.61 63.81,107.56 62.69,107.56 62.67,107.57 62.67,107.68 63.43,108.44 68.39,108.44
+VIN_VCCIN_AUX on BOTTOM (solid shape): 128.54,39.13 129.81,39.13 130.01,39.33 130.01,39.48 130.31,39.78 133.55,39.78 133.98,39.35 135.06,39.35 135.17,39.24 135.17,35.45 135.13,35.41 134.02,35.41 133.76,35.67 133.06,35.67 132.74,35.99 128.41,35.99 127.49,35.07 120.94,35.07 120.88,35.12 120.88,35.71 121.3,36.13 122.49,36.13 123.12,36.76 123.12,40.13 123.23,40.25 127.42,40.25
DVDD_IO on TOP (solid shape): 204.71,28.59 205.17,27.82 205.12,27.77 204.4,27.77 204.18,27.55 202.91,27.55 202.83,27.63 202.42,27.63 202.39,27.66 202.39,27.68 202.37,27.7 202.37,28.87 202.42,28.92 202.5,28.92 202.65,29.07 204.23,29.07
GND on TOP (solid shape): 65.85,36.26 65.61,36.02 65.61,33.9 63.96,33.9 63.96,37.62 64.05,37.71 65.85,37.71
GND on TOP (solid shape): 20.64,98.28 20.64,96.38 20.38,96.13 19.37,96.13 18.86,96.63 18.86,98.16 19.24,98.54 20.38,98.54
GND on TOP (solid shape): 22.72,28.69 22.72,26.1 22.69,26.07 21.83,26.07 21.8,26.1 21.8,28.66 21.86,28.71 22.69,28.71
GND on TOP (solid shape): 138.89,43.4 138.89,41.04 138.78,40.92 137.14,40.92 136.89,41.18 136.89,43.38 137.14,43.63 138.66,43.63
GND on TOP (solid shape): 49.31,122.66 49.31,121.75 49.27,121.71 47.32,121.71 47.16,121.87 47.16,122.6 47.3,122.75 49.22,122.75
GND on TOP (solid shape): 113.6,120.51 113.6,119.62 112.41,118.43 110.63,118.43 110.55,118.5 110.55,120.76 110.68,120.89 113.22,120.89
GND on TOP (solid shape): 100.26,27.16 100.26,26.78 100.65,26.4 100.65,25.13 100.26,24.75 97.22,24.75 96.96,25.01 96.96,27.16 97.09,27.29 100.14,27.29
GND on TOP (solid shape): 51.14,14.16 51.14,12.41 50.99,12.25 49.31,12.25 48.97,12.6 48.97,14.24 49.16,14.43 50.87,14.43
GND on TOP (solid shape): 109.1,120.86 109.1,117.56 108.67,117.13 107.22,117.13 107,117.36 107,118.15 106.97,118.17 106.97,120.97 107.05,121.04 108.93,121.04
GND on TOP (solid shape): 142.56,73.9 142.56,73.14 141.67,72.25 140.78,72.25 140.41,72.62 138,72.62 137.73,72.88 137.73,74.15 142.3,74.15
GND on TOP (solid shape): 36.92,23.07 36.92,22.13 36.8,22.02 36.55,22.02 36.54,22.01 32.85,22.01 32.7,22.16 32.7,23.35 32.83,23.48 36.51,23.48
GND on TOP (solid shape): 52.64,97.73 52.64,97.12 52.54,97.01 50.99,97.01 50.63,96.66 45.32,96.66 45.12,96.86 45.12,98.28 45.22,98.39 51.98,98.39
GND on TOP (solid shape): 92.01,85.58 92.01,82.66 92.26,82.41 92.26,80.89 92.01,80.63 91.25,80.63 89.85,82.03 89.85,82.59 89.34,83.09 89.34,85.84 91.76,85.84
GND on TOP (solid shape): 96.97,58.78 96.97,57.82 96.79,57.64 96.02,57.64 95.69,57.31 94.91,57.31 94.85,57.36 94.85,58.08 94.82,58.11 94.82,58.72 94.95,58.85 96.89,58.85
GND on TOP (solid shape): 102.25,17.05 102.25,16.19 101.74,15.68 101.36,15.68 100.93,15.25 99.1,15.25 98.74,15.61 98.74,16.9 98.97,17.13 102.17,17.13
GND on TOP (solid shape): 118.33,23.84 118.33,22.99 118.34,22.98 118.34,22.96 118.98,22.32 118.98,21.73 118.85,21.59 115.57,21.59 115.4,21.76 115.4,23.35 115.92,23.87 118.29,23.87
GND on TOP (solid shape): 192.35,11.51 192.35,11.32 192.72,10.95 192.72,10.53 192.6,10.4 189.5,10.4 189.39,10.5 189.39,11.01 189.8,11.42 190.71,11.42 190.89,11.59 192.26,11.59
GND on TOP (solid shape): 82.71,107.96 82.71,107.43 82.72,107.4 82.74,107.36 82.74,106.54 82.49,106.29 79.94,106.29 79.69,106.54 79.69,108.19 79.82,108.32 82.36,108.32
GND on TOP (solid shape): 46.14,21.7 46.14,21.17 46.52,20.79 46.52,18.43 46.37,18.27 43.17,18.27 42.78,18.66 42.78,20.86 42.07,21.58 42.07,22.16 42.18,22.26 45.58,22.26
GND on TOP (solid shape): 214.49,15.48 214.49,12.69 214.64,12.53 215.83,12.53 215.94,12.43 215.94,11.57 215.78,11.42 214.26,11.42 213.47,12.2 213.47,14.67 213.83,15.02 213.83,15.43 214.01,15.61 214.36,15.61
GND on TOP (solid shape): 37.65,32.12 37.65,31.2 37.43,30.97 35.88,30.97 35.62,30.72 33.34,30.72 33.21,30.85 33.21,31.61 33.59,31.99 33.6,31.99 33.85,32.24 37.53,32.24
GND on TOP (solid shape): 136.71,98.79 136.71,96.65 136.71,96.62 136.71,95.11 136.46,94.86 136.24,94.86 134.66,96.44 134.66,98.33 134.29,98.7 134.29,98.72 134.05,98.96 134.05,99.4 134.07,99.43 136.08,99.43
GND on TOP (solid shape): 64.14,119.34 64.2,119.34 64.2,119.12 64.28,119.05 64.28,118.15 64.08,117.96 63.7,117.96 63.64,118.02 63.64,118.44 63.76,118.57 63.76,118.93 63.8,118.97 63.85,118.97 63.85,118.98 63.85,119.34 63.89,119.34 63.89,119.89 63.93,119.92 64.14,119.92
GND on TOP (solid shape): 24.78,7.15 24.78,4.25 24.7,4.18 23.38,4.18 23.3,4.25 23.3,5.07 22.67,5.7 22.67,6.21 22.29,6.59 22.29,7.23 22.41,7.35 23.05,7.35 23.43,7.73 24.19,7.73
GND on TOP (solid shape): 27.3,74.22 27.3,73.89 27.27,73.79 27.25,73.7 27.27,73.6 27.3,73.51 27.3,71.04 27.11,70.85 26.22,70.85 25.84,71.23 25.84,72.38 26.22,72.76 26.22,74.28 26.35,74.41 27.11,74.41
GND on TOP (solid shape): 109.43,17.77 109.43,17.21 108.22,15.99 107.48,15.99 107.38,16.09 107.38,16.65 107.2,16.83 107.05,16.83 106.99,16.85 106.92,16.85 106.85,16.85 106.79,16.83 105.29,16.83 105.17,16.95 105.17,17.66 105.45,17.94 109.26,17.94
GND on TOP (solid shape): 112.94,40.14 112.94,39.74 113.35,39.33 113.35,35.6 114.23,34.71 114.23,34.15 112.8,32.71 111.94,32.71 111.81,32.84 111.81,34.8 111.76,34.85 111.76,36 111.57,36.19 111.57,38.46 111.68,38.58 111.68,39.3 111.57,39.41 111.57,39.91 111.9,40.25 112.84,40.25
GND on TOP (solid shape): 42.94,113.07 43.19,113.07 43.27,112.99 43.27,112.64 43.14,112.51 41.49,112.51 40.85,111.87 39.43,111.87 39.2,112.1 39.2,113.24 39.36,113.4 39.76,113.4 39.98,113.18 40.31,113.18 40.32,113.19 41.34,113.19 41.79,113.65 42.35,113.65
GND on TOP (solid shape): 62.3,96.49 62.3,96.48 62.41,96.22 62.67,96.11 62.69,96.11 62.93,95.87 63.94,95.87 64.07,95.74 64.07,95.24 63.82,94.98 62.04,94.98 61.53,94.47 61.28,94.47 61.02,94.73 61.02,97.01 61.28,97.27 61.53,97.27
GND on TOP (solid shape): 135.8,66.61 135.8,63.03 134.12,61.35 134.03,61.35 133.75,61.07 133.55,61.07 133.16,60.69 130.98,60.69 130.91,60.71 130.85,60.72 130.78,60.71 130.71,60.69 130.06,60.69 129.6,60.23 125.64,60.23 125.51,60.36 125.51,63.36 127.8,65.65 127.8,66.36 130.16,68.72 133.69,68.72
GND on TOP (solid shape): 109.92,125.08 109.92,122.41 109.54,122.03 105.73,122.03 105.47,122.29 105.47,123.58 105.69,123.8 105.77,123.92 105.8,124.07 105.72,124.3 105.51,124.44 105.49,124.44 105.47,124.47 105.47,125.26 105.49,125.29 105.52,125.31 109.69,125.31
GND on TOP (solid shape): 130.03,19.72 130.03,19.11 130.11,19.04 130.64,19.04 130.95,18.73 130.95,17.79 130.8,17.64 129.67,17.64 129.64,17.64 129.27,17.64 129.15,17.77 128.77,17.77 128.59,17.95 128.59,18.27 128.74,18.43 128.79,18.43 128.88,18.47 128.91,18.56 128.91,18.6 128.95,18.64 128.95,19.61 129.22,19.87 129.88,19.87
GND on TOP (solid shape): 158.89,29.75 158.89,26.61 158.67,26.39 158.67,26.39 158.48,26.2 158.48,26 158.38,25.89 157.55,25.89 157.17,26.28 152.33,26.28 151.98,26.63 151.98,26.96 152.08,27.06 152.08,27.55 152.23,27.7 152.87,27.7 153.4,27.16 156.32,27.16 156.6,27.44 156.6,27.7 156.7,27.8 157.92,27.8 158.05,27.93 158.05,29.32 158.56,29.83 158.81,29.83
GND on TOP (solid shape): 128.37,30.5 128.37,28.9 128.03,28.56 126.96,28.56 126.84,28.59 126.73,28.6 126.7,28.6 126.35,28.48 126.13,28.18 121.6,28.18 121.35,28.43 121.35,28.94 121.47,29.07 125.03,29.07 126.05,30.09 126.25,30.09 126.5,30.34 126.5,30.52 126.71,30.72 128.15,30.72
GND on TOP (solid shape): 85.33,87.28 85.4,87.26 85.48,87.25 85.56,87.26 85.64,87.28 85.65,87.29 86.12,87.29 86.17,87.24 86.17,86.57 86.04,86.45 85.28,86.45 85,86.17 85,85.86 84.8,85.66 84.54,85.66 84.44,85.76 84.44,85.81 84.44,86.72 84.53,86.8 84.51,86.82 84.75,86.93 84.86,87.17 84.95,87.26 84.98,87.27 85,87.29 85.32,87.29
GND on TOP (solid shape): 76.68,125.87 76.71,125.86 77.62,124.42 79.2,123.87 81.34,123.87 81.38,123.85 81.39,123.82 81.39,120.41 80.73,119.75 74.54,119.75 74.44,119.85 74.44,125.57 74.74,125.87
GND on TOP (solid shape): 158.43,22.49 158.43,21.2 158.56,21.07 161.94,21.07 162.12,20.89 162.12,20.35 162.04,20.27 155.85,20.27 155.39,20.27 155.33,20.34 155.33,20.61 155.48,20.76 157.41,20.76 157.92,21.27 157.92,21.78 157.67,22.03 157.34,22.03 157.22,21.91 155.03,21.91 154.06,20.94 154.06,20.74 154.05,20.7 154.01,20.69 150.05,20.69 149.92,20.81 149.92,21.51 149.92,21.54 149.92,22.47 150.05,22.59 156.83,22.59 156.98,22.74 158.18,22.74
GND on TOP (solid shape): 35.39,6.67 35.39,6.18 36,5.57 37.92,5.57 37.92,5.53 38.04,5.28 38.29,5.18 38.5,5.24 38.63,5.41 38.71,5.47 38.8,5.45 39.18,5.07 39.18,4.69 39.05,4.56 37.83,4.56 37.83,4.56 37.02,4.56 35.57,4.56 35.57,4.56 33.64,4.56 33.08,5.12 33.08,6.49 33.54,6.95 35.11,6.95
GND on TOP (solid shape): 60.67,108.52 60.67,107.81 60.87,107.61 61.78,107.61 61.8,107.59 62.33,107.59 63.09,106.83 63.09,106.78 63.18,106.69 63.18,106.21 63.33,106.06 63.33,105.5 63.21,105.37 62.77,105.37 62.52,105.62 62.52,106.46 62.29,106.69 61.63,106.69 61.56,106.62 60.92,106.62 60.64,106.34 60.64,106.21 60.64,105.93 60.56,105.85 60.26,105.85 60.08,106.03 60.08,107.48 59.47,108.09 59.47,108.52 59.49,108.56 59.52,108.57 59.66,108.62 59.74,108.74 59.74,108.75 59.77,108.77 60.41,108.77
GND on TOP (solid shape): 118.38,125.31 118.41,125.29 118.43,125.26 118.43,123.94 118.04,123.56 118.04,123.27 117.99,123.07 118.04,122.88 118.04,122.05 118.04,122.01 118.04,120.02 118.04,120.01 118.02,119.88 118.04,119.75 118.04,119.75 118.04,119.39 118.04,119.38 118.02,119.25 118.04,119.12 118.04,119.11 118.04,118.6 117.79,118.35 117.28,118.35 116.9,118.73 116.9,118.93 116.9,125.26 116.92,125.29 116.95,125.31
GND on TOP (solid shape): 41.18,109.64 41.18,108.09 41.32,107.95 41.98,107.95 42.23,107.71 42.56,107.71 42.68,107.58 42.68,107.33 42.5,107.14 42,107.14 42,107.17 41.94,107.23 41.95,107.27 41.95,107.32 41.6,107.7 41.19,107.37 41.17,107.34 41.17,106.35 41.12,106.31 41.08,106.31 41.01,106.27 40.85,106.27 40.79,106.31 40.38,106.72 39.69,106.72 39.38,106.41 38.82,106.41 38.62,106.62 38.62,107.22 40.24,108.85 40.24,109.59 40.36,109.71 41.12,109.71
GND on TOP (solid shape): 169.48,22.34 169.48,21.97 168.48,21.97 168.46,21.98 168.08,21.98 167.93,21.83 167.92,21.83 167.68,21.73 167.57,21.49 167.58,21.44 167.59,21.39 167.59,20.67 167.7,20.56 168.21,20.56 168.46,20.81 172.43,20.81 172.46,20.8 172.48,20.76 172.65,20.58 172.65,20.41 172.54,20.3 172.54,19.05 172.13,18.64 170.55,18.64 170.35,18.83 170.35,19.82 170.15,20.03 169.23,20.03 169.06,20.19 168.21,20.19 168.07,20.05 166.81,20.05 166.69,19.93 166.18,19.93 166.05,20.05 166.05,20.18 166.18,20.31 166.56,20.31 167.07,20.81 167.07,21.32 167.11,21.41 167.12,21.5 167.11,21.59 167.07,21.68 167.07,21.81 166.92,21.96 166.92,22.48 167.09,22.66 168.65,22.66 168.72,22.72 169.1,22.72
GND on TOP (solid shape): 43.84,31.97 43.84,31.61 43.53,31.3 43.53,30.77 42.98,30.23 41.82,30.23 41.72,30.12 41.72,28.93 40.74,27.95 40.74,27.62 40.61,27.34 40.74,27.06 40.74,26.95 40.51,26.72 38.7,26.72 38.6,26.81 38.6,27.11 38.72,27.23 39.11,27.23 39.27,27.39 39.27,27.94 39.64,28.31 39.64,29 39.66,29.02 40.52,29.02 40.82,29.31 40.82,30.8 40.86,30.85 40.88,30.85 41.12,30.98 41.21,31.23 41.14,31.45 40.95,31.59 40.88,31.66 40.9,31.76 41.24,32.1 43.72,32.1
GND on TOP (solid shape): 64.9,125.89 64.99,125.84 65,125.74 64.97,125.66 64.96,125.58 65.07,125.32 65.33,125.21 65.47,125.24 65.59,125.33 65.67,125.36 65.74,125.33 65.86,125.24 66.01,125.21 66.27,125.32 66.38,125.58 66.37,125.66 66.34,125.74 66.35,125.84 66.43,125.89 67.03,125.89 67.07,125.84 67.07,125.44 66.36,124.73 63.79,124.73 63.61,124.9 63.61,125.74 63.76,125.89
GND on TOP (solid shape): 136.71,33.01 136.71,32.64 136.68,32.63 136.42,32.29 136.68,31.96 136.71,31.95 136.71,30.34 136.97,30.09 136.97,29.96 136.84,29.83 136.46,29.83 136.33,29.7 136.33,29.22 136.32,29.21 136.32,29.09 135.77,28.54 135.77,28.33 135.69,28.22 135.66,28.08 135.66,28.02 135.44,27.8 134.3,27.8 133.92,27.42 132.52,27.42 132.4,27.55 132.4,28.43 132.38,28.45 132.38,30.22 131.66,30.95 131.66,31.53 131.84,31.71 131.84,32.37 131.91,32.45 132.32,32.45 132.65,32.12 132.65,31.86 132.82,31.7 133.37,31.7 133.54,31.86 133.54,32.37 133.67,32.5 134,32.5 134.17,32.32 134.17,31.82 134.3,31.7 135.15,31.7 135.44,31.99 135.44,33.26 135.55,33.36 136.36,33.36
GND on TOP (solid shape): 26.86,86.85 26.86,84.82 26.48,84.44 26.28,84.44 26.28,84.44 23.68,84.44 23.43,84.7 23.43,85.33 25.84,85.33 25.85,85.27 25.86,85.22 25.88,85.17 25.91,85.12 25.94,85.08 25.98,85.04 26.02,85 26.07,84.98 26.13,84.96 26.18,84.95 26.24,84.95 26.29,84.95 26.35,84.97 26.4,84.99 26.45,85.02 26.49,85.06 26.53,85.1 26.56,85.14 26.58,85.19 26.6,85.25 26.6,85.3 26.6,85.36 26.6,85.41 26.58,85.47 26.56,85.52 26.53,85.56 26.49,85.61 26.45,85.64 26.4,85.67 26.35,85.69 26.29,85.71 26.24,85.71 26.18,85.71 26.13,85.7 26.07,85.68 26.02,85.66 25.98,85.62 25.94,85.58 25.91,85.54 25.88,85.49 25.86,85.44 25.85,85.39 25.84,85.33 23.43,85.33 23.43,85.71 23.68,85.97 23.73,85.97 23.78,85.99 23.84,86.01 23.88,86.04 23.93,86.08 23.97,86.12 24,86.17 24.02,86.22 24.03,86.27 24.04,86.32 24.07,86.35 25.32,86.35 25.35,86.35 25.59,86.35 25.97,86.73 25.97,86.98 26.1,87.11 26.6,87.11
GND on TOP (solid shape): 159.05,37.87 159.26,37.87 159.55,37.58 159.8,37.58 160.05,37.42 160.56,37.13 160.81,36.98 161.53,36.26 161.53,35.01 161.4,34.89 160.36,34.89 159.95,35.29 159.95,35.93 159.7,36.18 156.27,36.18 156.06,36.39 156.06,36.41 156.07,36.54 156.06,36.59 156.05,36.64 156.03,36.68 156.03,36.73 155.89,36.87 155.89,37.27 158.46,37.27 158.46,37.22 158.46,37.17 158.48,37.12 158.5,37.07 158.53,37.03 158.57,36.99 158.61,36.95 158.66,36.93 158.71,36.91 158.76,36.89 158.81,36.89 158.87,36.89 158.92,36.91 158.97,36.93 159.01,36.95 159.05,36.99 159.09,37.03 159.12,37.07 159.14,37.12 159.16,37.17 159.17,37.22 159.17,37.27 159.16,37.33 159.14,37.38 159.12,37.43 159.09,37.47 159.05,37.51 159.01,37.54 158.97,37.57 158.92,37.59 158.87,37.6 158.81,37.6 158.76,37.6 158.71,37.59 158.66,37.57 158.61,37.54 158.57,37.51 158.53,37.47 158.5,37.43 158.48,37.38 158.46,37.33 158.46,37.27 155.89,37.27 155.89,37.71 156.14,37.96 157.36,37.96 157.62,38.22 158.71,38.22
GND on TOP (solid shape): 91.92,71.27 91.92,69.37 91.97,69.31 91.97,69.28 92.8,68.45 92.84,68.45 93.23,68.06 93.23,64.69 92.8,64.26 92.74,64.26 92.65,64.27 92.56,64.26 86.41,64.26 86.16,64.51 85.4,64.51 85.38,64.5 84.77,64.5 84.64,64.38 84.64,63.26 84.95,62.95 84.95,58.89 85.08,58.76 85.08,54.33 84.77,54.02 84.77,48.25 84.75,48.22 84.75,47.28 84.67,47.2 83.68,47.2 83.58,47.31 83.58,47.46 83.91,47.79 83.91,48.83 83.58,49.16 82.89,49.16 82.71,49.34 82.71,50.74 82.76,50.79 83.48,50.79 83.75,51.07 83.75,51.75 83.68,51.83 83.68,52.59 83.6,52.67 83.6,53.55 83.68,53.63 83.68,59.07 82.87,59.88 82.87,68.76 82.63,69 82.07,69 81.93,69.14 81.93,69.38 82,69.46 84.06,69.46 84.16,69.56 84.16,70.75 84.31,70.9 85.1,70.9 85.2,70.8 85.2,69.94 85.49,69.65 85.49,66.83 85.74,66.58 85.74,66.21 85.95,66 86.45,66 87.22,66.76 88.23,66.76 88.4,66.58 89.06,66.58 89.24,66.41 90.03,66.41 90.1,66.48 90.1,67.12 90.03,67.19 90.03,71.27 90.19,71.42 91.77,71.42
GND on TOP (solid shape): 22.01,69.96 22.01,66.36 19.29,63.64 16.11,63.64 15.3,62.83 15.3,60.54 14.82,60.06 13.67,60.06 13.27,59.65 13.27,59.24 12.5,59.24 12.5,61.84 11.88,62.58 11.04,62.09 8.9,62.09 8.54,61.95 8.4,61.59 8.4,61.49 2.21,61.49 1.85,61.85 1.85,67.89 2.21,68.25 7.07,68.25 8.33,67.35 9.35,68.5 9.35,70.9 9.38,70.93 9.71,70.93 9.82,70.83 9.82,70.27 10.15,69.94 12.91,69.94 15.66,72.68 19.29,72.68
GND on TOP (solid shape): 12.42,89.2 12.37,88.88 12.25,88.59 12.25,87.74 12.71,87.28 12.71,83.2 12.03,82.51 10.63,82.51 9.94,81.82 9.46,81.82 9.35,81.93 9.35,83.9 8.33,85.05 7.07,84.15 2.11,84.15 1.75,84.51 1.75,87.15 0.25,87.15 0.25,88.4 0.61,88.75 4.75,88.75 4.75,88 4.88,87.68 5.2,87.55 6.6,87.55 6.92,87.68 7.05,88 7.05,88.75 11.2,88.75 11.52,88.88 11.65,89.2 11.65,89.6 12.42,89.6
GND on TOP (solid shape): 13.27,49.39 14.08,48.58 14.72,48.58 15.07,48.22 15.07,47.64 14.79,47.36 13.78,47.36 13.52,47.1 13.52,45.96 14.16,45.33 14.16,44.82 14.15,44.8 14.15,42.29 15.3,41.13 15.3,40.27 15.05,40.02 13.54,40.02 13.27,39.74 13.27,39.25 12.5,39.25 12.5,41.84 11.88,42.58 11.04,42.09 8.9,42.09 8.54,41.95 8.4,41.59 8.4,41.49 3.35,41.49 2.99,41.85 2.99,47.03 3.35,47.39 8.4,47.39 8.4,47.29 8.54,46.93 8.9,46.79 11.04,46.79 11.88,46.3 12.5,47.04 12.5,49.62 13.27,49.62
GND on TOP (solid shape): outline of 84 points within 60.86,121.35 70.57,125.06
GND on TOP (solid shape): 142.25,26.33 142.36,26.24 142.51,26.21 142.57,26.22 142.64,26.24 144.59,24.29 144.59,23.97 144.59,23.96 144.59,23.56 144.99,23.17 144.99,19.56 144.51,19.08 144.04,18.61 143.84,18.61 143.78,18.63 143.72,18.63 143.37,18.27 143.72,17.92 143.91,17.97 144.04,18.11 144.79,18.86 145.1,18.86 145.48,18.48 145.48,18.45 145.55,18.38 145.55,17.58 144.49,16.51 141.85,16.51 141.63,16.73 141.54,17.07 141.29,17.17 141.16,17.15 141.05,17.08 140.98,17.06 140.91,17.08 140.8,17.15 140.68,17.17 140.42,17.07 140.32,16.78 140.33,16.72 140.21,16.6 139.99,16.6 139.89,16.7 139.89,17 139.51,17.39 136.33,17.39 135.35,18.37 135.35,18.75 135.79,19.19 136.33,19.19 136.53,19.39 136.53,19.95 136.42,20.07 136.41,20.08 136.32,20.24 136.16,20.33 136.15,20.34 136.08,20.41 136.08,20.99 136.02,21.05 136.02,23.26 136.14,23.39 136.18,23.56 136.18,23.62 136.16,23.68 136.16,23.75 136.2,23.81 136.33,23.93 136.39,24.1 136.39,24.12 138.6,26.33
GND on TOP (solid shape): outline of 91 points within 87.24,47.18 96.97,62.52
GND on TOP (solid shape): outline of 260 points within 0.25,18.86 15.33,29.65
GND on TOP (solid shape): outline of 117 points within 0.25,102.5 34.22,122.97
GND on TOP (solid shape): outline of 1521 points within 0.25,0.25 219.55,127.75
GND on BOTTOM (solid shape): 65.72,34.91 64.07,34.91 64.07,36.18 65.72,36.18
GND on BOTTOM (solid shape): 62.77,124.14 62.77,123.51 61.96,122.7 61.02,122.7 60.26,123.46 60.26,124.06 60.43,124.23 62.69,124.23
GND on BOTTOM (solid shape): 64.83,69.84 64.83,62.85 64.7,62.72 63.31,62.72 63.18,62.85 63.18,69.84 63.43,70.09 64.58,70.09
GND on BOTTOM (solid shape): 49.32,122.67 49.32,121.76 49.27,121.7 47.38,121.7 47.1,121.99 47.1,122.75 47.16,122.82 49.17,122.82
GND on BOTTOM (solid shape): 51.67,13.68 51.67,12.23 51.34,11.9 49.67,11.9 49.34,12.23 49.34,13.78 49.59,14.03 51.32,14.03
GND on BOTTOM (solid shape): 84.02,101.7 84.26,101.46 84.26,100.32 84.14,100.19 78.8,100.19 78.67,100.32 78.67,101.46 78.93,101.71 82.51,101.71
GND on BOTTOM (solid shape): 123,119.62 123,114.54 122.74,114.29 121.35,114.29 120.84,114.79 120.84,118.5 122.08,119.75 122.87,119.75
GND on BOTTOM (solid shape): 157.08,27.75 157.08,26.83 156.91,26.66 155.13,26.66 154.87,26.91 154.87,27.29 155,27.42 156.53,27.42 156.91,27.8 157.03,27.8
GND on BOTTOM (solid shape): 21.07,54.93 21.14,54.93 21.14,52.54 20.86,52.26 19.8,52.26 19.62,52.44 19.62,53.96 20,54.34 20,55.1 20.13,55.23 20.76,55.23
GND on BOTTOM (solid shape): 21.14,42.15 21.14,40.63 21.02,40.5 19.24,40.5 19.11,40.37 18.86,40.37 18.73,40.5 18.73,42.15 18.83,42.25 21.04,42.25
GND on BOTTOM (solid shape): 109.79,20.84 107.69,18.74 107.69,17.12 107.33,16.75 105.22,16.75 104.96,17 104.96,19.59 106.36,20.99 106.36,21.7 106.74,22.08 109.79,22.08
GND on BOTTOM (solid shape): 68.13,101.33 68.13,100.95 68.51,100.57 69.2,100.57 69.4,100.37 69.4,98.16 69.28,98.03 68.64,98.03 67.03,99.64 67.03,101.37 67.12,101.46 68.01,101.46
GND on BOTTOM (solid shape): 113.22,120.64 113.22,118.73 112.61,118.12 111.59,118.12 111.44,118.27 111.44,119.87 111.31,120 111.31,120.76 111.44,120.89 112.96,120.89
GND on BOTTOM (solid shape): 135.05,55.38 135.05,54.69 134.79,54.43 134.79,53.89 134.56,53.66 132.6,53.66 132.41,53.84 132.41,55.24 132.64,55.47 134.97,55.47
GND on BOTTOM (solid shape): 45.93,114.01 45.93,112.15 45.91,112.13 43.75,112.13 43.62,112.25 43.62,113.27 43.42,113.47 43.09,113.47 42.99,113.57 42.99,113.78 43.09,113.88 43.5,113.88 43.65,114.03 45.91,114.03
GND on BOTTOM (solid shape): 57.85,125.6 57.85,124.35 57.69,124.19 54.16,124.19 54.04,124.19 51.24,124.19 50.96,124.48 50.96,125.64 51.2,125.88 57.57,125.88
GND on BOTTOM (solid shape): 133.01,35.47 133.54,35.47 133.62,35.39 133.62,34.99 133.54,34.91 129.39,34.91 128.87,34.39 128.87,34.02 128.69,33.84 128.19,33.84 128.04,33.99 128.04,35.14 128.7,35.8 132.68,35.8
GND on BOTTOM (solid shape): 140.08,47.59 140.08,46.43 139.94,46.29 139.58,46.29 139.5,46.37 139.5,47.06 139.3,47.26 139.18,47.26 139.18,47.68 139.99,47.68
GND on BOTTOM (solid shape): 143.02,45 143.9,45 144.03,44.86 144.03,44.16 143.8,43.93 143.25,43.93 142.56,43.25 142.16,43.25 142.09,43.31 142.09,44.53 141.71,44.92 141.71,45.2 141.85,45.35 142.68,45.35
GND on BOTTOM (solid shape): 23.23,115.2 23.28,115.2 23.81,114.67 23.94,114.67 23.94,113.91 23.05,113.02 22.16,113.02 21.02,114.16 18.6,114.16 16.44,112 16.06,112 15.17,112.89 15.17,113.91 16.83,115.56 22.87,115.56
GND on BOTTOM (solid shape): 37.15,119.71 38.2,119.71 38.82,119.09 39.86,119.09 39.94,119.01 39.94,116.65 39.86,116.57 39.36,116.57 38.85,117.08 36,117.08 35.62,117.46 35.62,119.62 35.88,119.87 36.98,119.87
GND on BOTTOM (solid shape): 158.43,37.95 158.43,36.4 158.21,36.18 156.27,36.18 156.13,36.31 156.13,36.75 155.89,36.99 155.89,37.71 156.38,38.19 158.18,38.19
GND on BOTTOM (solid shape): 192.04,10.91 196.61,10.91 196.91,11.21 197.72,11.21 197.93,11.01 197.93,9.87 197.91,9.84 197.88,9.82 189.26,9.82 189.19,9.89 189.19,10.81 189.8,11.42 191.53,11.42
GND on BOTTOM (solid shape): 195.26,31.3 195.26,30.21 195.18,30.14 194.83,30.14 194.63,30.34 194.63,30.82 194.45,31 193.94,31 193.48,30.54 192.59,30.54 192.47,30.67 192.47,31.18 192.82,31.53 195.03,31.53
GND on BOTTOM (solid shape): 118.43,125.72 118.43,123.94 117.41,122.92 117.41,122.39 117,121.98 117,120.22 116.93,120.14 116.64,120.14 116.55,120.23 116.55,123.33 116.65,123.43 116.65,125.59 116.9,125.84 118.3,125.84
GND on BOTTOM (solid shape): 66.36,96.25 66.36,95.49 66.23,95.36 65.34,95.36 65.21,95.24 65.21,94.6 65.09,94.47 61.53,94.47 61.4,94.6 61.4,95.87 61.58,96.05 63.79,96.05 64.25,96.51 66.1,96.51
GND on BOTTOM (solid shape): 108.14,120.64 108.14,119.87 108.39,119.62 109.13,119.62 109.41,119.34 109.41,117.51 109.08,117.18 107.4,117.18 107,117.59 107,120.84 107.01,120.88 107.05,120.89 107.88,120.89
GND on BOTTOM (solid shape): 122.54,39.63 122.54,36.78 122.19,36.43 121.23,36.43 120.62,35.83 120.62,35.06 120.84,34.84 122.24,34.84 122.37,34.71 122.37,34.39 122.25,34.28 119.29,34.28 118.44,35.12 118.44,35.51 119.21,36.27 119.21,39.06 119.95,39.8 122.37,39.8
GND on BOTTOM (solid shape): 142.84,73.98 142.84,71.94 142.53,71.64 141.81,71.64 141.74,71.67 141.54,71.87 141.54,72.5 141.36,72.68 137.55,72.68 137.32,72.91 137.3,72.91 137.12,73.09 137.12,73.98 137.37,74.23 142.58,74.23
GND on BOTTOM (solid shape): 89.24,119.16 89.63,119.06 90.02,118.99 90.28,118.73 90.28,118.55 92.52,116.32 92.52,112.25 92.26,112 90.82,112 90.23,112.59 90.23,116.32 89.72,116.83 88.2,116.83 87.95,117.08 87.95,118.99 88.12,119.16
GND on BOTTOM (solid shape): 74.95,81.48 74.95,80.97 75.07,80.85 75.07,80.29 75.15,80.21 75.15,80 75.06,79.91 74.83,79.91 74.74,80 74.72,80 74.63,80.09 74.25,80.09 73.99,80.34 73.09,80.34 72.95,80.48 72.95,81.09 73.09,81.23 74.34,81.23 74.67,81.56 74.87,81.56
GND on BOTTOM (solid shape): 80.81,96.15 80.81,95.72 80.99,95.54 81.21,95.54 81.21,94.68 81.19,94.65 79.94,94.65 79.84,94.55 79.72,94.55 79.49,94.78 77.79,94.78 77.61,94.6 77.02,94.6 76.82,94.8 76.82,95.19 77.15,95.52 77.15,95.59 77.28,95.72 79.59,95.72 80.17,96.3 80.66,96.3
GND on BOTTOM (solid shape): 105.7,72.02 105.7,69.94 105.34,69.58 105.34,67.32 104.96,66.94 103.95,66.94 103.85,67.04 103.85,68.31 103.74,68.41 102.45,68.41 102.27,68.24 102.27,66.71 102.22,66.66 101.28,66.66 101.28,67.93 101.29,67.94 101.29,72.01 101.46,72.17 105.55,72.17
GND on BOTTOM (solid shape): 99.33,33.46 99.33,33.18 99.25,33.11 98.77,33.11 98.66,33.01 98.66,32.6 98.54,32.47 97.54,32.47 97.44,32.57 97.44,32.91 97.43,32.92 97.43,33.04 97.26,33.21 97.26,33.66 97.25,33.68 97.25,34.03 97.32,34.11 97.5,34.11 97.65,34.26 97.65,34.42 97.83,34.59 98.19,34.59
GND on BOTTOM (solid shape): 70.61,86.43 70.86,86.43 70.93,86.37 73.33,86.37 73.77,85.92 73.77,85.66 73.72,85.61 70.53,85.61 70.12,85.2 69.28,85.2 68.6,85.88 68.6,86.31 68.38,86.52 67.88,86.52 67.88,86.52 66.64,86.52 65.38,87.78 65.38,88.52 65.49,88.63 68.41,88.63
GND on BOTTOM (solid shape): 94.32,34.61 94.32,34.53 94.55,34.3 94.7,34.3 94.8,34.4 94.98,34.4 95.06,34.33 95.06,33.97 94.99,33.9 94.99,32.1 94.94,32.05 94.63,32.05 94.56,32.13 94.56,32.71 94.1,33.17 94.1,33.42 94.45,33.78 94.45,34.14 94.33,34.26 93.93,34.26 93.91,34.28 93.91,34.58 94.02,34.68 94.25,34.68
GND on BOTTOM (solid shape): 97.2,68.55 97.87,68.55 97.98,68.44 97.98,68.1 97.56,67.68 97.56,65 97.48,64.92 97.23,64.92 97.15,65 97.15,65.25 96.67,65.73 96.67,65.86 96.95,66.14 96.95,66.45 96.49,66.9 96.49,67.23 96.36,67.36 96.36,67.79 95.96,68.2 95.96,68.56 95.98,68.58 97.17,68.58
GND on BOTTOM (solid shape): 47.26,21.02 47.26,20.08 47.46,19.87 48.27,19.87 48.68,19.47 48.73,19.47 48.77,19.43 49.94,19.43 50.1,19.26 50.1,18.48 49.95,18.32 48.63,18.32 48.55,18.4 48.55,18.6 48.07,19.09 46.39,19.09 46.21,19.26 46.21,19.29 43.7,19.29 43.62,19.37 43.62,21.27 43.47,21.42 42.28,21.42 42.15,21.55 42.15,21.8 42.25,21.9 42.25,22.24 42.05,22.44 42.05,22.44 42,22.49 42,23 42.48,23.48 44.79,23.48
GND on BOTTOM (solid shape): 109.92,125.46 109.92,122.41 109.54,122.03 105.73,122.03 105.47,122.29 105.47,123.64 105.48,123.68 105.51,123.69 105.8,124.07 105.51,124.44 105.48,124.45 105.47,124.49 105.47,125.46 105.85,125.84 109.54,125.84
GND on BOTTOM (solid shape): 113.27,51.95 113.35,51.94 113.4,51.94 113.45,51.96 113.48,51.96 113.57,51.88 113.57,47.4 112.99,46.82 111.78,46.82 111.56,47.04 111.56,48.79 112.55,49.79 112.55,50.8 112.57,50.86 112.57,50.91 112.57,50.97 112.55,51.03 112.55,51.86 112.64,51.95 112.71,51.94 112.79,51.95 112.87,51.98 113.19,51.98
GND on BOTTOM (solid shape): 124.14,96.38 124.14,94.3 122.66,94.3 122.62,94.31 122.59,94.31 122.54,94.32 122.49,94.32 122.42,94.32 122.35,94.3 121.36,94.3 121.29,94.32 121.22,94.32 121.15,94.32 121.09,94.3 121.01,94.26 120.96,94.22 120.66,94.22 120.56,94.32 120.56,95.01 120.2,95.36 120.2,95.69 120.23,95.72 120.23,96.28 120.46,96.51 124.01,96.51
GND on BOTTOM (solid shape): 112.41,39.69 112.41,38.87 112.08,38.54 112.08,35.42 112.33,35.17 113.09,35.17 114.23,34.02 114.23,32.96 114.23,32.95 114.23,32.5 112.96,31.23 112.96,29.32 112.84,29.2 111.92,29.2 111.82,29.3 111.82,32.52 111.11,33.23 111.11,33.9 110.81,34.2 110.81,36.14 110.95,36.29 110.95,38.42 111.09,38.55 111.14,38.56 111.18,38.57 111.36,38.57 111.52,38.72 111.52,39.39 111.54,39.44 111.55,39.49 111.83,39.78 112.32,39.78
GND on BOTTOM (solid shape): 127.63,69.72 127.63,69.25 128.16,68.71 128.16,59.93 128.42,59.67 128.42,49.44 125.77,49.44 125.77,52.78 125.82,52.83 126.52,52.83 126.7,53.02 126.7,54.03 126.46,54.27 125.62,54.27 125.38,54.51 125.09,54.51 124.27,55.33 124.27,55.9 123.7,56.47 122.14,56.47 121.98,56.63 121.98,57.81 122.11,57.93 122.19,57.93 122.26,58.01 123.6,58.01 124.27,58.68 124.27,59.11 124.35,59.19 124.81,59.19 125.35,59.73 125.35,63.48 125.54,63.67 126.22,63.67 126.42,63.87 126.42,64.91 125.97,65.36 125.97,69.08 126.72,69.83 127.52,69.83
GND on BOTTOM (solid shape): 141.3,55.75 141.3,53.46 141.51,53.26 142.3,53.26 142.58,52.97 142.58,52.75 142.47,52.64 140.76,52.64 140.59,52.47 140.59,52.2 140.5,52.11 140.43,52.11 140.05,52.11 140.02,52.11 139.75,52.11 139.72,52.11 139.32,52.11 139.06,52.37 138.51,52.37 138.5,52.37 138.44,52.34 138.4,52.27 138.4,52.25 138.37,52.22 138.37,51.93 138.28,51.84 138.01,51.84 137.91,51.95 137.91,55.73 137.98,55.8 141.25,55.8
GND on BOTTOM (solid shape): 75.88,33.86 75.88,33.77 75.75,33.64 75.37,33.64 75.23,33.49 75.23,33.18 74.98,32.94 74.95,32.89 74.94,32.83 74.94,32.53 74.77,32.36 74.7,32.38 74.64,32.38 74.4,32.3 74.28,32.09 73.66,32.09 73.51,32.24 73.51,33.08 73.7,33.27 73.84,33.27 74.23,33.66 74.25,33.74 74.25,33.81 74.28,33.88 74.36,33.91 74.74,33.91 74.95,34.11 75.63,34.11
GND on BOTTOM (solid shape): 131.43,69.9 131.43,69.48 131.85,69.06 133.41,69.06 135.02,67.46 135.41,67.06 136.2,67.06 136.21,67.06 136.21,66.81 135.41,66.81 135.41,66.56 136.21,66.56 136.21,66.31 135.41,66.31 135.41,66.06 136.21,66.06 136.21,65.81 135.41,65.81 135.41,65.56 136.21,65.56 136.21,64.53 135.8,64.12 135.8,63.97 135.61,63.78 135.61,62.34 135.33,62.07 134.45,62.07 134.12,62.4 134.12,63.72 133.95,63.89 133.95,65.77 133.76,65.97 130.64,65.97 130.49,66.12 130.04,66.12 129.98,66.18 129.98,68.88 129.53,69.33 129.53,69.94 129.65,70.06 131.27,70.06
GND on BOTTOM (solid shape): 134.85,51.52 134.85,48.22 134.72,47.94 134.85,47.66 134.85,46.07 134.5,45.72 134.5,42.55 134.5,42.55 134.5,41.61 133.8,40.91 133.8,40.62 133.56,40.38 130.22,40.38 130.06,40.54 130.06,43.07 129.74,43.4 128.46,43.4 127.93,43.93 127.93,46.57 127.45,47.05 126.78,47.05 126.58,47.24 126.58,48.23 126.67,48.32 128.78,48.32 129.56,47.54 131.1,47.54 131.32,47.32 132.03,47.32 132.24,47.53 132.24,48.01 132.42,48.19 132.62,48.19 132.98,48.55 132.98,51.88 133.14,52.04 134.33,52.04
GND on BOTTOM (solid shape): 69.4,125.63 69.4,124.1 69.55,123.95 69.55,123.39 69.56,123.38 69.56,122.22 69.31,121.96 63.93,121.96 63.93,122.8 65.62,122.8 66.11,123.28 66.49,123.28 66.83,123.2 67.09,123.44 67.28,123.63 67.61,123.63 68.06,123.47 68.29,123.89 68.62,124.23 68.62,125.56 68.87,125.81 69.22,125.81
GND on BOTTOM (solid shape): 128.46,31.46 128.46,29.42 128.66,29.22 128.97,29.22 129.3,28.89 129.3,28.43 129.17,28.31 128.66,28.31 128.51,28.15 127.34,28.15 127.33,28.19 127.09,28.49 126.73,28.6 126.7,28.6 126.48,28.55 126.3,28.43 125.79,28.43 125.66,28.56 125.66,30.09 125.79,30.21 125.94,30.21 126.02,30.18 126.1,30.17 126.18,30.18 126.26,30.21 126.38,30.21 126.5,30.34 126.5,30.54 126.67,30.71 126.67,31.72 126.7,31.74 128.18,31.74
GND on BOTTOM (solid shape): 23.43,73.52 27.11,73.52 27.24,73.39 27.24,70.34 27.11,70.22 23.81,70.22 22.57,71.46 23.56,71.46 23.56,71.41 23.57,71.35 23.59,71.3 23.62,71.25 23.65,71.21 23.69,71.17 23.74,71.14 23.79,71.11 23.84,71.09 23.9,71.08 23.95,71.08 24.01,71.09 24.06,71.1 24.11,71.12 24.16,71.15 24.2,71.19 24.24,71.23 24.27,71.27 24.3,71.33 24.31,71.38 24.32,71.43 24.32,71.49 24.31,71.54 24.3,71.6 24.27,71.65 24.24,71.7 24.2,71.74 24.16,71.77 24.11,71.8 24.06,71.82 24.01,71.84 23.95,71.84 23.9,71.84 23.84,71.83 23.79,71.81 23.74,71.79 23.69,71.76 23.65,71.72 23.62,71.67 23.59,71.62 23.57,71.57 23.56,71.52 23.56,71.46 22.57,71.46 21.65,72.38 21.65,73.65 22.03,74.03 22.92,74.03
GND on BOTTOM (solid shape): 171.46,23.55 171.46,23.1 171.49,23.02 171.58,22.98 171.96,22.98 172.04,23.02 172.07,23.1 172.07,23.24 172.92,23.24 174.01,22.15 174.01,22.13 174.11,21.89 174.36,21.79 174.36,19.76 174.24,19.65 174.19,19.5 174.19,19.48 173.35,18.64 170.52,18.64 170.36,18.8 170.36,19.58 170.57,19.79 173.21,19.79 173.3,19.88 173.32,19.88 173.4,19.92 173.43,20 173.43,21.1 173.43,21.12 173.42,21.16 173.42,21.22 172.92,21.72 172.92,21.94 172.65,22.21 170.75,22.21 170.67,22.29 170.31,22.29 170.22,22.38 170.22,23.48 170.5,23.76 171.25,23.76
GND on BOTTOM (solid shape): 75.36,112.55 75.36,111.73 75.68,111.42 76.08,111.42 76.21,111.29 76.21,110.91 76.01,110.7 76.01,110.07 75.42,109.49 75.25,109.49 75.22,109.48 75.17,109.46 75.12,109.46 74.99,109.33 74.99,109.08 74.64,108.72 72.79,108.72 72.65,108.72 72.45,108.93 72.45,108.95 72.36,109.19 72.12,109.31 72.1,109.31 72,109.41 72,109.61 72.38,109.99 72.73,110.39 72.35,110.76 72.28,110.75 72.21,110.73 72.07,110.73 71.82,110.98 71.82,111.49 71.94,111.62 72.38,111.62 72.63,111.87 74.08,111.87 74.26,112.05 74.26,112.43 74.39,112.56 75.34,112.56
GND on BOTTOM (solid shape): 122.74,85.97 122.74,80.76 122.86,80.64 129.67,80.64 129.72,80.59 129.72,77.29 129.47,77.04 117.14,77.04 116.99,77.2 116.99,79.92 117.03,79.96 117.03,80 116.27,80.76 114.49,80.76 113.09,82.16 105.98,82.16 105.47,82.66 105.47,83.6 105.49,83.62 105.51,83.67 105.53,83.72 105.54,83.78 105.54,83.84 105.52,83.9 105.5,83.96 107.76,86.22 115.01,86.22 115.01,86.17 115.02,86.11 115.04,86.06 115.07,86.02 115.1,85.97 115.14,85.93 115.19,85.9 115.23,85.88 115.28,85.86 115.34,85.85 115.39,85.85 115.45,85.86 115.5,85.87 115.55,85.89 115.59,85.92 115.63,85.95 115.67,85.99 115.7,86.04 115.72,86.09 115.74,86.14 115.75,86.19 115.75,86.25 115.74,86.3 115.72,86.35 115.7,86.4 115.67,86.44 115.63,86.49 115.59,86.52 115.55,86.55 115.5,86.57 115.45,86.58 115.39,86.59 115.34,86.59 115.28,86.58 115.23,86.56 115.19,86.53 115.14,86.5 115.1,86.47 115.07,86.42 115.04,86.38 115.02,86.33 115.01,86.27 115.01,86.22 107.76,86.22 108.65,87.11 109.28,87.11 109.6,87.43 117.6,87.43 117.79,87.62 121.09,87.62
GND on BOTTOM (solid shape): 76.65,125.94 76.68,125.93 77.57,124.43 79.19,123.84 81.14,123.84 81.39,123.59 81.39,120.51 80.91,120.03 80.2,120.03 80.02,120.2 80.02,121.98 79.87,122.14 79.8,122.14 79.74,122.2 76.75,122.2 76.68,122.14 76.66,122.14 75.82,121.3 75.82,118 75.74,117.92 75.11,117.92 74.85,117.67 74.85,116.53 74.59,116.27 74.59,115.71 74.46,115.58 74.03,115.58 73.98,115.63 73.98,116.55 73.98,116.73 73.9,116.8 73.76,116.91 73.59,116.95 73.46,116.93 73.35,116.86 73.34,116.85 73.28,116.85 73.1,117.03 73.1,121.32 73.71,121.93 73.71,125.57 73.71,125.59 73.73,125.6 74.06,125.94
GND on BOTTOM (solid shape): 30.16,22.08 30.16,21.65 30.02,21.51 29.97,21.32 29.99,21.19 30.07,21.07 30.09,21 30.07,20.94 29.99,20.82 29.97,20.69 30,20.55 30.07,20.44 30.1,20.36 30.07,20.29 29.96,20.05 30.03,19.8 30.03,19.62 29.97,19.5 29.96,19.37 29.96,19.34 29.91,19.29 28.89,19.29 28.56,19.62 28.56,20.15 28.56,20.19 28.56,20.25 28.54,20.35 28.52,20.37 28.45,20.46 28.36,20.52 28.35,20.53 28.31,20.57 27.18,20.57 26.91,20.84 26.91,22.39 27.11,22.59 29.65,22.59
GND on BOTTOM (solid shape): outline of 85 points within 77.15,100.19 91.25,108.47
GND on BOTTOM (solid shape): 12.42,89.2 12.37,88.88 12.25,88.59 12.25,84.75 12.71,84.29 12.71,83.2 12.03,82.51 10.63,82.51 9.98,81.86 9.44,81.86 9.35,81.95 9.35,83.9 8.33,85.05 7.07,84.15 2.11,84.15 1.75,84.51 1.75,87.15 0.25,87.15 0.25,88.4 0.61,88.75 4.75,88.75 4.75,88 4.88,87.68 5.2,87.55 6.6,87.55 6.92,87.68 7.05,88 7.05,88.75 11.2,88.75 11.52,88.88 11.65,89.2 11.65,89.6 12.42,89.6
GND on BOTTOM (solid shape): 13.27,49.39 14.08,48.58 14.72,48.58 15.07,48.22 15.07,47.64 14.67,47.23 13.65,47.23 13.52,47.1 13.52,46.09 13.59,46.02 13.64,45.95 13.71,45.9 13.9,45.71 14.73,45.71 14.78,45.66 14.78,41.95 15.3,41.43 15.3,40.55 14.77,40.02 13.54,40.02 13.27,39.74 13.27,39.25 12.5,39.25 12.5,41.84 11.88,42.58 11.04,42.09 8.9,42.09 8.54,41.95 8.4,41.59 8.4,41.49 3.35,41.49 2.99,41.85 2.99,47.03 3.35,47.39 8.4,47.39 8.4,47.29 8.54,46.93 8.9,46.79 11.04,46.79 11.88,46.3 12.5,47.04 12.5,49.62 13.27,49.62
GND on BOTTOM (solid shape): 10.73,113.24 13.17,113.24 15.48,110.93 15.48,107.66 12.38,104.55 12.38,103.5 12.41,103.35 12.42,103.2 12.42,102.98 12.15,102.87 11.97,102.64 11.65,102.64 11.65,103.2 11.52,103.52 11.2,103.65 7.05,103.65 7.05,104.4 6.92,104.72 6.6,104.85 5.2,104.85 4.88,104.72 4.75,104.4 4.75,103.65 0.61,103.65 0.25,104.01 0.25,105.29 0.41,105.45 1.85,105.45 1.85,110.95 0.41,110.95 0.25,111.11 0.25,112.69 0.61,113.05 3.35,113.05 3.41,113.03 3.69,112.81 3.97,112.75 5.93,112.75 6.22,112.82 6.5,113.05 7.44,113.08 7.45,113.05 8.28,112.7 8.68,113.5 10.48,113.5
GND on BOTTOM (solid shape): outline of 124 points within 33.21,5.27 43.88,10.78
GND on BOTTOM (solid shape): 140.57,34.99 140.57,32.3 141.01,31.86 141.01,30.64 141.18,30.47 142.81,30.47 143.44,31.1 145.48,31.1 145.6,30.97 145.6,30.34 144.79,29.53 144.79,28.33 144.64,28.18 143.65,28.18 143.29,27.82 143.29,27.39 143.19,27.29 142.41,27.29 142.37,27.33 141.88,27.33 141.63,27.58 140.1,27.58 139.89,27.8 139.89,28.7 139.9,28.74 140.18,28.85 140.28,29.09 140.21,29.31 140.01,29.43 139.95,29.47 139.93,29.54 139.93,29.58 139.92,29.65 139.89,29.72 139.89,29.74 139.89,31.42 139.82,31.49 139.82,31.5 139.74,31.61 139.62,31.69 139.61,31.7 139.51,31.8 138.96,31.8 138.89,31.72 138.48,31.72 138.34,31.86 138.34,32.19 138.68,32.54 138.72,32.54 139.06,32.88 138.72,33.22 138.58,33.19 138.47,33.11 138.39,33.08 138.31,33.11 138.2,33.19 138.06,33.22 138.05,33.22 138,33.24 137.98,33.26 137.98,33.9 137.86,34.02 136.51,34.02 136.38,34.15 136.38,34.56 136.41,34.58 137.04,34.58 137.18,34.72 137.21,34.74 137.3,34.83 137.3,34.89 137.31,34.94 137.31,35 137.48,35.16 140.4,35.16
GND on BOTTOM (solid shape): 17,72.62 21.74,69.59 19.82,64.31 19.73,64.26 19.73,64.25 19.12,63.64 16.11,63.64 15.3,62.83 15.3,60.54 14.82,60.06 13.67,60.06 13.27,59.65 13.27,59.24 12.5,59.24 12.5,61.84 11.88,62.58 11.04,62.09 8.9,62.09 8.54,61.95 8.4,61.59 8.4,61.49 2.21,61.49 1.85,61.85 1.85,67.89 2.21,68.25 7.07,68.25 8.33,67.35 9.35,68.5 9.35,70.85 9.41,70.9 9.76,70.9 9.82,70.85 9.82,70.27 10.15,69.94 12.91,69.94 15.58,72.6 17,72.6
GND on BOTTOM (solid shape): outline of 181 points within 13.9,7.79 22.92,14.34
GND on BOTTOM (solid shape): outline of 174 points within 83.99,37.76 93.62,41.29
GND on BOTTOM (solid shape): outline of 260 points within 0.25,18.86 15.33,29.65
GND on BOTTOM (solid shape): outline of 251 points within 209.03,20.81 212.48,23.28
GND on BOTTOM (solid shape): outline of 294 points within 205.43,9.97 209.71,16.75
GND on BOTTOM (solid shape): outline of 941 points within 94.47,51.51 98.77,64.67
GND on BOTTOM (solid shape): outline of 1584 points within 0.25,0.25 219.55,127.75
GND on SGND (solid shape): outline of 2984 points within 0.51,0.51 219.29,127.49
GND on IN1 (solid shape): 65.72,35.64 65.65,35.57 65.65,33.8 65.62,33.77 63.94,33.77 63.94,37.32 65.72,37.32
GND on IN1 (solid shape): 100.67,26.35 100.67,25.18 100.37,24.88 97.75,24.88 97.17,25.46 97.17,26.63 97.65,27.11 99.91,27.11
GND on IN1 (solid shape): 102.55,88.23 102.55,85.48 102.53,85.46 99.02,85.46 98.99,85.48 98.99,88.23 99.02,88.25 102.53,88.25
GND on IN1 (solid shape): 45.91,114.16 45.91,112.13 45.78,112 43.75,112 42.99,112.76 42.99,113.78 43.09,113.88 43.11,113.88 43.27,114.03 44.51,114.03 44.77,114.29 45.78,114.29
GND on IN1 (solid shape): 12.42,89.2 12.37,88.88 12.25,88.59 12.25,87.74 12.71,87.28 12.71,83.2 12.03,82.51 10.63,82.51 9.97,81.85 9.43,81.85 9.35,81.93 9.35,83.9 8.33,85.05 7.07,84.15 2.11,84.15 1.75,84.51 1.75,87.15 0.25,87.15 0.25,88.4 0.61,88.75 4.75,88.75 4.75,88 4.88,87.68 5.2,87.55 6.6,87.55 6.92,87.68 7.05,88 7.05,88.75 11.2,88.75 11.52,88.88 11.65,89.2 11.65,89.62 12.42,89.62
GND on IN1 (solid shape): 19.2,72.61 21.27,70.54 21.27,70.29 21.57,69.99 21.57,69.66 21.85,69.38 21.85,66.35 20.72,65.22 20.72,65.07 19.29,63.64 16.11,63.64 15.3,62.83 15.3,60.54 14.82,60.06 13.67,60.06 13.27,59.65 13.27,59.24 12.5,59.24 12.5,61.84 11.88,62.58 11.04,62.09 8.9,62.09 8.54,61.95 8.4,61.59 8.4,61.49 2.21,61.49 1.85,61.85 1.85,67.89 2.21,68.25 7.07,68.25 8.33,67.35 9.35,68.5 9.35,70.82 9.46,70.93 9.71,70.93 9.82,70.83 9.82,70.27 10.15,69.94 12.91,69.94 15.66,72.68 19.2,72.68
GND on IN1 (solid shape): 13.27,49.39 14.08,48.58 14.72,48.58 15.07,48.22 15.07,47.64 14.73,47.29 13.71,47.29 13.24,46.82 13.24,46.04 14.93,44.35 14.93,42.17 15.3,41.8 15.3,40.27 15.05,40.02 13.54,40.02 13.27,39.74 13.27,39.25 12.5,39.25 12.5,41.84 11.88,42.58 11.04,42.09 8.9,42.09 8.54,41.95 8.4,41.59 8.4,41.49 3.35,41.49 2.99,41.85 2.99,47.03 3.35,47.39 8.4,47.39 8.4,47.29 8.54,46.93 8.9,46.79 11.04,46.79 11.88,46.3 12.5,47.04 12.5,49.62 13.27,49.62
GND on IN1 (solid shape): 10.73,113.24 13.17,113.24 15.48,110.93 15.48,107.4 12.38,104.3 12.38,103.5 12.41,103.35 12.42,103.2 12.42,102.5 11.65,102.5 11.65,103.2 11.52,103.52 11.2,103.65 7.05,103.65 7.05,104.4 6.92,104.72 6.6,104.85 5.2,104.85 4.88,104.72 4.75,104.4 4.75,103.65 0.61,103.65 0.25,104.01 0.25,105.29 0.41,105.45 1.85,105.45 1.85,110.95 0.41,110.95 0.25,111.11 0.25,112.69 0.61,113.05 3.35,113.05 3.41,113.03 3.69,112.81 3.97,112.75 5.93,112.75 6.22,112.82 6.5,113.05 7.44,113.08 7.45,113.05 8.19,112.67 8.7,113.33 8.79,113.41 10.56,113.41
