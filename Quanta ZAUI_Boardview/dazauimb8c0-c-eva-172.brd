# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DQ53: length 14.6
  TOP w0.127: v2(117.77,110.22) 118.27,109.71 121.25,109.71 v1(124.53,113) 124.93,113.4 v2(126.58,113.4)
  BOTTOM w0.127: v2(117.77,110.22) 116.99,109.45 116.15,109.45 115.88,109.17 115.56,109.17 115.2,109.53 U22.AA26
  BOTTOM w0.165: v2(126.58,113.4) 126.58,113.42 126.96,113.8 VRAM1.A4
VMA_DQ54: length 17.7
  TOP w0.127: v2(129.81,113.4) 129.73,113.4 129.23,112.9 125.15,112.9 v1(123.27,111.02) 121.45,109.21 117.74,109.21 v2(117.49,108.96)
  BOTTOM w0.102: v2(117.49,108.96) 116.75,108.22 115.3,108.22 U22.W26
  BOTTOM w0.165: v2(129.81,113.4) 129.81,113.4 VRAM1.E4
VMA_DQ55: length 19.6
  TOP w0.127: v2(116.22,108.96) 116.73,108.44 121.45,108.44 v1(124.55,111.54) 125.57,112.57 129.78,112.57 130.61,113.4 v2(130.61,113.4)
  BOTTOM w0.127: v2(116.22,108.96) 116.11,108.84 115.46,108.84 115.25,109.05 114.49,109.05 U22.Y25
  BOTTOM w0.165: VRAM1.F4 130.63,113.42 130.63,113.42 v2(130.61,113.4)
VMA_DQ56: length 13.9
  BOTTOM w0.127: VRAM1.B13 127.42,106.21 126.65,106.21 125.93,105.48 v1(120.2,105.48) 119.18,105.48 119.1,105.4 118.39,105.4 118.2,105.6 116.49,105.6 115.84,104.94 115.57,104.94 115.2,104.57 U22.R26
VMA_DQ57: length 14.1
  BOTTOM w0.127: U22.T25 114.53,104.97 115.06,104.97 115.3,105.21 115.3,105.68 115.49,105.87 116.23,105.87 116.35,105.98 118.21,105.98 118.37,105.82 118.85,105.82 119.06,106.03 v1(121.85,106.03) 125.87,106.03 126.44,106.6 VRAM1.A13
VMA_DQ58: length 17.6
  BOTTOM w0.127: U22.N27 115.88,103.04 116.95,103.04 118.3,104.38 v1(122.36,104.38) 129.98,104.38 130.74,105.14 130.74,105.4 130.62,105.52 130.62,106.21 VRAM1.F13
VMA_DQ59: length 16
  BOTTOM w0.127: U22.R27 115.84,104.57 116.6,105.33 118.05,105.33 118.41,104.97 v1(123.51,104.97) 129.3,104.97 129.81,105.47 129.81,106.2 VRAM1.E13
VMA_DQ60: length 13.2
  BOTTOM w0.127: VRAM1.A11 126.64,108.57 v1(120.33,108.57) 119.87,108.57 118.09,106.78 116,106.78 115.9,106.68 115.5,106.68 115.12,107.05 U22.V26
VMA_DQ61: length 14
  BOTTOM w0.127: VRAM1.B11 127.42,108.59 127.42,109.29 127.25,109.46 v1(123.12,109.46) 120.05,109.46 117.64,107.05 U22.V27
VMA_DQ62: length 18.1
  BOTTOM w0.127: U22.W27 117,107.85 119.75,110.6 v1(120.58,110.6) 129.86,110.6 130.64,109.82 130.64,108.57 VRAM1.F11
VMA_DQ63: length 18.6
  BOTTOM w0.127: U22.W25 114.55,107.43 117.3,107.43 119.97,110.1 v1(121.85,110.1) 129.01,110.1 129.47,109.64 129.47,109.42 129.77,109.12 129.77,108.64 VRAM1.E11
VMA_WCK01: length 37.1
  IN3 w0.089: v2(107.91,94.19) 108.13,94.19 108.41,93.92 109.12,93.92 113.7,89.34 121.91,89.34 127.04,84.21 135.32,84.21 136.59,85.48 136.59,85.58 137.45,86.44 137.57,86.44 v2(137.81,86.21)
  BOTTOM w0.102: U22.D18 108.01,95.09 108.01,94.29 v2(107.91,94.19) ; VRAM2.D4 137.41,85.81 v2(137.81,86.21)
VMA_WCK01#: length 37.1
  IN3 w0.089: v2(137.81,87.01) 137.43,86.62 137.37,86.62 136.41,85.66 136.41,85.56 135.24,84.39 127.11,84.39 121.99,89.51 113.77,89.51 109.19,94.09 108.48,94.09 108.4,94.18 108.4,94.57 108.77,94.94 v2(108.77,95.01)
  BOTTOM w0.102: VRAM2.D5 137.41,86.61 v2(137.81,87.01) ; v2(108.77,95.01) 108.32,95.01 108.22,94.91 108.22,94.76 U22.C18
VMA_WCK23: length 28
  IN3 w0.089: v2(107.08,95.02) 107.29,95.24 108.26,95.24 108.59,95.57 108.93,95.57 109.41,95.09 109.41,94.65 111.23,92.82 112.58,92.82 112.91,92.49 112.91,91.61 114.45,90.07 123.08,90.07 126.56,86.6 128.62,86.6 v2(129.01,86.21)
  BOTTOM w0.102: v2(107.08,95.02) 107.48,95.43 U22.D17 ; v2(129.01,86.21) 129.01,86.2 VRAM2.P4
VMA_WCK23#: length 28.1
  IN3 w0.089: v2(129.01,87.01) 128.78,86.78 126.63,86.78 123.16,90.25 114.52,90.25 113.09,91.68 113.09,92.57 112.66,93 111.31,93 109.59,94.72 109.59,95.16 109,95.74 108.51,95.74 108.18,95.41 107.5,95.41 v2(107.11,95.8)
  BOTTOM w0.102: U22.D16 106.74,95.43 v2(107.11,95.8) ; v2(129.01,87.01) 129.01,86.81 129.22,86.6 VRAM2.P5
VMA_WCK45: length 34.5
  IN3 w0.089: v2(137.01,113.41) 136.93,113.32 136.68,113.32 136.59,113.41 136.59,114.66 135.86,115.39 133.58,115.39 133.16,115.81 132.27,115.81 130.74,117.33 125.41,117.33 117.79,109.71 116.02,109.71 115.45,109.15 115.45,108.52 114.82,107.89 114.34,107.89 114.11,108.11 113.4,108.11 112.91,107.63 112.91,106.47 113.22,106.16 113.22,106.03 v2(112.96,105.78)
  BOTTOM w0.102: v2(137.01,113.41) 137.41,113.8 VRAM1.P4 ; U22.T24 113.33,105.68 113.23,105.78 v2(112.96,105.78)
VMA_WCK45#: length 34.5
  IN3 w0.089: v2(137.01,112.61) 137.01,112.85 136.71,113.14 136.6,113.14 136.41,113.34 136.41,114.59 135.79,115.21 133.5,115.21 133.08,115.63 132.2,115.63 130.67,117.16 125.48,117.16 117.86,109.54 116.09,109.54 115.63,109.08 115.63,108.44 114.9,107.71 114.26,107.71 114.03,107.94 113.47,107.94 113.09,107.56 113.09,106.54 113.4,106.23 113.4,105.98 113.57,105.8 v2(113.75,105.8)
  BOTTOM w0.102: v2(113.75,105.8) 113.74,105.8 U22.U24 ; VRAM1.P5 137.41,113 v2(137.01,112.61)
VMA_WCK67: length 20
  IN3 w0.089: v2(129.01,114.21) 129.01,113.89 128.87,113.75 128.77,113.75 128.43,114.08 123.31,114.08 116.32,107.1 114.08,107.1 v2(113.73,107.45)
  BOTTOM w0.102: U22.V24 v2(113.73,107.45) ; v2(129.01,114.21) 129.41,113.81 VRAM1.D4
VMA_WCK67#: length 19.9
  IN3 w0.089: v2(113.72,106.62) 114.02,106.92 116.39,106.92 123.38,113.91 128.36,113.91 128.69,113.57 128.81,113.57 v2(128.99,113.4)
  BOTTOM w0.102: U22.V25 113.82,107.05 113.72,106.95 v2(113.72,106.62) ; VRAM1.D5 129.39,113 v2(128.99,113.4)
VQQD_VPPSNS: length 3.3
  TOP w0.203: PU1.12 64.52,123.11 v1(64.72,123.31)
  BOTTOM w0.203: v1(64.72,123.31) v1(63.72,124.32) PR123.2
VR_SVID_ALERT#: length 60.9
  TOP w0.102: PR61.1 v1(137.46,48.56)
  IN1 w0.089: v1(108.06,77.38) 108.16,77.48 110.94,77.48 113.85,74.57 113.85,68.74 115.81,66.79 119.98,66.79 120.04,66.73 121.9,66.73 121.96,66.79 127.19,66.79 132.61,61.36 132.61,59.13 134.72,57.02 134.72,55.63 133.67,54.57 133.67,52.39 137.46,48.59 v1(137.46,48.56)
  BOTTOM w0.102: v1(108.06,77.38) 107.38,77.38 106.51,78.24 106.51,79.09 v1(105.31,80.3) 104.1,81.51 104.1,81.57 103.69,81.98 102.86,81.98 102.58,81.7 R588.1 102.14,81.44 102.09,81.49 R587.2 ; PR204.2 137.45,48.65 137.46,48.64 v1(137.46,48.56)
VR_SVID_CLK: length 62.3
  TOP w0.102: PR63.1 v1(138.93,48.56)
  IN1 w0.089: v1(138.93,48.56) 138.93,48.33 138.67,48.07 137.25,48.07 133.18,52.13 133.18,54.76 134.25,55.82 134.25,56.81 132.13,58.93 132.13,61.09 126.91,66.31 122.1,66.31 122.06,66.26 119.84,66.26 119.8,66.31 115.61,66.31 113.37,68.54 113.37,74.38 110.76,77 108.42,77 v1(108.04,76.62)
  BOTTOM w0.102: PR206.2 138.92,48.93 138.93,48.92 v1(138.93,48.56) ; v1(108.04,76.62) 107.45,76.62 105.98,78.09 v1(105.98,78.52) 105.98,78.94 104.06,80.86 101.68,80.86 R590.2
VR_SVID_DATA: length 61.9
  TOP w0.102: PR62.1 138.2,48.65 138.19,48.64 v1(138.19,48.56)
  IN1 w0.089: v1(108.06,78.09) 108.2,77.95 111.13,77.95 114.34,74.75 114.34,68.94 116.01,67.27 120.16,67.27 120.23,67.2 121.73,67.2 121.8,67.27 127.37,67.27 133.09,61.55 133.09,59.31 135.19,57.22 135.19,55.43 134.2,54.44 134.2,52.56 137.63,49.14 137.78,49.14 138.19,48.73 v1(138.19,48.56)
  BOTTOM w0.102: R586.2 102.14,82.26 102.35,82.46 103.62,82.46 103.98,82.82 R585.1 104.18,82.18 104.58,81.77 v1(104.58,81.74) 104.58,81.71 107.05,79.24 107.05,78.65 107.61,78.09 v1(108.06,78.09) ; v1(138.19,48.56) PR205.2
VRALERT#: length 74.1
  TOP w0.102: R241.1 80.61,45.86 80.27,45.52 v2(80.26,45.52)
  IN1 w0.102: v2(80.26,45.52) 80.27,45.51 80.83,45.51 81.05,45.73 82.46,45.73 82.64,45.55 83.86,45.55 84.52,46.21 84.52,48.58 85.41,49.47 85.41,54.1 86.33,55.02 86.33,74.68 85.51,75.5 85.51,77.27 85.3,77.48 85.3,81.06 85.23,81.14 85.23,82.49 83.91,83.81 83.91,84.62 v1(83.42,85.1)
  BOTTOM w0.102: v1(83.42,85.1) 83.53,85.2 83.53,86.12 84.16,86.75 85,86.75 85.05,86.8 89.22,86.8 89.88,87.46 92.04,87.46 92.57,86.93 93.41,86.93 94.8,85.53 95.52,85.53 95.82,85.23 102.75,85.23 102.89,85.37 102.89,85.9 v1(103.46,86.47) 104.02,87.03 105.27,87.03 105.47,86.83 R571.1 105.47,85.89 105.7,85.66 D23.1
  BOTTOM w0.114: v2(80.26,45.52) 80.26,45.61 79.98,45.9 U24.CN38
VREF_RC: length 2.2
  TOP w0.457: PR57.2 PC60.2
  TOP w0.508: PC60.2 v1(145.89,50.67)
VRON: length 107.8
  TOP w0.102: v2(143.74,60.27) 143.29,60.72 PR46.1 ; U13.69 199.71,17.38 199.78,17.31 200.62,17.31 200.98,16.95 R459.1 201.18,17.44 v2(201.26,17.51)
  IN3 w0.089: v2(201.26,17.51) 200.7,18.06 200.7,19.44 200.21,19.93 200.21,22.43 201,23.22 201,24.12 200.51,24.6 196.95,24.6 196.47,25.08 196.47,25.47 195.69,26.24 195.43,26.24 195.14,26.54 193.94,26.54 193.06,27.42 193.06,28.76 191.72,30.09 187.32,30.09 187.21,30.2 183.48,30.2 182.92,29.63 180.1,29.63 179.62,30.12 175.66,30.12 174.75,31.03 170.13,31.03 169.75,30.65 166.24,30.65 165.88,30.29 164.57,30.29 163.99,30.88 162.14,30.88 161.36,30.1 160.43,30.1 159.65,30.88 158.6,30.88 157.74,31.74 155.38,31.74 154.25,32.87 146.69,32.87 145.85,32.03 143.94,32.03 143.33,32.64 143.33,32.99 142.58,33.74 142.58,35.61 142.95,35.97 142.95,37.79 142.62,38.12 142.62,38.45 143.84,39.67 143.84,39.87 144,40.03 144,43.06 144.52,43.58 144.52,45.01 144.89,45.38 144.89,46.39 145.95,47.45 145.96,47.45 146.05,47.53 146.05,49.82 146.7,50.47 146.7,53.82 145.6,54.91 145.6,56.39 144.63,57.36 144.63,59.38 v2(143.74,60.27)
VSTBY_FSPI: length 28.8
  TOP w0.102: v2(176.39,32.78) 177.72,31.45 178.54,31.45 179.11,30.88 R331.2 179.7,30.22 R344.2 ; v2(192.59,32.93) 192.54,32.98 192.54,33.2 192.36,33.38 v1(192.19,33.38) 192.11,33.38 191.88,33.16 191.88,31.08 192.13,30.83 193.46,30.83 193.65,30.64 U13.106
  IN2 w0.089: v2(176.39,32.78) 176.39,32.44 176.89,31.94 179.29,31.94 179.85,31.39 182.38,31.39 182.98,31.99 186.62,31.99 188.06,33.43 190,33.43 190.44,32.98 192.54,32.98 v2(192.59,32.93)
WIGIG_LED: length 5
  BOTTOM w0.102: TP83.1 190.14,32.12 189.75,31.73 189.75,30.13 190,29.88 CN9.6
WLAN_RST#: length 2.8
  BOTTOM w0.102: R819.1 193.13,19.29 192.64,18.81 192.37,18.81 191.94,18.38 CN9.52
WLANPWR#: length 5.2
  TOP w0.102: TP48.1 187.56,10.45 187.56,11.01 187.21,11.37 187.21,12.84 186.85,13.19 185.77,13.19 185.65,13.32 U13.35
WRST#: length 15.8
  TOP w0.102: D13.2 176.75,25.5 R399.1 176.1,24.63 176.31,24.42 176.31,22.69 176.44,22.57 v2(176.45,22.57) 176.45,22.1 v1(176.13,21.78) ; U13.14 182.34,22.98 181.65,22.29 180.71,22.29 180.38,21.96 180.38,21.73 v2(180.3,21.65) 179,20.36 179,19.71 C435.1
  IN3 w0.089: v2(180.3,21.65) 180.21,21.65 179.96,21.4 179.4,21.4 178.84,21.96 177.06,21.96 v2(176.45,22.57)
XDP_PCH_SPI0_IO2: length 3.2
  BOTTOM w0.102: R723.2 R743.1 R753.1 76.42,26.91 76.21,26.7 TP92.1
XDP_PCH_SPI0_SI: length 3.2
  BOTTOM w0.102: R755.2 77.43,27.07 77.38,27.01 77.38,26.5 77.33,26.45 R771.1 77.33,26.02 77.05,25.74 76.74,25.74 76.61,25.61 R778.1 76.61,24.7 TP96.1
XDP_RSMRST#: length 0.9
  BOTTOM w0.102: TP82.1 R704.1
XDP_TCK: length 8.8
  TOP w0.102: v1(102.07,75.81) 101.48,75.22 99.78,75.22 v2(99.71,75.3)
  BOTTOM w0.079: U24.P3 97.12,74.59 98.76,74.59 98.78,74.6 99.38,75.2 99.6,75.2 v2(99.71,75.3)
  BOTTOM w0.102: TP69.1 103.27,75.47 103.2,75.55 102.68,75.55 102.58,75.65 R603.1 102.2,75.93 v1(102.07,75.81) R604.2
XDP_TDI_CPU: length 7.9
  BOTTOM w0.079: 100.34,78.78 100.16,78.78 99.82,78.44 99.82,78.28 98.43,76.89 97.72,76.89 97.66,76.82 96.96,76.82 96.94,76.85 96.61,76.85 96.31,76.55 U24.K5
  BOTTOM w0.102: 100.34,78.78 101.71,78.78 TP66.1 101.79,78.87 R592.2
XDP_TDO_CPU: length 9.1
  BOTTOM w0.079: 98.88,76.58 98.68,76.37 98.53,76.37 98.28,76.12 97.83,76.12 97.68,76.27 97.03,76.27 U24.K3 ; 99.62,77.29 100.39,78.06
  BOTTOM w0.102: 99.62,77.29 99.6,77.29 98.88,76.58 ; TP67.1 104.07,76.74 102.7,76.74 102.58,76.87 R599.1 102.42,77.48 R598.2 101.56,77.48 100.95,78.09 100.42,78.09 100.39,78.06
XDP_TMS_CPU: length 9.6
  BOTTOM w0.079: 99.44,74.88 98.97,74.41 98.12,74.41 98.1,74.43 97.34,74.43 97.2,74.28 96.96,74.28 96.61,74.63 U24.P4
  BOTTOM w0.102: TP70.1 104.68,74.2 104.41,73.93 R608.2 103.59,73.93 103.54,73.98 103.16,73.98 102.07,75.07 101.89,75.07 101.74,75.22 100.44,75.22 100.14,74.92 99.48,74.92 99.44,74.88
XDP_TRST#: length 8
  BOTTOM w0.079: 100.01,76.14 99.38,76.14 98.72,75.47 98.33,75.47 U24.N1
  BOTTOM w0.102: TP68.1 105.09,76.44 104.86,76.21 103.92,76.21 103.8,76.34 102.27,76.34 102.14,76.47 R602.2 101.48,76.47 101.37,76.35 101.04,76.35 100.82,76.14 100.01,76.14
XTAL1: length 2.5
  TOP w0.102: R16.2 45.45,109.45 45.06,109.06 45.06,108.35 44.84,108.14 U1.28
XTAL2: length 2.1
  TOP w0.102: U1.29 44.44,108.12 44.65,108.33 v1(44.65,108.65) 44.65,109.33 R15.1
XTAL_38P4M_IN: length 6.7
  BOTTOM w0.102: R727.2 99.23,29.75 98.48,30.49 96.68,30.49 96.07,31.1 95.24,31.1 94.38,31.96 94.38,32.46 U24.DW8
XTAL_38P4M_IN_R: length 4.8
  BOTTOM w0.102: R727.1 98.78,29.16 98.84,29.1 R740.1 98.84,28.27 C658.2 99.37,27.54 98.94,27.11 98.94,26.04 Y4.1
XTAL_38P4M_OUT: length 7.1
  BOTTOM w0.102: U24.DU8 94.21,33.91 93.93,33.63 93.93,32.48 94.12,32.28 94.12,31.93 95.18,30.87 95.73,30.87 96.51,30.09 97.6,30.09 97.76,29.92 R726.2
XTAL_38P4M_OUT_R: length 3.2
  BOTTOM w0.102: Y4.3 98.2,27.56 C657.2 98.39,27.75 R740.2 98.39,28.91 98.21,29.09 R726.1
XTAL_SSIN: length 7.6
  BOTTOM w0.102: R570.1 98.7,87.36 98.8,87.46 98.8,89.43 100.03,90.66 100.46,90.66 101.38,91.59 101.38,92.6 101.71,92.93 U22.A10
N06325: length 10.3
  BOTTOM w0.102: R798.1 70.12,23.86 68.57,23.86 67.24,22.54 Q43.3 67.04,20.66 66.61,20.23 R807.2 R820.2
N10350616: length 5.6
  BOTTOM w0.178: PC200.2 137.63,51.82 137.85,51.61 PR200.2
  BOTTOM w0.203: PR206.1 PR205.1 PR204.1 PR203.2 136.71,49.74 136.59,49.87 136.59,50.48 137.34,51.24 PR200.2
N10356361: length 27
  TOP w0.178: v1(137.53,57.26) 137.31,57.26 136.9,57.67 136.9,58.25 137.21,58.55 PR52.2 137.72,58.9 137.72,58.9 137.85,59.03 137.85,59.35 138.09,59.59 138.71,60.21 v1(139.46,60.21) PR47.2
  IN3 w0.102: v1(137.53,57.26) 137.68,57.42 137.68,60.01 136.4,61.28 133.22,61.28 126.7,67.8 124.8,67.8 v1(124.39,68.21)
  BOTTOM w0.178: v1(124.39,68.21) 124.39,67.35 PR160.2
N16824426: length 2
  BOTTOM w0.102: R510.2 R509.2 101.03,119.37 U20.2
N17002655: length 3
  BOTTOM w0.203: C629.2 209.36,35.64 209.36,34.76 209.13,34.53 208.87,34.53 208.36,34.03 U30.39
N17002661: length 5.6
  BOTTOM w0.102: U30.37 207.76,35.22 v1(208.21,35.67) 208.67,36.13 208.67,39.1 208.59,39.19 C615.2
N17002676: length 1.9
  BOTTOM w0.102: U30.34 206.06,36.31 206.54,36.79 206.54,37.21 C622.1
N17002678: length 2.3
  BOTTOM w0.203: C635.1 200.32,33.41 200.9,32.82 U30.19
N17002722: length 4.7
  TOP w0.102: R338.2 208.96,29.85 v1(209.61,29.2) 209.61,28.9 R366.2
  BOTTOM w0.102: U30.48 208.18,30.43 208.34,30.26 208.34,29.73 v1(208.49,29.58) 208.55,29.63 209.18,29.63 v1(209.61,29.2)
N17002952: length 1.7
  BOTTOM w0.102: C659.1 204.23,28.35 204.46,28.58 U30.7
N17002968: length 7.2
  BOTTOM w0.102: U30.11 202.86,28.79 202.75,28.69 202.37,28.69 201.34,27.66 R754.1 200.96,27.66 200.83,27.52 200.83,27.19 200.64,27 200.64,26.72 200.37,26.45 199.22,26.45 R772.1 199.05,25.92 R782.1
N17002995: length 6.6
  BOTTOM w0.102: R746.1 199.13,27.86 198.66,27.39 R756.1 198.94,27.16 198.99,27.21 v1(199.35,27.21) 199.64,26.93 C660.1 200.59,27.35 200.59,27.9 200.93,28.23 201.51,28.23 202.46,29.18 U30.12
N17003129: length 6.1
  BOTTOM w0.102: v1(207.39,40.96) C615.1 207.39,39.83 207.88,39.33 207.88,38.9 207.33,38.34 207.33,36.92 206.88,36.47 206.74,36.47 206.46,36.19 U30.35
N17003186: length 4.5
  BOTTOM w0.102: R695.1 199.09,34.8 v1(199.96,35.67)
  BOTTOM w0.203: U30.20 200.94,33.22 200.27,33.9 199.81,33.9 199.09,34.62 R695.1
N17004316: length 3.5
  BOTTOM w0.102: D37.1 200.24,23.13 200.34,23.02 200.34,21.53 201.21,20.66 Q45.3
N17047007: length 2.8
  TOP w0.152: PR12.1 51.57,116.9 51.8,116.67 51.8,114.89 PR18.1
  vias: v1(50.68,119.28)
N17047009: length 2.6
  BOTTOM w0.152: PR261.1 131.63,27.29 133.23,27.29 133.42,27.48 PU12.20
N17047028: length 3.1
  BOTTOM w0.152: PU12.19 133.82,27.45 133.36,26.99 131.73,26.99 PR267.1
N17047087: length 24.2
  TOP w0.508: v1(119.7,26.91) 119.72,26.91 120.22,27.41 PC91.1 121.6,26.27 124.48,26.27 124.69,26.48 126.13,26.48 126.23,26.38 127.46,26.38 128.22,27.14 128.94,27.14 v1(129.21,26.87) 129.47,26.61 129.47,25.93 PR108.1
  BOTTOM w0.152: PR266.1 111.87,27.01 111.71,26.85 111.71,25.26 112.32,24.65 119.72,24.65 PR270.2
  vias: v1(114.62,26.91) v1(115.25,26.91) v1(115.89,26.91) v1(116.52,26.91) v1(117.16,26.91) v1(117.79,26.91) v1(118.43,26.91) v1(119.06,26.91)
N17047112: length 172.2
  TOP w0.508: PQ3.4 43.37,121.4 43.43,121.34 PC8.2 44.66,121.34 v1(44.69,121.37) 45.26,121.94 PC6.2 ; PQ4.4 v1(44.85,116.77)
  IN2 w0.508: v1(124.83,48.83) 124.83,48.96 123.71,50.07 117.36,50.07 116.24,51.19 116.24,66.74 115.13,67.85 115.13,73.68 115.56,74.1 115.56,80.78 110.42,85.92 106.65,85.92 101.11,91.45 97.36,91.45 96.31,92.5 96.31,102.09 96.1,102.3 96.1,103.46 93.36,106.2 93.36,107.3 91.2,109.46 85.41,109.46 84.14,110.73 82.48,110.73 80.48,112.74 78.29,112.74 75.61,115.42 75.61,117.2 73.72,119.09 73.72,125.21 72.73,126.2 61.5,126.2 60.23,124.93 58.84,124.93 57.59,123.68 51.75,123.68 51.18,123.11 46.43,123.11 v1(44.69,121.37)
  IN3 w0.508: v1(134.58,34.96) 132.12,37.43 129.68,37.43 126.17,40.94 126.17,47.49 v1(124.83,48.83)
  BOTTOM w0.508: v1(44.85,116.77) 45.58,117.5 45.58,120.43 44.69,121.32 v1(44.69,121.37) ; PR247.1 v1(134.58,34.96)
N17047335: length 5
  BOTTOM w0.508: PC249.1 127.6,27.57 127.06,27.04 v1(126.58,27.04) 125.48,27.04 125.37,26.92 124.01,26.92 PR268.2
N17047399: length 1.4
  BOTTOM w0.508: PC243.2 PR254.2
N17047601: length 12.6
  TOP w0.508: PQ11.4 119.58,27.84 119.93,28.19 PC91.2 121.01,28.19 122.08,27.11 v1(124.24,27.11) 126.4,27.11 126.5,27.01 127.19,27.01 127.96,27.77 129.2,27.77 129.81,27.16 PR99.1
N17398787: length 1.8
  TOP w0.203: PR80.2 135.06,32.63 134.85,32.83 v1(134.65,32.83)
  BOTTOM w0.178: PU12.5 134.62,32.81
  BOTTOM w0.203: 134.62,32.81 v1(134.65,32.83)
N17424918: length 1.9
  BOTTOM w0.178: PR253.2 137.68,30.01 137.58,29.91 PU12.11
N17424920: length 2
  BOTTOM w0.178: PU12.12 137.72,29.51 137.93,29.3 PR255.2
N17424921: length 1.4
  BOTTOM w0.178: 135.42,32.33 PU12.7
  BOTTOM w0.203: PR249.2 135.91,32.82 135.42,32.33
N17424925: length 1.6
  BOTTOM w0.198: PU12.9 136.7,30.71 136.87,30.87
  BOTTOM w0.203: PR251.2 136.87,31.12 136.87,30.87
N17424950: length 2.6
  TOP w0.178: PR86.2 PR88.2 136.48,28.96 135.98,28.46 135.98,28.1 v2(136,28.08)
  BOTTOM w0.178: v2(136,28.08) 135.98,28.08 135.95,28.05 135.88,28.05 135.73,27.91 PU12.15
N17661815: length 1.8
  BOTTOM w0.198: 136.56,31.71 136.22,31.37 PU12.8
  BOTTOM w0.203: PR250.2 137.3,32.12 136.89,31.71 136.56,31.71
N17755724: length 32.4
  TOP w0.203: v1(139.28,39.79) 139.28,39.99 138.84,40.43 PC62.2
  IN2 w0.089: v1(139.28,39.79) 138.96,40.11 138.96,40.46 138.57,40.85 137.08,40.85 136.17,39.94 120.41,39.94 118.3,37.83 118.3,37.58 118.04,37.32 117.79,37.32 117.31,36.84 115.84,36.84 v1(115.33,36.33)
  BOTTOM w0.178: v1(139.28,39.79) 139.33,39.73 PR231.2
  BOTTOM w0.203: PR241.1 114.15,35.5 PR243.1 114.7,35.71 v1(115.33,36.33) ; PR235.1 139.33,38.61 PR231.2 138.88,39.07 138.87,39.08 PR233.1
N18377216: length 4.9
  TOP w0.102: R302.1 87.28,33.87 86.65,34.5 85.64,34.5 85.31,34.84 85.31,36.03 84.94,36.4 v2(84.94,36.45)
  BOTTOM w0.102: v2(84.94,36.45) 84.99,36.45 85.26,36.71 85.26,36.72 U24.DL27
N18377220: length 8.5
  TOP w0.102: R311.1 85.41,32.55 83.75,34.2 83.75,34.58 83.73,34.58 83.46,34.85 83.46,35.91 83.6,36.05 83.6,36.75 83.5,36.84 83.5,37.85 83.08,38.28 v2(83.05,38.28)
  BOTTOM w0.102: U24.DJ29 84.15,38.33 83.1,38.33 v2(83.05,38.28)
N18867651:
  vias: v1(153.17,24.01)
N18867812:
  vias: v1(20.64,29.65)
N18922914: length 1.2
  BOTTOM w0.381: U22.AA9 100.9,109.59 v2(100.51,109.97) U22.AA8
  vias: v1(97.6,108.22)
N19138106: length 1.4
  TOP w0.102: v2(111.31,96.66) 111.27,96.66 110.82,97.11 R59.2
  BOTTOM w0.102: U22.F22 111.63,96.98 v2(111.31,96.66)
N19138109: length 2.2
  TOP w0.102: R46.2 110.83,99.79 111.01,99.6 111.47,99.6 111.88,99.19 v2(112.11,99.19)
  BOTTOM w0.102: v2(112.11,99.19) U22.J22
N19521323: length 2.4
  TOP w0.102: PR83.1 143.28,31.48 142.91,31.48 v1(142.86,31.43) 142.86,30.88 PQ12.3
N19521733: length 9.3
  TOP w0.102: v1(142.61,34.02) 142.3,34.02 141.92,33.64 141.92,31.55 PR82.1 141.57,31.19 141.57,29.77 141.92,29.42 141.92,28.56 141.68,28.32 PQ12.2 141.59,28.08 PR96.1 141.48,27.3 141.24,27.55 140.88,27.55 140.75,27.67 PR92.1
N19549602: length 6.9
  TOP w0.102: PR122.1 PR121.1 46.83,12.38 v1(46.29,12.91) 46.19,13.02 46.19,15.4 45.67,15.92 PQ13.2 45.07,15.92 45.01,15.86 PR118.1
N20858957: length 1
  TOP w0.508: C211.2 63.18,75.03 R154.2
N20946170: length 4.3
  TOP w0.102: R114.1 v1(45.28,82.14) 45.28,82.42 U2.E9
N20946459: length 3.6
  TOP w0.102: R229.1 43,48.64 43.39,49.03 v1(43.39,50.07) 43.39,51.11 U6.E9
N20946794: length 4.2
  TOP w0.102: U4.E9 42.71,70.97 42.71,69.11 v1(43.07,68.74) 43.2,68.74 R190.1
N20947128: length 4.2
  TOP w0.102: R295.1 41.07,35.92 42.89,37.73 42.89,38.1 U8.E9
N21263014: length 18.5
  TOP w0.102: v2(101.3,95.82) 101.3,95.69 100.8,95.2 100.21,95.2 99.96,95.44 99.46,95.44 98.08,94.07 95.29,94.07 93.41,92.19 90.13,92.19 89.6,91.65 89.11,91.65 88.45,92.32 88.05,92.32 87.67,92.7 86.47,92.7 TP9.1
  BOTTOM w0.102: U22.E10 v2(101.3,95.82)
N21263017: length 15.6
  TOP w0.102: v2(101.28,96.63) 102.04,95.87 102.04,95.11 100.65,93.71 96.33,93.71 94.3,91.68 TP10.1
  BOTTOM w0.102: U22.F10 101.71,97.06 v2(101.28,96.63)
N24507642: length 6.7
  TOP w0.102: v2(158.89,24.62) 158.89,25.01 158.66,25.23 158.45,25.23 PR105.1 158.43,25.5 158.96,26.04 PC102.1 ; PC102.1 PR106.2 ; PC102.1 v1(159.35,26.96)
  BOTTOM w0.102: v2(158.89,24.62) 159.31,24.2 PU14.6
N24507664: length 14.5
  TOP w0.102: v2(159.47,24.62) 160.08,24.62 160.36,24.9 PR106.1 ; v1(161.35,24.93) 161.19,24.93 160.86,25.26 PR106.1 ; PC102.2 PR106.1
  BOTTOM w0.102: v2(159.47,24.62) 159.88,24.62 160.11,24.85 162.74,24.85 163.02,25.13 165.03,25.13 165.21,25.31 165.21,25.73 165.63,26.15 167.22,26.15 167.37,26 167.37,24.96 168.03,24.3 PR272.1
N24507676: length 15.8
  TOP w0.102: PR116.1 166.15,18.15 v1(165.72,17.72) 165.52,17.51 164.78,17.51 164.57,17.73 164.57,19.67 165.19,20.29 165.19,23.76 165.8,24.37 166.28,24.37 166.37,24.28 PC104.2 166.64,24.45 166.15,24.93 v2(166.15,25.51)
  BOTTOM w0.102: PU14.1 164.14,24.2 164.54,24.6 165.8,24.6 166.15,24.95 v2(166.15,25.51)
N24507691: length 8.7
  TOP w0.102: PR109.2 167.5,25.31 167.3,25.51 v2(166.97,25.51)
  BOTTOM w0.102: v2(166.97,25.51) 166.97,25.72 166.76,25.92 165.72,25.92 165.44,25.64 165.44,25.18 165.14,24.88 163.09,24.88 162.58,24.37 162.49,24.37 161.38,23.25 PU14.5
N24742093: length 3.9
  BOTTOM w0.508: PR141.1 69.91,109.47 69.91,108.01 69.15,107.25 69.15,106.03
  vias: v1(71.23,100.27)
N24742096: length 16.9
  IN2 w0.089: v2(75.93,98.84) v2(74.97,98.84)
  BOTTOM w0.102: PQ15.3 70.39,107.3 71.18,107.3 71.28,107.2 71.92,107.2 72.6,106.51 72.6,105.93 73.06,105.47 73.06,103.06 73.19,102.93 73.19,102.7 v1(73.49,102.4) 73.21,102.12 73.21,101.84 73.11,101.74 73.11,100.8 73.29,100.62 73.6,100.62 74.59,99.63 75.35,99.63 75.93,99.05 v2(75.93,98.84) ; v2(74.97,98.84) 74.79,98.84 74.36,98.41 PR151.2 73.6,98.04 73.09,97.52 PD7.2
N24742104: length 11.2
  BOTTOM w0.102: PQ17.2 75.46,104.29 75.27,104.48 75.27,105.91 PR146.1 ; PR146.1 75.86,106.32 75.86,106.26 75.95,106.18 75.95,106.15 76.33,105.78 76.62,105.78 77.38,105.02 PQ18.3 ; PR146.1 PR145.2 75.31,106.97 74.43,106.97 v1(74.33,106.87) 74.23,106.97 72.91,106.97 72.05,107.83 PQ15.2
N24742107:
  vias: v1(21.27,95.77)
N24742118: length 1.4
  BOTTOM w0.102: PR147.1 76.39,101.71 76.83,101.27 PU8.3
N24742123: length 10.6
  BOTTOM w0.102: PQ17.3 74.51,105.95 73.72,106.74 72.76,106.74 72.07,107.43 71.56,107.43 70.52,108.47 70.52,108.95 70.65,109.08 70.65,111.21 70.51,111.36 PR141.2 69.12,111.36 v1(68.46,110.7)
N24742126: length 9.4
  BOTTOM w0.102: PU8.4 76.83,98.37 77.93,99.47 v1(77.93,100.44) 77.93,101.95 77.88,102 PQ18.2
  BOTTOM w0.254: PR153.1 PC158.1 75.91,96.8 76.55,96.8 76.83,97.07 PU8.4
N24742146: length 2.2
  BOTTOM w0.102: PC161.1 74.48,93.49 v1(74.56,93.41)
  BOTTOM w0.254: PC161.1 74.36,94.34 PR152.2
N24742173: length 5
  TOP w0.102: PU3.4 22.54,91.93 22.67,91.81 22.67,91.05 PC40.1 23.18,90.54 23.68,90.03 23.68,88.77 PR37.2
N24742207: length 1.9
  TOP w0.102: PU3.10 22.94,95.26 23.56,95.87 PC34.1
N24742208: length 1.8
  TOP w0.102: PU3.12 22.14,95.84 PC33.1
N24742222: length 5.6
  TOP w0.102: PU3.5 22.94,91.8 PC41.1 25.08,89.66 v1(25.08,89.24) 25.08,89.15 PR38.1
N24742230: length 4.8
  TOP w0.102: PR36.2 22.67,88.77 22.67,90.04 PC39.1 22.14,90.56 v1(22.14,91.53) PU3.3
N24995566: length 2.8
  BOTTOM w0.102: PU13.5 103.57,27.28 PC255.1 103.08,27.02 102.8,27.29 102.68,27.29 102.58,27.39 PR262.2
N24995570: length 1.4
  BOTTOM w0.102: PR263.1 108.09,27.28 PU13.1
N24995581: length 1.1
  BOTTOM w0.102: PR269.1 107.88,25.38 PU13.3
N25365001: length 5
  TOP w0.102: v1(125.37,119.02) PQ2.3
  TOP w0.508: PQ2.3 123.76,119.47 123.25,119.98 121.62,119.98 PR5.2
N25369936: length 3
  TOP w0.102: Q21.1 71.63,17.37 71.84,17.59 71.84,18.3 71.66,18.48 R437.1 R433.2
N25369945: length 3.4
  TOP w0.102: R450.1 R449.2 74.97,16.95 73.91,15.9 Q21.4
N25430988: length 3.3
  BOTTOM w0.254: PR232.2 21.46,37.97 20.63,37.14 v1(20.46,37.14) 20,37.59 PQ23.3
N25430994: length 3.4
  BOTTOM w0.254: PR256.2 21.23,28.14 20.65,27.56 20.47,27.56 v1(20,27.09) 19.53,27.56 PQ28.3
N25431520: length 5.8
  BOTTOM w0.102: v1(17.44,35.34) 18.83,35.34 19.49,34.68 PQ25.3
  BOTTOM w0.254: PR238.2 20.26,34.67 19.81,34.22 PQ25.3
N25804343: length 2.3
  BOTTOM w0.102: v1(69.12,114.57) 69.23,114.57 69.67,114.12 PR138.2
  BOTTOM w0.254: PR136.2 70.24,114.91 PR138.2
N25817818: length 2.7
  TOP w0.381: PQ5.3 136.8,78.84 v1(137.27,79.31) PR39.2
N25817820: length 4.1
  TOP w0.102: v1(133.62,80) PR40.2
  TOP w0.381: 132.9,77.81 132.9,77.82 PQ6.3 ; PQ5.2 134.09,78.86 133.89,79.06 PR40.2 133.54,78.97 133.54,78.17
N25821251: length 1.4
  BOTTOM w0.559: PC172.1 PR156.2
N27752748: length 2.4
  BOTTOM w0.203: R694.1 196.69,35.36 196.81,35.24 196.81,34.86 196.69,34.74 R697.1 197.17,34.53 197.37,34.73 R695.2
N28087213:
  vias: v1(22.82,110.55) v1(25.59,112.38) v1(25.59,111.75) v1(26.63,112.13)
N28100067: length 1.8
  BOTTOM w0.102: R796.1 69.32,21.91 CN12.8
N28379472: length 6.2
  BOTTOM w0.102: PC146.1 v1(75.35,113.05)
  BOTTOM w0.254: PR137.1 72.99,113.65 74.16,113.65 74.48,113.32 PC146.1 74.41,113.05 73.63,112.27 PR139.1 73.14,112.27 73.13,112.27 72.18,112.27 PR140.2
N28379477: length 2.3
  TOP w0.102: PR27.1 v1(84.31,107.84)
  TOP w0.508: PR27.1 83.25,106.6 PC30.1
N28380796: length 4.1
  TOP w0.102: PR20.1 71.16,114.16 70.42,114.9 69.91,114.9 69.59,115.22 69.59,116.68 TP1.1
N28380828: length 2.8
  TOP w0.254: PR16.2 67.14,115.29 PR21.2 67.66,114.47 68.14,114.96 PC19.1
N28414264: length 16.5
  TOP w0.254: PU2.13 72.22,108.81 72.1,108.93 v2(72.1,108.95)
  IN1 w0.203: v2(72.1,108.95) 72.1,111.85 72.68,112.43 75.45,112.43 79.82,116.8 v1(79.82,116.83)
  BOTTOM w0.102: v1(72.35,110.37) PR142.1
  BOTTOM w0.254: PR142.1 71.66,109.57 71.63,109.54 71.63,109.42 v2(72.1,108.95)
  BOTTOM w0.381: PR133.1 79.5,116.49 79.82,116.8 v1(79.82,116.83)
N28607521: length 1.4
  TOP w0.254: PU2.22 76.97,111.03 77.01,111.07 PR25.1
N29093947: length 5.7
  TOP w0.102: v1(89.34,94.86) 89.28,94.91 Q8.2 87.62,94.91 87.05,94.34 R83.1 85.79,94.02 86.6,93.2 Q9.3
N30319022:
  vias: v1(137.43,76.34) v1(137.4,75.65) v1(137.37,74.84) v1(137.98,76.67) v1(137.98,76.03) v1(137.98,75.4) v1(138.62,76.47) v1(138.62,75.83) v1(139.28,76.47) v1(139.28,75.83) v1(139.91,76.47) v1(139.91,75.83) v1(140.63,76.47) v1(140.63,75.83) v1(141.57,76.62)
N30319317: length 19.7
  TOP w0.203: PR41.2 140.93,78.14 141.34,78.55 v1(143.17,78.55)
  IN2 w0.203: v1(143.17,78.55) 143.29,78.42 143.29,64.38 v1(142.86,63.94)
  BOTTOM w0.254: PC183.2 PR167.1 142.15,63.89 142.2,63.94 v1(142.86,63.94)
N30319351: length 2.2
  BOTTOM w0.508: PC171.2 138.37,70.91 138.95,71.49 139.09,71.49 PR154.1
N30442035:
  vias: v1(20.25,24.55)
N30442060: length 4.2
  TOP w0.102: PU6.4 24.67,27.42 PC93.1 25.3,28.05 26.48,28.05 26.94,27.6 PR93.1
N30442062: length 1.6
  TOP w0.203: PU6.12 20.39,27.02 20.13,26.76 PC98.1
N30442063: length 1.5
  TOP w0.102: PU6.10 19.83,27.82 PC92.1
N30442080: length 5.1
  TOP w0.102: PR89.2 26.99,28.89 v1(26.48,29.4) 25.68,29.4 PC87.1 24.84,28.3 24.29,27.75 23.71,27.75 23.64,27.82 PU6.5
N30442084: length 5.3
  TOP w0.102: v1(27.08,25.74) PR100.2 26.55,27.16 25.38,27.16 PC99.1 24.46,27.02 PU6.3
N30568314: length 7.5
  TOP w0.203: PR84.2 146.7,32.24 v1(147.08,32.63) 146.82,32.88 PR78.1 146.22,33.66 145.86,34.02 v2(145.86,34.5) 145.88,34.48 146.85,34.48 147.32,34.95 PC70.2
  BOTTOM w0.203: v2(145.86,34.5) 146.16,34.2 146.16,33.69 146.4,33.46 PU11.12
N30568326: length 2
  TOP w0.102: v1(148.4,35.39) 148.06,35.73 PC70.1
  TOP w0.508: PC70.1 PR72.1
N30568424: length 4.6
  BOTTOM w0.229: PU15.9 44.23,16.91 44.43,16.7 44.49,16.7 PR274.1 PR275.2 45.02,15.19 v1(45.02,14.2) 45.02,13.62 PC272.2
N30568429: length 1.9
  BOTTOM w0.102: PR278.1 v1(43,12.5)
  BOTTOM w0.229: PR278.1 43.05,13.37 PC272.1
N30568472: length 6.7
  TOP w0.102: v1(45.12,17.87) 44.67,17.42 44,17.42
  TOP w0.508: v1(41.7,17.37) PR117.1 43.31,17.42 44,17.42
  BOTTOM w0.203: v1(41.7,17.37) 42.79,17.37 PU15.12
  BOTTOM w0.381: v1(41.7,17.37) 41.34,17 PC266.1
N30568498: length 4
  TOP w0.254: PQ13.3 48.17,14.45 v1(48.17,13.6) 47.87,13.3 47,13.3 v1(46.76,13.54)
  BOTTOM w0.254: v1(46.76,13.54) 46.54,13.31 PR279.1
N30568535: length 6.4
  BOTTOM w0.102: PR234.2 145.32,38.21 v1(145.6,38.49)
  BOTTOM w0.203: PR244.2 143.32,34.68 143.7,35.06 PR237.1 144.08,36.1 144.26,36.1 144.56,36.41 144.56,37.68 144.72,37.84 PR234.2 144.72,38.98 PR230.1
N31069510:
  vias: v1(157.11,24.95)
N31161958: length 2.8
  TOP w0.203: PU7.4 154.85,28.59 v2(154.82,28.61)
  BOTTOM w0.203: v2(154.82,28.61) 154.82,28.51 155.31,28.03 PC251.1 PR260.2
N31161974: length 3
  TOP w0.203: PC111.1 155.46,23.94 v1(155.75,24.23) 155.25,24.73 PU7.12
N31161976: length 3
  TOP w0.203: PC110.1 154.62,23.24 154.62,24.07 v1(154.47,24.22) 154.62,24.37 154.62,25.01 154.45,25.18 PU7.10
N31162017: length 3
  TOP w0.203: PU7.5 154.45,28.2 154.24,28.41 v2(154.24,28.61)
  BOTTOM w0.203: v2(154.24,28.61) 154.1,28.61 PC250.1 152.94,27.88 152.87,27.95 PR259.2
N31162025: length 2.9
  TOP w0.203: v2(155.41,28.61) 155.41,28.51 155.25,28.35 PU7.3
  BOTTOM w0.203: v2(155.41,28.61) 155.54,28.61 PC252.1 156.4,28.01 PR257.1
N31353058:
  vias: v1(34.43,28.61)
N31353100: length 2.7
  TOP w0.102: PR79.2 39.63,32.84 v1(39.79,33.01)
  TOP w0.508: PR79.2 PC75.2
N33618596: length 2.4
  TOP w0.203: R495.2 26.51,6.95 26.88,7.33 v1(26.88,7.38) 26.88,7.68 26.4,8.16 Q27.3
N33761123: length 4.1
  TOP w0.102: R498.1 31.21,3.06 31.04,2.9 R501.1 30.26,2.65 v1(30.19,2.73) 30.16,2.75 30.16,2.98 v1(30.6,3.42)
  BOTTOM w0.102: CN18.38 v1(30.6,3.42)
N33761125: length 3.2
  TOP w0.102: R497.1 28.54,2.96 28.41,2.83 v1(28.41,2.78) 28.21,2.78 28.05,2.93 v1(28.05,3.39)
  BOTTOM w0.102: CN18.50 27.6,2.94 v1(28.05,3.39)
N33761127: length 11.2
  TOP w0.102: v1(18.58,3.97) 18.02,3.97 17.64,4.35 TP49.1
  BOTTOM w0.102: v1(18.58,3.97) 18.58,4.33 19.9,5.65 22.39,5.65 23.99,4.05 23.99,2.88 23.84,2.73 23.25,2.73 23.1,2.58 CN18.68
N35663361: length 7.4
  TOP w0.254: R265.2 107.43,41.39 107.26,41.23 U9.1 107.26,39.12 107.15,39 106.97,39 106.72,38.75 106.72,37.32 106.9,37.14 R288.2 106.9,35.06 R297.1
N35697678: length 3.1
  BOTTOM w0.102: R625.2 111.06,55.86 110.61,55.4 R627.1 110.61,54.18 110.28,53.86 U25.4
N35697684: length 16.3
  TOP w0.254: v1(114.31,65.75) 114.31,65.52 112.69,63.89 112.69,62.57 v1(112.61,62.5) 112.53,62.42 112.53,61.28 112.66,61.15 112.66,59.3 112.18,58.82 112.18,57.57 111.87,57.26 v1(111.54,57.26)
  BOTTOM w0.254: Q38.2 113.22,58.71 113.02,58.51 112.46,58.51 112.2,58.25 112.2,57.52 111.95,57.26 v1(111.54,57.26) 111.54,57.19 111.06,56.7 R625.1 ; v1(114.31,65.75) 114.02,66.03 C578.1 113.3,66.03 113.1,65.83 Q37.2
N35745518: length 1.5
  BOTTOM w0.178: PR218.1 PR217.1 138.04,46.79 137.84,46.99 PR211.2
N35745570: length 0.9
  BOTTOM w0.178: PR235.2 PC220.2
N35745574: length 1.1
  BOTTOM w0.203: PR229.1 142.05,40.53 PC213.2
N35849315: length 2.8
  BOTTOM w0.305: 98.4,51.09 99.99,52.69 99.99,53.26
N36191354: length 8.5
  TOP w0.254: v1(107.81,34.86) 107.73,34.86 107.38,34.51 R297.2 106.67,34.51 106.52,34.66 106.52,36.48 106.52,36.79 105.96,37.34 U9.4
  BOTTOM w0.254: v1(107.81,34.86) 107.83,34.89 107.83,35.14 108.6,35.9 108.6,36.01 108.87,36.28 109.31,36.28 109.66,36.64 U29.2
N36203385: length 3.4
  TOP w0.102: Q24.6 54.51,15.65 v1(54.16,15.99) 54.16,16.8 54.36,17 R454.1 55.14,17 55.35,16.78 R456.2
N36203387: length 5
  TOP w0.102: Q24.3 56.21,13.31 v1(55.99,13.09) 55.94,13.14 55.69,13.14 55.56,13.27 Q24.2 55.56,14.51 55.33,14.74 54.62,14.74 54.49,14.62 54.49,14.24 54.29,14.04 R474.1
N36208700: length 2.5
  BOTTOM w0.254: R628.1 113.76,54.98 114.02,55.24 Q39.3 114.32,55.52 114.5,55.7 114.5,56.01 114.34,56.17 Q39.2
N36208702: length 4.3
  BOTTOM w0.254: R621.1 112.63,57.88 112.63,57.36 112.42,57.15 Q39.6 111.85,56.82 111.64,56.62 111.64,55.54 111.06,54.95 R627.2
N36209325: length 7.4
  TOP w0.254: v1(108.14,36.44) 108.34,36.44 108.98,35.8 U10.4
  BOTTOM w0.203: R675.1 110.26,40.38 110.26,38.94 110.07,38.75 109.41,38.75 109.01,38.34 U29.1 109.01,37.06 108.39,36.44 v1(108.14,36.44)
N36446693: length 2.6
  TOP w0.102: Y1.3 44.07,111.95 C32.1 44.77,111.23 R15.2
N36953746: length 1.1
  TOP w0.102: v1(51.23,23.16) 50.92,22.85 C393.2
N36954805: length 3.4
  TOP w0.102: U16.7 67.25,17 v1(67.66,16.58) 68.4,15.85 R464.2
N36977514: length 7.2
  BOTTOM w0.102: Q44.3 198.13,20.94 198.13,20.26 198.05,20.17 197.58,20.17 197.05,19.65 196.51,19.65 v1(195.92,19.06) 195.92,17.85 R827.2 195.86,17.15 195.49,16.78 195.49,16.39 195.33,16.23 Q47.2
N37139396: length 1.1
  TOP w0.102: R423.1 130.56,20.09 130.47,20 D16.2
N37139525: length 3.3
  TOP w0.102: R458.2 121.85,16.75 v1(122.49,16.75) 122.79,16.75 123.09,17.05 U15.24
N37139527: length 2.6
  TOP w0.102: R417.2 121.56,21.84 121.96,21.44 121.96,21.1 122.39,20.67 122.39,20.33 122.51,20.21 U15.21
N37139529: length 5.1
  TOP w0.102: U15.19 122.58,21.21 122.41,21.37 122.41,21.63 122.19,21.86 122.19,22.94 121.73,23.4 120.84,23.4 R403.2 120.63,24.2 v1(120.46,24.37)
N37139539: length 3.5
  TOP w0.102: R400.2 122.18,23.76 v1(122.42,23.53) 122.42,21.95 122.66,21.71 U15.18
N37139543: length 2.9
  TOP w0.102: R412.2 121.7,22.47 121.96,22.21 121.96,21.76 122.19,21.54 122.19,21.2 122.67,20.71 U15.20
N37162665: length 5.3
  TOP w0.381: v1(212.13,34.38) 212.28,34.38 212.73,33.93 R313.2
  BOTTOM w0.381: v1(212.13,34.38) 212,34.25 L13.1 211.11,34.47 v1(211.11,35.24) 211.54,35.67 R690.2
N37162929: length 1
  TOP w0.102: TP41.1 209.31,27.37 R366.1
N37164012: length 3.9
  BOTTOM w0.203: U30.16 v1(199.18,31.63) 199.18,31.68 198.74,32.12 198.14,32.12 C638.1
N37164724: length 1
  BOTTOM w0.102: R707.2 196.02,33.21 196.17,33.36 R699.2
N37190310: length 10.5
  TOP w0.508: v1(35.9,121.27) 35.88,121.3 35.88,121.96 35.67,122.16 35.67,123.4 35.85,123.58 HE1.2
  BOTTOM w0.508: v1(35.9,121.27) 36.1,121.27 v1(36.83,120.55) 37.3,120.08 38.47,120.08 38.94,119.6 C508.1 40.04,120.01 D22.2 41.25,120.01 42.26,121.02 R507.2
N37352433: length 2.6
  TOP w0.102: PR10.1 76.93,117.39 v1(76.44,116.9)
  TOP w0.508: PR10.1 75.76,117.97 PC17.1
N37598035: length 2.7
  TOP w0.102: U3.4 v1(21.52,82.49) 21.52,82.87 20.98,83.42 R104.1
N37994586: length 2.1
  TOP w0.102: C170.2 28.89,87.46 29.21,87.14 R94.2 R95.2
N38144837: length 3
  BOTTOM w0.254: Q40.3 108.53,38.96 108.27,38.7 R688.1 108.44,38.31 109.18,39.05 Q40.2
N38144855: length 10.3
  TOP w0.203: v1(110.93,43.12) 110.93,42.81 110.78,42.66 110.76,42.66 110.37,42.28 106.97,42.28 106.61,41.92 v1(106.61,41.13) U9.2
  BOTTOM w0.203: Q40.6 109.83,41.53 110.04,41.74 110.55,41.74 110.86,42.05 R667.1 111.17,42.18 111.31,42.33 111.31,42.91 111.11,43.12 v1(110.93,43.12)
N38144913: length 5.1
  BOTTOM w0.203: U29.4 110.31,35.99 110.68,36.36 110.68,38.36 110.6,38.44 110.6,40.01 R680.1
N38517581: length 5.9
  TOP w0.381: D20.1 18.6,9.69 v1(18.3,9.38) 17.07,9.38 R490.2 15.95,9.76 14.82,8.62 14.58,8.62 R494.1
N38517589: length 2
  TOP w0.381: R490.1 15.55,10.54 15.36,10.72 Q26.2
N38517597: length 5.9
  TOP w0.508: v1(13.73,9.3) 13.75,9.32 13.93,9.32 13.93,9.32 Q26.3
  IN3 w0.508: v1(13.73,9.3) 14.49,10.06 14.49,11.37 16.42,13.29 16.42,13.29 v1(16.47,13.24)
  vias: v1(15.28,13.14)
N38517605: length 7.2
  TOP w0.356: R482.1 17.88,13.07 19.09,13.07 20.15,12 21.2,12 21.45,12.25 21.45,12.95 v1(21.87,13.37) Q22.3
N38517627: length 3.2
  TOP w0.102: R493.2 10.98,8.81 v1(10.98,9.04)
  TOP w0.381: Q30.3 12.58,6.7 11.73,7.55 R493.2
N38517632: length 1.2
  TOP w0.102: 21.47,17.3 21.54,17.3 21.83,17.59 22.36,17.59 v1(22.49,17.46)
N38517638: length 2.4
  TOP w0.381: Q30.2 11.84,4.14 11.62,3.92 C492.2 12.62,3.42 R499.2
N38521997: length 37.7
  TOP w0.102: R430.1 149.54,19.32 149.85,19.01 149.85,18.78 v2(149.87,18.76) 149.87,18.22 v1(149.52,17.87) 149.52,17.21 149.52,17.2 D18.1
  BOTTOM w0.102: CN10.1 175,19.73 174.95,19.68 174.95,18.97 174.38,18.4 170.32,18.4 170.14,18.57 170.14,19.26 169.81,19.59 169.4,19.59 169.18,19.37 169.18,19.11 168.78,18.71 168.63,18.71 168.29,19.06 168.29,19.34 168.03,19.6 167.33,19.6 167.1,19.82 165.82,19.82 165.68,19.68 165.68,18.67 164.15,17.13 164.15,16.65 163.15,15.66 150.56,15.66 149.85,16.37 149.85,18.73 v2(149.87,18.76)
N38680042: length 3.1
  BOTTOM w0.102: D34.1 D35.1 195.18,34.56 195.72,34.02 R699.1
N38680880: length 4.2
  TOP w0.102: R365.1 174.64,28.26 175.37,28.99 v1(175.37,30.31) 175.45,30.39 175.7,30.39 175.92,30.61 Q16.2
N38756738: length 6.6
  TOP w0.102: U13.82 199.79,22.58 200.32,23.11 v1(200.32,23.47) 200.83,23.99 C387.2 201.7,24.5 201.98,24.5 202.13,24.65 202.45,24.65 202.54,24.74 203.54,24.74 203.9,24.39 R402.1
N38756749: length 1.9
  TOP w0.102: U13.87 199.62,24.58 199.79,24.75 200.59,24.75 TP43.1
N38756787: length 3.8
  TOP w0.102: R318.1 196.62,31.89 C367.2 197.06,31.47 197.21,31.32 v1(197.21,31.18) 197.21,30.96 196.85,30.59 U13.98
N38756834: length 102.5
  TOP w0.102: v1(63.31,96.48) 63.32,96.5 Q7.3
  IN1 w0.089: v1(63.31,96.48) 63.28,96.48 62.86,96.06 62.1,96.06 61.53,96.63 56.58,96.63 56.35,96.86 55.41,96.86 54.72,96.18 54.04,96.18 53.24,96.98 51.47,96.98 49.09,94.6 45.05,94.6 44.01,95.63 31.69,95.63 27.73,91.67 27.73,88.53 26.76,87.55 26.76,85.18 25.9,84.32 25.9,74.27 26.92,73.26 27.37,73.26 27.97,72.66 27.97,68.56 26.2,66.79 26.2,65.42 25.8,65.02 25.8,62.7 26.41,62.09 26.41,57.92 25.56,57.07 25.56,51.14 v1(25.01,50.58)
  BOTTOM w0.102: v1(25.01,50.58) 24.55,51.05 24.55,51.6 24.83,51.88 24.83,54.98 22.79,57.01 20.89,57.01 v1(20.65,56.77) 19.64,56.77 19.39,57.01 R622.2 19.14,57.52 18.73,57.52 16.95,59.3 SW3.3 SW3.4
N38757336: length 3.7
  TOP w0.102: R310.1 183.48,31.88 C371.1 183.59,30.97 184.06,30.97 184.85,30.19 U13.128
N38757362: length 7.8
  TOP w0.102: R487.1 197.77,11.32 198.05,11.04 C480.2 198.55,11.66 199.2,12.31 199.2,13.19 199.83,13.83 v1(199.83,14.95) 199.83,16.08 199.73,16.18 U13.66
N38757406: length 11.8
  TOP w0.102: Q7.2 65.02,99.49 65.69,100.15 C112.1 65.69,100.41 66.34,101.07 v1(66.34,101.34) 66.41,101.41 v1(66.41,102.32) 66.41,102.65 66.56,102.81 R37.2
  BOTTOM w0.102: SW2.3 66.7,103.1 66.41,102.81 v1(66.41,102.32) 66.86,101.87 66.86,97.96 SW2.4
N38758998: length 1.3
  TOP w0.102: C389.2 179.37,22.81 R419.1
N38759178: length 1.8
  TOP w0.102: C388.1 181.88,23.48 182.08,23.68 182.33,23.68 182.43,23.78 U13.12
N39168858: length 16.9
  TOP w0.254: R111.2 R117.2 R121.2 R124.2 R138.2 R144.2 R153.2 R157.2 13.72,73.71 v1(13.4,73.39)
  BOTTOM w0.254: Q34.3 20.68,75.13 20.38,75.42 v1(19.85,75.42) 19.62,75.42 18.1,73.9 16.39,73.9 16.28,73.79 15.82,73.79 15.56,73.52 13.52,73.52 v1(13.4,73.39)
N39692582: length 3.1
  BOTTOM w0.203: R578.2 92.39,85.46 92.67,85.74 R574.1 92.67,86.17 92.32,86.52 R572.2 91.42,86.52 91.3,86.4 Q32.2
N39707880: length 1.5
  BOTTOM w0.102: R696.2 66.05,34.43 65.92,34.3 Y3.2
N39785725: length 4.5
  BOTTOM w0.102: R835.1 211.84,14.44 211.97,14.57 R834.1 212.28,15.23 v1(212.28,16.5) 212.53,16.75 213.04,16.75 213.47,16.32 HD1.1
N40437801: length 10.5
  BOTTOM w0.102: U22.V7 98.79,107.43 98.11,107.43 97.98,107.3 97.98,106.79 97.85,106.67 95.77,106.67 95.52,106.41 95.52,105.14 95.31,104.94 92.11,104.94 91.65,105.4 TP57.1
N40437812: length 10.2
  BOTTOM w0.102: TP55.1 92.42,108.29 98.73,108.29 U22.W7
N40437815: length 7.6
  BOTTOM w0.102: TP56.1 91.68,107.48 97.7,107.48 98.07,107.85 U22.W6
N40437818: length 10.2
  BOTTOM w0.102: U22.Y6 98.37,108.81 97.98,109.21 97.98,109.71 97.75,109.94 91.53,109.94 90.26,111.21 TP54.1
N40911013: length 4.8
  BOTTOM w0.127: VRAM2.J13 133.41,93.21 133.03,93.59 133.03,94.22 132.4,94.86 v1(132.4,96.46) 132.4,96.88 R530.2
N40911015: length 4.5
  BOTTOM w0.102: R523.2 v1(132.79,103.16) 133.01,103.38 133.01,106.2 VRAM1.J13
N43700942: length 2.6
  BOTTOM w0.102: R517.2 55.97,105.09 55.92,105.14 55.92,105.17 55.06,106.03 55.06,106.37 55.35,106.66 CN2.24
N43737419: length 1.8
  BOTTOM w0.102: CN2.29 57.85,105.98 58.05,105.78 R516.2
N44885066: length 3.6
  TOP w0.254: PD4.3 128.35,31.84 PR81.2 v1(130.78,32.88)
N45198823:
  vias: v1(59.23,125.59) v1(59.96,125.59)
N45477665: length 3.5
  TOP w0.508: v1(55.04,109.4) 55.05,109.41 55.05,110.21 55.05,110.22 Q2.2 55.38,110.21 C37.2 R14.2
N45672179: length 7.8
  BOTTOM w0.079: 93.66,29.2 93.66,29.58 93.07,30.17 93.07,30.82 92.52,31.36 92.52,31.39 92.3,31.62 92.3,32.12 92.07,32.34 92.07,32.42 92.05,32.44 92.05,32.72 91.98,32.87 91.98,33.1 92.01,33.13 92.01,33.39 91.59,33.81 U24.DU14
  BOTTOM w0.102: 93.66,29.2 93.66,28.1 93.76,28 93.76,27.57 93.79,27.55 R764.1
N45773643: length 4
  TOP w0.102: R188.2 110.81,67.27 v1(110.31,66.77) 110.31,67.11 109.75,67.67 R187.2 109.35,67.61 Q12.1
N45773665: length 2.3
  TOP w0.102: R188.1 111.52,67.74 v1(111.77,67.74) Q11.2
N45774339: length 2.7
  TOP w0.102: R320.2 193.49,31.47 193.97,31 194.47,31 194.85,30.63 U13.103
N45774342: length 2.1
  TOP w0.102: U13.102 195.25,30.61 194.38,31.47 R321.2
N45774345: length 1.8
  TOP w0.102: U13.101 195.65,30.77 195.21,31.2 R322.2
N45774348: length 2.8
  TOP w0.102: U13.105 194.05,30.56 193.55,31.06 192.99,31.06 192.57,31.47 R319.2
N47271970:
  vias: v1(95.03,88.12)
N47273600: length 4
  TOP w0.102: PR113.1 101.51,21.22 101.71,21.42 v1(102.22,21.42) 102.22,21.32 101.87,20.97 101.87,20.36 101.99,20.23 v2(101.99,20.18)
  BOTTOM w0.102: PJ11.5 101.45,20.77 101.99,20.23 v2(101.99,20.18)
N47273609: length 7.6
  TOP w0.381: PR120.1 102.62,14.72
  TOP w0.508: 102.62,14.72 v1(103.41,15.51) 103.41,16.94 v1(103.45,16.98)
  BOTTOM w0.508: PJ11.4 v1(103.45,16.98)
N47273625: length 7.1
  TOP w0.381: 105.78,16.24 106.11,15.91 PR119.1
  TOP w0.508: 105.78,16.24 v1(105.11,16.24) 104.58,16.77 104.58,16.83 v1(104.43,16.98)
  BOTTOM w0.508: PJ11.3 105.45,20.77 104.39,19.71 104.39,17.02 v1(104.43,16.98)
N48434117: length 6.1
  TOP w0.102: C127.2 v1(103.97,97.24)
  TOP w0.381: L5.2 104.96,99.18 104.96,98.74 105.18,98.52 C135.2 104.71,98.31 104.62,98.22 C127.2 103.4,98.22 103.33,98.15 C133.2 102.78,97.67 v2(102.93,97.52)
  BOTTOM w0.381: v2(102.93,97.52) 102.93,97.45 U22.F11
N48587681: length 1.3
  TOP w0.254: v2(97.97,103.29) 98.53,103.29 R42.1
  BOTTOM w0.254: v2(97.97,103.29) 98.36,102.89 U22.N6
N48650493: length 5.2
  TOP w0.102: R1.1 101.46,125.02 v1(100.53,125.02) 100.13,124.61 R2.1 99.76,124.44 Q1.2
N49263752: length 7.4
  BOTTOM w0.203: 105.86,88.04 105.52,87.69 v1(104.51,87.69) 104.13,87.69 103.3,88.51 R565.2 ; 105.86,88.04 R566.2 ; 105.86,88.04 107.28,88.04 107.64,88.4 R567.2 R568.1
N59038271: length 2.7
  BOTTOM w0.102: R717.2 R716.1 67.09,29.79 C649.1 66.44,29.15 v1(66.44,28.76)
N60242660: length 1
  TOP w0.508: R48.1 C125.2
N453702120: length 2
  TOP w0.102: TP46.1 190.31,12.69 190.85,13.22 U13.48
N3707465495: length 5.4
  TOP w0.076: U8.T7 32.59,39.88 32.04,39.33 31.71,39.33 31.43,39.61 v1(31.43,40.43) 31.43,40.62
  TOP w0.102: R264.2 31.43,40.62
N3707518295: length 4.3
  TOP w0.076: 31.43,52.82 31.63,52.61 32.12,52.61 32.83,53.33 33.71,53.33 34.01,53.03 U6.T7
  TOP w0.102: 31.43,52.82 30.68,52.82 R209.2
N3707546095: length 5.4
  TOP w0.076: R165.2 30.6,73.22 31.61,72.21 v1(32.21,72.21) 32.21,72.72 32.74,73.25 33.73,73.25 34.05,72.93 U4.T7
N3707585895: length 6.1
  TOP w0.076: U2.T7 34.27,86.68 33.89,87.06 33.29,87.06 32.7,86.47 32.7,85.97 v1(32.45,85.72) 32.07,85.33 30.8,85.33 30.41,84.95 R99.2
N4537377412: length 2.4
  TOP w0.102: TP40.1 180.81,26.98 U13.4

## Copper pours and planes (outline as drawn)
1V8_AON_S on TOP (solid shape): 25.46,98.33 25.46,94.21 25.46,94.18 25.38,94.09 25.36,93.99 25.35,93.89 25.34,93.84 25.35,93.8 25.35,93.75 25.35,93.72 25.21,93.59 24.57,93.59 24.06,94.09 23.98,94.09 23.96,94.1 23.9,94.16 23.84,94.17 23.69,94.17 23.65,94.18 23.64,94.22 23.64,94.94 23.44,94.94 23.44,94.22 23.43,94.18 23.39,94.17 23.29,94.17 23.25,94.18 23.24,94.22 23.24,94.94 23.23,94.94 23.19,94.96 23.18,94.99 23.18,95.24 24.19,96.25 24.19,98.61 24.34,98.77 25.03,98.77
+1.2V_VCCPLL_OC_S2 on TOP (solid shape): 49.34,33.18 49.34,32.5 48.86,32.02 48.86,31.13 48.37,30.64 48.37,30.09 48.3,30.01 47.2,30.01 46.87,30.34 46.87,30.92 47.31,31.36 47.31,32.07 47.66,32.42 47.66,33.06 47.97,33.36 49.16,33.36
+1.2VSUS on TOP (solid shape): 47.74,96.35 47.74,95.44 47.36,95.06 45.43,95.06 45.38,95.11 44.94,95.11 44.44,95.62 44.44,96.2 44.64,96.4 47.69,96.4
+1.2VSUS on TOP (solid shape): 54.18,123.79 55.25,123.79 56.89,122.15 56.89,120.75 56.95,120.68 56.95,120.64 57.25,120.34 60.07,120.34 60.31,120.09 60.31,119.17 60.16,119.01 55.59,119.01 55.38,119.21 52.33,119.21 50.91,120.64 46.59,120.64 46.44,120.79 46.44,121.25 46.75,121.55 49.59,121.55 49.67,121.63 49.67,122.67 50.91,122.67 51.12,122.88 51.12,124.37 51.27,124.52 53.44,124.52
+1.2VSUS on TOP (solid shape): outline of 8459 points within 34.48,34.28 82.74,93.84
+1.2VSUS on BOTTOM (solid shape): 57.21,123.94 57.21,120.26 56.96,120 55.05,120 52.51,117.46 47.05,117.46 46.32,118.2 46.32,121.17 46.73,121.59 49.78,121.59 49.84,121.65 49.84,123.18 50.73,124.07 57.08,124.07
+1.2VSUS on BOTTOM (solid shape): outline of 333 points within 79.03,53.73 81.75,71.54
+1.2VSUS on BOTTOM (solid shape): outline of 178 points within 59.68,54.49 71.86,97.67
+1.2VSUS on BOTTOM (solid shape): outline of 14532 points within 20,34.51 48.98,101.46
+1.2VSUS on IN1 (solid shape): outline of 4233 points within 62.42,53.1 85.58,96.25
+1.2VSUS on IN2 (solid shape): outline of 2449 points within 62.29,55.49 84.9,95.36
+1.2VSUS on SVCC (solid shape): 51.62,121.28 51.62,110.07 51.37,109.97 51.27,109.71 51.37,109.46 51.62,109.36 51.62,108.17 48.04,104.59 48.02,104.59 47.77,104.49 47.66,104.23 47.66,104.21 45.67,102.22 45.64,102.22 45.39,102.12 45.28,101.87 45.28,101.83 45.02,101.56 44.96,101.58 44.89,101.59 44.64,101.48 44.54,101.23 44.54,101.17 44.56,101.1 43.01,99.55 28.26,99.55 28.16,99.53 28.08,99.48 22.56,93.97 18.46,93.97 18.35,94.07 18.35,99.01 25.63,106.28 37.15,106.28 37.54,106.36 37.87,106.59 39.89,108.61 40.11,108.94 40.19,109.33 40.19,113.52 40.19,113.59 40.18,113.66 42.74,116.22 42.78,116.22 43.04,116.32 43.14,116.57 43.14,116.62 43.93,117.41 43.98,117.49 44,117.59 44,123.07 44.31,123.38 48.36,123.38 48.6,123.39 48.82,123.43 49.47,123.43
+1.5V on TOP (solid shape): 169.35,24.12 169.34,24.06 169.34,24.03 169.37,23.88 169.45,23.77 169.45,23.31 169.47,23.29 169.47,22.91 169.4,22.85 167.6,22.85 167.37,23.07 167.37,24.24 167.63,24.5 168.97,24.5
+1.5V on BOTTOM (solid shape): 167.61,24.37 167.69,24.34 167.71,24.26 167.71,24.25 167.71,23.91 167.75,23.82 167.84,23.78 168.22,23.78 168.29,23.8 168.34,23.86 168.35,23.87 168.44,23.97 168.73,23.97 168.86,23.87 169.01,23.83 169.02,23.83 169.16,23.86 169.28,23.94 169.35,23.94 169.48,23.75 169.7,23.67 169.73,23.67 169.73,22.47 169.61,22.34 168.97,22.34 168.72,22.59 167.7,22.59 167.57,22.47 167.57,21.96 167.45,21.83 166.91,21.83 166.84,21.85 166.77,21.86 166.74,21.86 166.67,21.85 166.6,21.83 166.48,21.83 166.05,22.26 166.05,23.48 166.1,23.53 166.34,23.64 166.43,23.89 166.42,23.98 166.38,24.07 166.36,24.1 166.33,24.14 166.33,24.2 166.31,24.31 166.4,24.37
+1.05V_LAN on TOP (solid shape): 41.59,113.78 41.21,113.4 40.32,113.4 40.19,113.52 40.19,113.85 39.94,114.11 39.94,114.29 39.43,114.79 39.43,115.94 39.5,116 41.59,116
+1.05V_LAN on TOP (solid shape): 49.47,108.06 49.72,108.06 49.83,107.95 49.83,107.4 49.46,107.03 49.46,106.39 49.19,106.11 48.91,106.11 48.53,105.72 47.53,105.72 47.35,105.9 46.24,105.9 46.24,106.04 46.24,106.07 46.26,106.1 46.61,106.1 46.61,106.09 47.95,106.09 48.63,106.77 48.63,107.99 48.7,108.06 49.46,108.06
+1.05V_LAN on TOP (solid shape): 40.65,106.18 40.75,106.18 40.76,106.17 40.93,106.13 41.1,106.17 41.11,106.18 41.96,106.18 42.04,106.1 43.02,106.1 43.03,106.09 43.03,105.91 43.02,105.9 41.88,105.9 41.73,105.75 38.95,105.75 38.77,105.57 38.77,103.01 38.97,102.81 40.85,102.81 42.01,103.97 42.01,104.06 42.05,104.1 43.03,104.1 43.08,104.05 43.08,103.88 43.05,103.86 43.01,103.86 42.68,103.53 42.68,103.2 42.44,102.96 42.38,102.97 42.34,102.97 42.09,102.87 41.98,102.61 41.99,102.58 42,102.52 41.44,101.96 40.05,101.96 39.98,102.03 38.88,102.03 38.81,101.96 38.12,101.96 37.68,102.4 37.68,106.06 37.91,106.29 39.61,106.29 39.74,106.41 40.42,106.41
+1.05V_LAN on BOTTOM (solid shape): outline of 781 points within 37.65,102.09 50.48,115.35
+1.05V_LAN_REGOUT on TOP (solid shape): 47.76,108.86 47.76,107 47.46,106.7 46.25,106.7 46.23,106.73 46.23,106.87 46.45,107.09 46.56,107.09 47.43,107.96 47.43,108.75 47.61,108.93 47.69,108.93
+1.05V_LAN_REGOUT on TOP (solid shape): 43.67,115.38 44.21,115.38 44.23,115.38 44.94,115.38 45.15,115.18 45.15,114.29 45.05,114.19 44.99,114.19 44.96,114.17 44.54,114.17 44.51,114.18 43.62,114.18 43.59,114.17 42.34,114.17 42.1,114.41 42.1,115.84 42.23,115.96 43.09,115.96
+1.05V_LAN_REGOUT on IN1 (solid shape): outline of 294 points within 42.61,108.06 48.18,115.43
+1.8V on IN3 (solid shape): 124.62,17.87 124.62,16.9 124.45,16.73 124.42,16.73 124.3,16.7 124.2,16.64 124.13,16.61 123.84,16.73 123.54,16.61 123.48,16.64 123.19,16.72 122.96,16.54 122.85,16.54 122.79,16.6 122.79,17.26 123.55,18.02 124.47,18.02
