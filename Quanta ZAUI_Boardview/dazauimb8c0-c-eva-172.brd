# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_ALERT#: length 122.1
  TOP w0.076: U8.P9 35.87,37.95 v1(35.62,37.71) ; U4.P9 35.49,70.96 35.18,70.96 33.8,69.58 v1(32.88,69.58) ; v1(33.11,82.64) 33.44,82.97 33.89,82.97 35.18,84.26 35.49,84.26 U2.P9 ; v1(32.6,50.13) 34.25,50.13 35.18,51.06 35.49,51.06 U6.P9
  TOP w0.127: R112.1 33.08,81.27 33.4,81.58 v1(33.4,81.99) 33.4,82.35 v1(33.11,82.64)
  IN1 w0.089: v1(33.11,82.64) 33.29,82.47 33.29,80.07 33.44,79.91 33.44,78.59 32.64,77.79 32.64,76.05 32.55,75.96 32.55,75.19 32.17,74.8 32.17,74.04 32.47,73.75 32.47,72.23 32.73,71.97 32.73,71.84 32.83,71.74 32.93,71.74 33.06,71.61 33.06,71.43 32.98,71.35 32.8,71.35 32.73,71.27 32.73,71.16 32.8,71.08 32.98,71.08 33.06,71 33.06,70.89 32.98,70.82 32.8,70.82 32.73,70.74 32.73,70.63 32.8,70.55 32.98,70.55 33.06,70.47 33.06,69.96 32.88,69.79 v1(32.88,69.58) 32.88,69.32 32.9,69.29 32.9,60.5 33.44,59.96 33.44,59.05 32.64,58.25 32.64,56.14 32.55,56.06 32.55,55.34 32.45,55.23 32.26,55.23 32.17,55.14 32.17,54.14 32.55,53.75 32.55,52.32 32.73,52.14 32.73,51.13 32.51,50.92 32.51,50.72 32.78,50.46 32.78,50.3 v1(32.6,50.13) 32.78,49.95 32.78,48.16 32.95,47.98 32.95,46.13 33.15,45.94 33.15,45.34 32.85,45.05 32.85,39.13 33.23,38.75 34.58,38.75 v1(35.62,37.71)
  IN3 w0.102: v2(69.84,78.68) 69.81,78.68 69.73,78.75 59.99,78.75 57.68,76.44 52.04,76.44 50.95,75.35 50.95,74.73 50.35,74.13 50.35,73.37 49.85,72.86 49.85,72.46 47.04,69.65 45.37,69.65 44.57,68.85 41.2,68.85 39.89,70.15 39.89,72.73 38.67,73.95 38.67,78.22 34.24,82.64 v1(33.11,82.64)
  BOTTOM w0.079: v2(69.84,78.68) 70.12,78.68 72.07,76.73 72.07,76.31 72.43,75.96 73.12,75.96 73.28,75.79 74.22,75.79 U24.M49
M_B_BG#0: length 151.9
  TOP w0.076: v1(36.26,46.6) 37.05,45.8 37.05,44.1 37.27,43.88 U8.M2 ; U6.M2 37.47,57.3 37.07,57.69 37.07,58.79 v1(36.21,59.65) ; U2.M2 37.47,90.5 37.07,90.9 37.07,91.98 37.4,92.31 v1(37.4,92.95) 37.4,93.56 v1(37.87,94.03) 38.29,94.45 R75.2 ; v1(36.21,79.55) 36.93,79.55 37.31,79.17 37.31,78.31 37.07,78.07 37.07,77.6 37.47,77.2 U4.M2
  IN1 w0.089: v1(36.26,46.6) 36.57,46.91 36.57,49.14 35.62,50.09 35.62,52.53 35.74,52.66 35.74,54.22 35.45,54.52 35.45,55.36 36.14,56.04 36.14,57.65 36.66,58.17 36.66,61.13 36.59,61.2 36.46,61.2 36.38,61.12 36.38,59.83 v1(36.21,59.65) 36.05,59.81 36.05,62.9 36.41,63.25 36.41,68.17 35.65,68.92 35.65,72.47 35.74,72.56 35.74,74.16 35.45,74.46 35.45,75.26 36.14,75.95 36.14,76.94 36.75,77.55 36.75,79.22 36.42,79.55 v1(36.21,79.55) 36,79.76 36,80.95 35.83,81.12 35.83,85.56 36.56,86.29 36.56,90.66 37.3,91.4 37.3,91.58 37.78,92.06 37.78,92.19 37.65,92.32 37.4,92.32 37.27,92.44 37.27,92.82 v1(37.4,92.95)
  IN3 w0.102: v1(36.26,46.6) 35.55,46.6 35.38,46.76 35.38,47.14 35.47,47.23 35.58,47.23 35.67,47.32 35.67,47.45 35.58,47.53 35.47,47.53 35.38,47.62 35.38,47.75 35.47,47.84 35.58,47.84 35.67,47.93 35.67,48.06 35.58,48.14 35.47,48.14 35.38,48.23 35.38,49.2 35.16,49.42 33.57,49.42 33.34,49.66 33.34,51.85 33.69,52.21 33.69,54.09 33.84,54.24 33.84,55.16 35.16,56.48 35.16,56.74 37.21,58.79 37.21,58.91 36.63,59.49 36.63,59.62 36.72,59.71 36.85,59.71 37.42,59.13 37.55,59.13 37.64,59.22 37.64,59.34 37.26,59.72 37.26,59.84 37.35,59.93 37.48,59.93 37.85,59.56 37.98,59.56 38.07,59.65 38.07,59.77 37.7,60.15 37.7,60.28 37.79,60.37 37.91,60.37 38.29,59.99 38.41,59.99 38.5,60.08 38.5,60.21 38.13,60.58 38.13,60.71 38.22,60.8 38.34,60.8 38.72,60.42 38.84,60.42 38.93,60.51 38.93,60.64 38.56,61.01 38.56,61.14 38.65,61.23 38.77,61.23 39.15,60.85 39.27,60.85 39.36,60.94 39.36,61.07 38.99,61.44 38.99,61.57 39.08,61.66 39.2,61.66 39.58,61.28 39.71,61.28 39.8,61.37 39.8,61.5 39.42,61.88 39.42,62 39.51,62.09 39.64,62.09 40.01,61.72 40.14,61.72 40.46,62.04 40.84,62.04 40.92,62.11 40.92,62.58 40.98,62.65 41.13,62.65 41.22,62.56 41.22,62.1 41.29,62.04 41.44,62.04 41.52,62.13 41.52,62.56 41.61,62.65 41.74,62.65 41.83,62.56 41.83,62.13 41.92,62.04 42.05,62.04 42.13,62.13 42.13,62.56 42.22,62.65 42.35,62.65 42.44,62.56 42.44,62.13 42.53,62.04 42.65,62.04 42.74,62.13 42.74,62.56 42.83,62.65 42.96,62.65 43.05,62.56 43.05,62.13 43.14,62.04 43.26,62.04 43.35,62.13 43.35,62.56 43.44,62.65 43.57,62.65 43.66,62.56 43.66,62.13 43.75,62.04 43.87,62.04 43.96,62.13 43.96,62.56 44.05,62.65 44.18,62.65 44.27,62.56 44.27,62.13 44.36,62.04 44.48,62.04 44.57,62.13 44.57,62.56 44.66,62.65 44.79,62.65 44.88,62.56 44.88,62.13 44.97,62.04 45.09,62.04 45.18,62.13 45.18,62.56 45.27,62.65 45.4,62.65 45.49,62.56 45.49,62.13 45.58,62.04 45.7,62.04 45.79,62.13 45.79,62.56 45.88,62.65 46.01,62.65 46.1,62.56 46.1,62.13 46.19,62.04 47.54,62.04 50.38,64.87 50.38,65.34 51.7,66.66 54.47,66.66 54.68,66.87 54.68,68.04 55.35,68.71 57.68,68.71 62.2,73.23 64.96,73.23 65.57,73.84 67.64,73.84 68.21,74.41 69.2,74.41 69.74,74.94 v2(71.14,74.94)
  BOTTOM w0.076: 75.84,74.17 76.05,74.38 U24.R45
  BOTTOM w0.079: 75.84,74.17 75.77,74.09 75,74.09 74.7,74.06 74.45,73.95 74.11,73.95 73.89,74.17 73.67,74.17 73.58,74.26 73.35,74.26 73.18,74.09 72.27,74.09 71.42,74.94 v2(71.14,74.94)
M_B_BG#1: length 78
  TOP w0.127: R267.1 29.5,40.5 29.42,40.58 v2(29.02,40.58)
  IN3 w0.102: v2(69.34,78.03) 69.12,78.24 60.2,78.24 57.89,75.93 54.9,75.93 53.12,74.15 51.39,74.15 50.96,73.73 50.96,73.21 50.43,72.68 50.43,72.32 46.45,68.34 38.17,68.34 35.6,65.77 34.29,65.77 27,58.48 27,43.3 29.02,41.28 v2(29.02,40.58)
  BOTTOM w0.076: 74.99,75.16 U24.N47
  BOTTOM w0.079: v2(69.34,78.03) 69.59,78.03 69.91,77.71 70.44,77.71 71.72,76.44 71.72,76.18 72.3,75.6 73,75.6 73.14,75.46 73.91,75.46 74.11,75.26 74.48,75.26 74.51,75.28 74.76,75.28 74.99,75.16
M_B_BG#1_R: length 91
  TOP w0.076: U2.M9 37.53,84.57 37.53,83.93 ; U8.M9 37.05,38.7 32.22,38.7 32.07,38.85 31.61,38.85 ; 37.14,49.8 37.47,50.13 U6.M9
  TOP w0.102: 34.1,69.33 34.5,69.73 37.18,69.73 37.6,70.15 37.6,71.2 U4.M9
  TOP w0.127: 37.14,49.8 36.99,49.64 33.34,49.64 v1(31.11,47.42) ; v1(30.69,67.3) 32.52,69.12 33.89,69.12 34.1,69.33 ; 31.61,38.85 31.3,38.85 30.92,39.23 30.54,39.23 30.14,39.64 v2(30.14,39.94) 30.55,40.36 R267.2 ; R139.2 R120.1 29.18,79.84 30.67,79.84 v1(31.18,80.35) 31.48,80.66 33.1,80.66 35.5,83.06 37.29,83.06 37.53,83.3 37.53,83.93
  IN1 w0.089: v1(31.18,80.35) 31.12,80.29 31.12,77.14 30.52,76.54 30.52,67.47 v1(30.69,67.3) 31,66.99 31,61.32 31.25,61.07 31.25,60.08 31.12,59.95 31.12,57.25 30.31,56.44 30.31,51.47 30.93,50.85 30.93,47.6 v1(31.11,47.42) 31.3,47.23 31.3,46.24 31.22,46.15 31.08,46.15 31,46.07 31,45.95 31.08,45.86 31.22,45.86 31.3,45.78 31.3,45.65 31.22,45.57 31.08,45.57 31,45.48 31,45.36 31.08,45.28 31.22,45.28 31.3,45.19 31.3,43.55 30.86,43.11 30.17,43.11 30.08,43.02 30.08,42.9 30.17,42.82 30.86,42.82 30.95,42.73 30.95,42.61 30.86,42.53 30.17,42.53 30.08,42.44 30.08,42.32 30.17,42.23 30.86,42.23 30.95,42.15 30.95,42.03 30.86,41.94 30.17,41.94 30.08,41.86 30.08,41.74 30.17,41.65 30.86,41.65 30.95,41.56 30.95,41.44 30.86,41.36 30.17,41.36 30.08,41.27 30.08,41.15 30.17,41.07 30.86,41.07 30.95,40.98 30.95,39.61 30.8,39.46 30.39,39.46 30.14,39.71 v2(30.14,39.94)
M_B_BS#0: length 149.5
  TOP w0.076: U8.N2 36.67,44.14 36.19,44.62 36.19,44.84 35.83,45.2 35.83,46.93 36.1,47.2 v1(36.1,47.21) ; R74.2 37.32,94.02 36.89,93.59 36.89,93.03 36.1,92.24 v1(36.1,91.56) 36.23,91.43 36.23,90.67 36.67,90.23 U2.N2 ; v1(36.1,58.36) 36.28,58.18 36.28,56.63 36.36,56.55 36.61,56.55 36.67,56.61 U6.N2 ; U4.N2 36.51,76.77 36.51,76.67 36.59,76.59 36.59,76.5 36.33,76.24 36.21,76.24 35.98,76.47 35.98,76.59 36.19,76.8 36.19,77.06 36.28,77.15 36.41,77.15 36.51,77.25 36.51,77.35 36.43,77.43 36.26,77.43 36.19,77.5 36.19,77.72 36.29,77.82 36.29,78.07 v1(36.1,78.26)
  IN1 w0.089: v1(36.1,47.21) 36.28,47.39 36.28,47.69 36.18,47.79 35.32,47.79 35.24,47.87 35.24,48.02 35.33,48.1 36.23,48.1 36.3,48.18 36.3,48.31 36.22,48.4 35.33,48.4 35.24,48.49 35.24,48.61 35.33,48.7 35.56,48.7 35.65,48.79 35.65,48.91 35.56,49 35.17,49 35.08,49.09 35.08,49.22 35.16,49.31 35.71,49.31 35.8,49.4 35.8,49.53 35.72,49.61 35.16,49.61 35.08,49.7 35.08,49.82 35.16,49.91 35.27,49.91 35.36,50 35.36,50.17 35.27,50.26 35.17,50.26 35.08,50.35 35.08,50.55 35.16,50.64 35.26,50.64 35.35,50.73 35.35,50.91 35.19,51.07 35.19,51.22 35.37,51.4 35.37,52.64 35.49,52.76 35.49,54.12 35.2,54.41 35.2,55.46 35.88,56.15 35.88,57.1 35.73,57.25 35.73,57.44 35.88,57.59 35.88,57.8 35.73,57.95 35.73,58.26 35.83,58.36 v1(36.1,58.36) 35.73,58.73 35.73,60.11 35.79,60.18 35.79,66.16 35.37,66.58 35.37,72.54 35.49,72.66 35.49,74.06 35.2,74.35 35.2,75.36 35.88,76.05 35.88,77.04 36.5,77.66 36.5,77.86 v1(36.1,78.26) 35.73,78.63 35.73,80.86 35.58,81.02 35.58,85.67 36.3,86.39 36.3,90.96 36.76,91.43 36.76,91.55 36.53,91.79 36.33,91.79 v1(36.1,91.56)
  IN3 w0.102: v2(79.69,74.03) 79.23,74.48 78.22,74.48 77.77,74.93 73.08,74.93 72.76,74.61 72.37,74.61 72.2,74.43 72.2,74.23 72.12,74.15 71.98,74.15 71.89,74.24 71.89,74.93 71.8,75.02 71.67,75.02 71.58,74.93 71.58,74.24 71.49,74.15 71.37,74.15 71.28,74.24 71.28,74.42 71.19,74.51 71.06,74.51 70.97,74.42 70.97,74.24 70.88,74.15 70.76,74.15 70.67,74.24 70.67,74.52 70.58,74.61 70.45,74.61 70.36,74.52 70.36,74.24 70.27,74.15 70.15,74.15 70.06,74.24 70.06,74.52 69.97,74.61 69.84,74.61 69.75,74.52 69.75,74.24 69.66,74.15 68.34,74.15 67.77,73.58 65.7,73.58 65.09,72.97 62.3,72.97 57.78,68.45 55.47,68.45 54.93,67.91 54.93,66.74 54.6,66.41 51.8,66.41 50.63,65.24 50.63,64.77 47.65,61.78 40.57,61.78 35.42,56.64 35.42,56.28 35.13,55.99 35.13,55.68 35.02,55.57 34.61,55.57 34.1,55.06 34.1,54.14 33.95,53.99 33.95,53.42 34.03,53.33 34.57,53.33 34.66,53.24 34.66,53.11 34.57,53.02 34.03,53.02 33.95,52.94 33.95,52.81 34.03,52.72 34.57,52.72 34.66,52.63 34.66,52.5 34.57,52.41 34.03,52.41 33.95,52.33 33.95,52.2 34.03,52.11 34.57,52.11 34.66,52.02 34.66,51.89 34.57,51.81 33.68,51.81 33.59,51.72 33.59,51.59 33.68,51.5 34.57,51.5 34.66,51.41 34.66,51.28 34.57,51.2 33.68,51.2 33.59,51.11 33.59,50.98 33.68,50.89 34.57,50.89 34.66,50.8 34.66,50.68 34.57,50.59 33.68,50.59 33.59,50.5 33.59,50.37 33.68,50.28 35.01,50.28 35.09,50.19 35.09,50.07 35.01,49.98 33.68,49.98 33.59,49.89 33.59,49.76 33.68,49.67 35.42,49.67 35.63,49.45 35.63,48.63 36.1,48.16 v1(36.1,47.21)
  BOTTOM w0.079: v2(79.69,74.03) 79.95,73.77 U24.T38
M_B_BS#1: length 153.9
  TOP w0.076: v1(37.07,70.28) 36.26,71.09 36.26,71.65 36.67,72.07 U4.N8 ; 36.64,83.93 36.26,84.31 36.26,84.95 36.67,85.37 U2.N8 ; v1(31.74,83.43) 31.25,83.43 v1(30.89,83.06) 29.92,82.09 R109.2 ; v1(37.07,50.37) 36.26,51.19 36.26,51.75 36.67,52.16 U6.N8 ; v1(36.3,39.48) 36.67,39.12 U8.N8
  TOP w0.127: v1(37.02,83.55) 36.64,83.93
  IN1 w0.089: v1(36.3,39.48) 36.3,38.17 36.46,38.01 37.37,38.01 37.46,38.09 37.46,41.88 36.89,42.45 36.89,44.87 38.04,46.01 38.16,46.01 38.29,46.14 38.29,49.28 37.7,49.87 37.7,50.23 37.56,50.37 v1(37.07,50.37) 36.64,50.8 36.64,52.12 36.76,52.23 36.76,54.49 37.06,54.79 37.06,55.28 37.36,55.57 37.36,56.29 37.67,56.61 37.67,65.81 37.46,66.03 37.46,69.89 v1(37.07,70.28) 36.67,70.68 36.67,72.04 36.76,72.14 36.76,74.39 37.06,74.69 37.06,75.21 37.36,75.5 37.36,75.71 37.77,76.12 37.77,83.26 37.48,83.55 v1(37.02,83.55)
  IN3 w0.089: v1(37.02,83.55) 36.99,83.58 31.96,83.58 31.81,83.43 v1(31.74,83.43)
  IN3 w0.102: v1(36.3,39.48) 35.88,39.06 35.88,38.24 36.12,38 37.16,38 37.27,38.11 37.27,38.21 37.18,38.3 36.27,38.3 36.18,38.39 36.18,38.52 36.27,38.61 37.18,38.61 37.27,38.7 37.27,38.82 37.18,38.91 36.68,38.91 36.59,39 36.59,39.13 36.68,39.22 37.18,39.22 37.27,39.31 37.27,42.04 36.69,42.63 36.69,44.94 35.13,46.5 35.13,48.94 34.91,49.16 33.47,49.16 33.08,49.55 33.08,50.45 33.01,50.53 32.74,50.53 32.67,50.61 32.67,50.76 32.75,50.84 32.98,50.84 33.08,50.94 33.08,51.04 32.98,51.14 32.75,51.14 32.67,51.22 32.67,51.37 32.75,51.45 33,51.45 33.08,51.53 33.08,51.68 33.01,51.75 32.73,51.75 32.67,51.81 32.67,53.42 32.75,53.5 33.35,53.5 33.44,53.59 33.44,53.72 33.35,53.81 32.75,53.81 32.67,53.89 32.67,54.03 32.75,54.11 33.34,54.11 33.54,54.32 33.54,55.22 34.28,55.95 34.28,56.8 35,57.53 35.13,57.53 35.28,57.37 35.4,57.37 35.49,57.46 35.49,57.59 35.34,57.74 35.34,57.87 35.7,58.22 35.7,59.72 36.04,60.06 37.12,60.06 39.96,62.9 48.05,62.9 50.13,64.98 50.13,65.45 52.19,67.51 53.69,67.51 55.73,69.56 58.17,69.56 62.12,73.51 64.85,73.51 65.43,74.09 67.52,74.09 68.15,74.71 69.15,74.71 69.76,75.32 71.94,75.32 72.39,74.87 72.75,74.87 73.12,75.24 76.27,75.24 76.38,75.12 78.19,75.12 v2(78.34,74.97)
  BOTTOM w0.076: v2(78.34,74.97) 78.29,74.92 78.29,73.89 U24.T42
M_B_CAS#: length 152.8
  TOP w0.076: U2.M8 v1(37.07,85.03) ; v1(37.78,36.92) 37.81,36.94 37.81,38.7 37.47,39.03 U8.M8 ; v1(31.71,84.06) 31.25,84.06 30.19,82.99 R108.2 ; v1(37.07,51.83) 37.78,51.83 37.86,51.9 37.86,52.11 37.73,52.23 U6.M8 ; U4.M8 37.61,72 37.73,72 37.86,72.12 37.86,72.32 37.7,72.48 37.25,72.48 37.07,72.3 v1(37.07,71.73)
  IN1 w0.089: v1(37.78,36.92) 38.21,37.35 38.21,38.58 38.3,38.66 38.48,38.66 38.57,38.75 38.57,38.87 38.48,38.95 38.3,38.95 38.21,39.04 38.21,39.66 37.84,40.03 37.84,41.07 37.71,41.2 37.71,42.24 37.15,42.81 37.15,44.76 38.14,45.76 38.44,45.76 38.54,45.86 38.54,49.39 37.96,49.97 37.96,51.45 37.58,51.83 v1(37.07,51.83) 37.01,51.88 37.01,54.38 37.32,54.68 37.32,55.17 37.61,55.46 37.61,55.99 38.02,56.41 38.02,59.35 38.6,59.93 38.6,65.25 37.71,66.13 37.71,71.09 v1(37.07,71.73) 37.01,71.79 37.01,74.28 37.32,74.59 37.32,75.11 37.61,75.4 37.61,75.6 38.02,76.02 38.02,84.33 37.32,85.03 v1(37.07,85.03)
  IN3 w0.089: v1(31.71,84.06) 31.76,84.01 36.05,84.01 v1(37.07,85.03)
  IN3 w0.102: v1(37.78,36.92) 37.81,36.95 37.81,37.43 37.9,37.52 38.19,37.52 38.28,37.61 38.28,37.74 38.19,37.83 37.9,37.83 37.81,37.92 37.81,38.04 37.9,38.13 38.33,38.13 38.42,38.22 38.42,38.35 38.33,38.44 37.9,38.44 37.81,38.52 37.81,38.65 37.9,38.74 38.78,38.74 38.87,38.83 38.87,38.96 38.78,39.05 37.9,39.05 37.81,39.13 37.81,39.26 37.9,39.35 38.78,39.35 38.86,39.44 38.86,39.57 38.77,39.65 37.9,39.65 37.81,39.74 37.81,39.87 37.9,39.96 38.78,39.96 38.86,40.05 38.86,40.17 38.77,40.26 37.9,40.26 37.81,40.35 37.81,41.04 37.93,41.16 38.44,41.16 38.67,41.39 38.67,41.72 37.45,42.94 37.45,49.87 37.35,49.97 36.9,49.97 36.61,50.26 36.61,52.75 36.52,52.84 35.98,52.84 35.89,52.93 35.89,53.06 35.98,53.15 36.52,53.15 36.61,53.23 36.61,53.36 36.52,53.45 35.98,53.45 35.89,53.54 35.89,53.67 35.98,53.76 36.52,53.76 36.61,53.84 36.61,53.97 36.52,54.06 35.98,54.06 35.89,54.15 35.89,54.28 35.98,54.36 36.52,54.36 36.61,54.45 36.61,56.75 40.55,60.69 40.93,60.69 41.22,60.4 45.93,60.4 46.56,61.02 47.97,61.02 51.4,64.45 51.4,64.92 52.09,65.62 54.9,65.62 56.23,66.95 57.4,66.95 62.65,72.2 65.44,72.2 66.06,72.82 68.15,72.82 68.72,73.39 72.65,73.39 73.1,73.85 73.1,74.14 73.32,74.36 77.53,74.36 78.55,73.35 78.55,72.88 78.66,72.77 78.66,72.62 v2(78.29,72.25)
  BOTTOM w0.079: U24.Y42 78.29,72.06 v2(78.29,72.25)
M_B_CKE0: length 142.1
  TOP w0.076: U2.K2 39.07,89.91 39.15,89.83 v1(39.47,89.83) ; U8.K2 v1(38.67,44.28) ; U6.K2 v1(39.47,57.43) ; U4.K2 39.07,76.58 39.41,76.24 39.52,76.24 39.73,76.45 39.73,76.54 39.43,76.85 39.43,77.29 v1(39.47,77.33) ; R79.2 42.15,94.1 41.51,93.46 40.47,93.46 v1(39.94,92.92)
  IN1 w0.089: v1(39.47,89.83) 39.47,89.97 39.89,90.38 39.89,90.56 39.99,90.66 40.14,90.66 40.24,90.56 40.24,90.01 40.35,89.91 40.46,89.91 40.55,89.83 40.55,89.71 40.46,89.62 39.91,89.62 39.82,89.53 39.82,89.41 39.91,89.33 40.46,89.33 40.55,89.24 40.55,89.12 40.46,89.04 39.8,89.04 39.66,88.9 39.66,87.46 39.51,87.32 39.51,86.62 39.94,86.19 39.94,84.57 39.57,84.19 39.57,82.05 40.17,81.45 40.17,78.03 v1(39.47,77.33) 39.93,76.87 39.93,75.4 38.28,73.75 38.28,73.07 38.37,72.99 38.82,72.99 38.98,72.83 38.98,69.09 39.79,68.27 39.79,66.65 39.87,66.58 39.87,59.24 39.47,58.85 v1(39.47,57.43) 39.7,57.43 40.11,57.02 40.11,55.68 38.28,53.85 38.28,52.93 39.81,51.4 39.81,45.1 39,44.28 v1(38.67,44.28)
  IN3 w0.089: v1(39.47,89.83) 38.8,90.51 38.8,91.78 v1(39.94,92.92)
  IN3 w0.102: v1(38.67,44.28) 39.06,44.67 39.06,44.93 38.97,45.02 38.56,45.02 38.47,45.11 38.47,45.23 38.56,45.32 38.97,45.32 39.06,45.41 39.06,45.54 38.97,45.63 38.56,45.63 38.47,45.72 38.47,45.84 38.56,45.93 38.97,45.93 39.06,46.02 39.06,46.15 38.97,46.24 38.56,46.24 38.47,46.33 38.47,46.45 38.56,46.54 38.97,46.54 39.06,46.63 39.06,46.76 38.97,46.85 38.56,46.85 38.47,46.94 38.47,47.06 38.56,47.15 38.97,47.15 39.06,47.24 39.06,47.37 38.97,47.46 38.56,47.46 38.47,47.54 38.47,47.67 38.56,47.76 38.97,47.76 39.06,47.85 39.06,47.98 38.97,48.07 38.56,48.07 38.47,48.15 38.47,48.28 38.56,48.37 38.97,48.37 39.06,48.46 39.06,48.59 38.97,48.67 38.56,48.67 38.47,48.76 38.47,48.89 38.56,48.98 38.97,48.98 39.06,49.07 39.06,49.2 38.97,49.28 38.56,49.28 38.47,49.37 38.47,49.5 38.56,49.59 38.97,49.59 39.06,49.68 39.06,49.8 38.97,49.89 38.56,49.89 38.47,49.98 38.47,50.11 38.56,50.2 38.97,50.2 39.06,50.29 39.06,50.41 38.97,50.5 38.56,50.5 38.47,50.59 38.47,50.72 38.56,50.81 38.97,50.81 39.06,50.9 39.06,51.02 38.97,51.11 38.56,51.11 38.47,51.2 38.47,51.33 38.56,51.42 38.97,51.42 39.06,51.51 39.06,51.63 38.97,51.72 38.56,51.72 38.47,51.81 38.47,51.94 38.56,52.03 38.97,52.03 39.06,52.12 39.06,53.63 39.58,54.14 39.58,55.1 39.03,55.65 39.03,57.59 39.27,57.84 39.7,57.84 40.65,58.79 45.83,58.79 45.92,58.88 45.92,59.29 46.01,59.38 46.14,59.38 46.23,59.29 46.23,58.88 46.32,58.79 46.44,58.79 46.53,58.88 46.53,59.29 46.62,59.38 46.75,59.38 46.84,59.29 46.84,58.88 46.92,58.79 47.05,58.79 47.14,58.88 47.14,59.29 47.23,59.38 47.36,59.38 47.45,59.29 47.45,58.88 47.53,58.79 48.98,58.79 49.36,59.17 49.36,60.97 52.21,63.82 53.74,63.82 53.91,63.98 56.35,63.98 57.75,65.37 57.75,65.86 63.03,71.14 65.88,71.14 66.53,71.79 68.64,71.79 69.23,72.38 69.7,72.38 69.79,72.29 69.79,71.96 69.88,71.87 73.57,71.87 73.7,72 73.7,72.14 v2(73.21,72.63)
  BOTTOM w0.076: v2(73.21,72.63) 73.61,73.02 73.88,73.02 74.02,72.88 74.86,72.88 74.99,72.76 75.75,72.76 76.13,73.13 U24.U45
M_B_CLKN0: length 157.1
  TOP w0.076: v1(39.47,52.63) 38.69,52.63 38.59,52.54 38.59,52.28 38.65,52.23 U6.K8 ; U4.K8 39.07,72.38 39.15,72.45 39.41,72.45 39.56,72.6 39.56,73.26 39.43,73.38 39.43,73.65 39.54,73.75 39.8,73.75 v1(40.03,73.52) ; U2.K8 39.07,85.67 39.12,85.72 39.37,85.72 39.55,85.91 39.55,87.43 39.9,87.78 40.03,87.78 v1(40.32,87.49) ; U8.K8 39.07,39.4 39.13,39.46 39.39,39.46 39.55,39.62 39.55,40.87 39.88,41.19 40.21,41.19 40.27,41.13 v1(40.27,40.93)
  TOP w0.102: R95.1 30.03,86.31 30.44,86.31 C176.1 31,86.41 31.68,86.41 v1(31.68,86.41)
  IN1 w0.089: v1(40.32,87.49) 40.55,87.72 40.71,87.72 40.83,87.6 40.83,87.28 40.4,86.85 40.4,82.32 40.65,82.07 40.65,78.05 40.4,77.79 40.4,75.37 39.36,74.33 39.36,73.92 39.56,73.71 39.84,73.71 v1(40.03,73.52) 40.25,73.75 40.36,73.75 40.47,73.63 40.47,73.16 40.04,72.73 40.04,70.26 40.91,69.4 40.91,69.12 40.35,68.57 40.35,67.85 40.7,67.5 40.7,58 40.46,57.76 40.46,55.4 38.77,53.71 38.77,53.18 38.99,52.95 39.15,52.95 v1(39.47,52.63) 39.75,52.91 40.23,52.91 40.37,52.76 40.37,52.44 40.68,52.13 40.68,49.95 41.08,49.54 41.08,47.03 41.41,46.7 42.74,46.7 42.82,46.61 42.82,46.22 42.73,46.13 41.13,46.13 40.88,45.88 40.88,45.01 40.47,44.6 40.47,42.98 39.66,42.17 39.66,41.54 39.91,41.29 40.15,41.29 40.27,41.17 v1(40.27,40.93)
  IN3 w0.089: v2(64.7,70.6) 64.5,70.39 63.26,70.39 62.93,70.06 62.93,69.68 62.78,69.53 62.27,69.53 61.99,69.25 61.99,68.74 61.68,68.44 61.18,68.44 60.89,68.15 60.89,67.65 60.73,67.49 60.23,67.49 59.88,67.14 59.88,66.63 59.63,66.38 59.14,66.38 58.58,65.82 58.58,65.51 59.07,65.03 59.07,64.63 58.99,64.55 58.84,64.55 58.46,64.94 58.18,64.94 57.86,64.61 57.86,64.34 58.46,63.74 58.46,63.64 58.23,63.41 58.08,63.41 57.5,63.99 57.23,63.99 56.9,63.66 56.9,63.39 57.59,62.7 57.59,62.53 57.46,62.39 57.19,62.39 56.55,63.03 56.28,63.03 55.64,62.4 55.13,62.4 55.03,62.5 55.03,62.77 54.77,63.03 54.27,63.03 53.97,62.74 53.97,62.08 53.85,61.95 53.56,61.95 53.47,62.04 53.47,63.01 53.28,63.21 52.82,63.21 52.62,63.01 52.62,62.04 52.53,61.95 51.76,61.95 51.55,61.73 51.55,61.12 51.44,61.01 51.31,61.01 50.95,61.37 50.63,61.37 50.35,61.1 50.35,60.77 50.71,60.41 50.71,60.29 49.97,59.54 49.97,58.52 49.62,58.18 48.35,58.18 48.16,57.98 48.16,57.33 48.07,57.24 47.75,57.24 47.66,57.33 47.66,57.98 47.47,58.18 47.03,58.18 46.67,57.82 46.37,57.82 46.01,58.18 40.89,58.18 40.18,57.47 40.18,52.7 39.68,52.2 39.68,48.9 39.87,48.71 40.94,48.71 41.03,48.62 41.03,48.3 40.94,48.21 39.87,48.21 39.68,48.02 39.68,41.5 39.84,41.34 40.3,41.34 40.4,41.24 40.4,41.06 v1(40.27,40.93) ; v1(31.68,86.41) 31.91,86.64 32.03,86.64 32.32,86.35 32.32,86.09 33.08,85.33 36,85.33 37.02,86.35 38.42,86.35 39.78,87.71 40.1,87.71 v1(40.32,87.49)
  BOTTOM w0.079: U24.Y48 74.97,71.72 74.91,71.65 74.48,71.65 74.45,71.62 74.18,71.62 74.06,71.74 72.83,71.74 71.4,73.18 67.68,73.18 67.2,72.69 67.12,72.69
  BOTTOM w0.102: v2(64.7,70.6) 65.15,71.04 65.15,71.31 66.53,72.69 67.12,72.69
M_B_CLKP0: length 157.2
  TOP w0.076: U8.K7 39.07,39.72 39.16,39.63 39.32,39.63 39.39,39.69 39.39,40.94 39.81,41.36 40.22,41.36 40.27,41.41 v1(40.27,41.77) ; U4.K7 39.07,72.69 39.15,72.62 39.34,72.62 39.39,72.67 39.39,73.19 39.27,73.32 39.27,73.71 39.47,73.91 39.79,73.91 v1(40.03,74.15) ; U6.K7 38.66,53.03 38.59,53.1 38.59,53.35 38.67,53.43 v1(39.47,53.43) ; v1(40.32,88.12) 40.14,87.95 39.84,87.95 39.39,87.5 39.39,85.98 39.3,85.89 39.13,85.89 39.07,85.95 U2.K7
  TOP w0.102: R94.1 29.99,86.57 30.38,86.57 C176.2 30.86,86.68 31.31,86.68 v1(31.68,87.05)
  IN1 w0.089: v1(40.32,88.12) 40.52,87.92 40.79,87.92 41.03,87.68 41.03,87.19 40.6,86.76 40.6,82.41 40.85,82.16 40.85,77.96 40.6,77.71 40.6,75.32 39.53,74.26 39.53,73.99 39.63,73.89 39.76,73.89 v1(40.03,74.15) 40.25,73.93 40.43,73.93 40.65,73.71 40.65,73.09 40.22,72.66 40.22,70.34 41.08,69.47 41.08,69.05 40.52,68.49 40.52,67.93 40.88,67.57 40.88,57.93 40.64,57.68 40.64,55.33 38.94,53.64 38.94,53.25 39.07,53.13 39.17,53.13 v1(39.47,53.43) 39.82,53.08 40.3,53.08 40.55,52.84 40.55,52.51 40.85,52.21 40.85,50.02 41.26,49.62 41.26,47.1 41.49,46.87 42.81,46.87 43,46.68 43,46.15 42.8,45.95 41.2,45.95 41.06,45.81 41.06,44.94 40.65,44.53 40.65,42.91 39.84,42.09 39.84,41.61 39.99,41.46 40.2,41.46 40.27,41.53 v1(40.27,41.77)
  IN3 w0.089: v1(40.27,41.77) 40.27,41.62 40.17,41.52 39.91,41.52 39.86,41.57 39.86,47.95 39.95,48.04 41.02,48.04 41.21,48.23 41.21,48.69 41.02,48.89 39.95,48.89 39.86,48.98 39.86,52.13 40.36,52.63 40.36,57.39 40.96,58 45.94,58 46.29,57.64 46.75,57.64 47.1,58 47.4,58 47.49,57.91 47.49,57.25 47.68,57.06 48.14,57.06 48.34,57.25 48.34,57.91 48.43,58 49.7,58 50.14,58.45 50.14,59.47 50.89,60.21 50.89,60.48 50.53,60.85 50.53,61.02 50.7,61.2 50.88,61.2 51.24,60.84 51.51,60.84 51.73,61.05 51.73,61.66 51.84,61.77 52.61,61.77 52.8,61.97 52.8,62.94 52.89,63.03 53.21,63.03 53.3,62.94 53.3,61.97 53.49,61.77 53.92,61.77 54.15,62 54.15,62.66 54.34,62.85 54.7,62.85 54.85,62.7 54.85,62.42 55.05,62.22 55.72,62.22 56.35,62.86 56.48,62.86 57.12,62.22 57.53,62.22 57.77,62.45 57.77,62.77 57.08,63.46 57.08,63.58 57.31,63.81 57.43,63.81 58.01,63.23 58.3,63.23 58.63,63.56 58.63,63.81 58.03,64.41 58.03,64.54 58.26,64.76 58.38,64.76 58.77,64.38 59.07,64.38 59.24,64.55 59.24,65.11 58.76,65.59 58.76,65.75 59.22,66.2 59.7,66.2 60.06,66.56 60.06,67.06 60.3,67.31 60.8,67.31 61.07,67.58 61.07,68.08 61.25,68.26 61.76,68.26 62.16,68.67 62.16,69.17 62.35,69.35 62.85,69.35 63.1,69.61 63.1,69.99 63.33,70.22 64.85,70.22 65.16,70.52 v2(65.34,70.52) ; v1(40.32,88.12) 40.1,87.9 39.7,87.9 38.34,86.54 36.94,86.54 35.92,85.52 33.16,85.52 32.51,86.17 32.51,86.43 32.11,86.83 31.91,86.83 v1(31.68,87.05)
  BOTTOM w0.079: 67.12,72.5 67.24,72.5 67.75,73.01 71.33,73.01 72.76,71.57 73.99,71.57 74.11,71.45 74.52,71.45 74.55,71.49 75.16,71.49 75.54,71.87 U24.Y47
  BOTTOM w0.102: 67.12,72.5 66.61,72.5 65.34,71.23 v2(65.34,70.52)
M_B_CS#0: length 153.4
  TOP w0.076: v1(38.03,54.93) 38.47,54.49 38.47,53.83 38.27,53.64 U6.L7 ; v1(38.29,40.75) 38.06,40.75 37.91,40.61 37.91,40.47 38.12,40.26 38.51,40.26 38.76,40.51 38.76,40.85 38.86,40.96 38.96,40.96 39.06,40.85 39.06,40.41 38.53,39.88 U8.L7 ; R77.2 40.22,94.5 v1(38.67,92.95) ; U2.L7 38.27,86.54 37.7,87.11 37.7,88.02 37.91,88.23 38.16,88.23 38.37,88.02 v1(38.37,87.62) ; v1(38.03,74.83) 38.13,74.74 38.72,74.74 38.82,74.64 38.82,74.52 38.76,74.46 38.43,74.46 38.34,74.37 38.34,74.24 38.4,74.18 38.73,74.18 38.82,74.09 38.82,73.98 38.75,73.9 38.42,73.9 38.27,73.75 U4.L7
  IN1 w0.089: v1(38.37,87.62) 38.53,87.45 38.53,83.86 38.62,83.78 38.67,83.78 38.75,83.69 38.75,83.57 38.67,83.49 38.62,83.49 38.53,83.4 38.53,83.28 38.62,83.19 38.67,83.19 38.75,83.11 38.75,82.99 38.67,82.9 38.62,82.9 38.53,82.82 38.53,82.69 38.62,82.61 38.67,82.61 38.75,82.52 38.75,82.4 38.67,82.32 38.62,82.32 38.53,82.23 38.53,82.11 38.62,82.02 38.67,82.02 38.75,81.94 38.75,81.82 38.67,81.73 38.62,81.73 38.53,81.65 38.53,81.53 38.62,81.44 39.01,81.44 39.09,81.35 39.09,81.23 39.01,81.15 38.62,81.15 38.53,81.06 38.53,80.94 38.62,80.86 39.32,80.86 39.41,80.77 39.41,80.65 39.32,80.56 38.62,80.56 38.53,80.48 38.53,80.36 38.62,80.27 39.01,80.27 39.09,80.19 39.09,80.07 39.01,79.98 38.62,79.98 38.53,79.89 38.53,79.77 38.62,79.69 38.67,79.69 38.75,79.6 38.75,77.94 38.53,77.72 38.53,75.32 v1(38.03,74.83) 38.03,74.59 37.52,74.07 37.52,72.52 38.22,71.82 38.22,68.2 38.32,68.1 38.89,68.1 38.97,68.02 38.97,67.9 38.89,67.81 38.31,67.81 38.22,67.72 38.22,67.59 38.3,67.52 38.95,67.52 39.03,67.44 39.03,65.95 39.1,65.87 39.1,59.6 38.53,59.03 38.53,55.42 v1(38.03,54.93) 38.03,54.68 37.52,54.17 37.52,52.61 39.05,51.09 39.05,45.45 38.84,45.24 38.34,45.24 37.65,44.55 37.65,43.06 38.87,41.85 38.87,41.03 38.59,40.75 v1(38.29,40.75)
  IN3 w0.089: v1(38.37,87.62) 38.77,88.02 38.77,89.04 37.72,90.09 37.72,90.11 37.4,90.43 37.4,91.68 v1(38.67,92.95)
  IN3 w0.102: v1(38.29,40.75) 38.64,40.75 39.13,40.27 39.13,37.73 39.23,37.63 39.43,37.63 39.53,37.73 39.53,40.47 38.92,41.08 38.92,41.83 37.7,43.05 37.7,51.88 36.87,52.72 36.87,55.86 37.53,56.52 37.53,57.31 40.37,60.15 46.04,60.15 46.66,60.77 48.08,60.77 51.65,64.34 51.65,64.82 52.2,65.37 56.49,65.37 56.98,65.86 56.98,66.17 62.74,71.93 65.54,71.93 66.18,72.57 68.27,72.57 68.84,73.14 72.66,73.14 72.95,73.43 73.54,73.43 74.28,74.17 76.25,74.17 76.82,73.6 77.13,73.6 77.58,73.14 v2(78.17,73.14)
  BOTTOM w0.079: U24.V42 78,72.97 v2(78.17,73.14)
M_B_DIM0_ODT0: length 145.7
  TOP w0.076: v1(39.3,92.95) 40.11,93.75 40.75,93.75 40.88,93.88 v1(40.88,94.02) 41.18,94.32 R78.2 ; v1(39.46,56.6) 39.08,56.23 U6.K3 ; U8.K3 38.81,43.08 38.66,42.92 v1(38.66,42.67) ; U4.K3 38.7,76.51 38.7,78.14 v1(39.47,78.92) ; U2.K3 39.04,89.43 38.67,89.81 v1(38.67,89.83)
  IN1 w0.089: v1(38.66,42.67) 37.99,43.34 37.99,44.53 38.43,44.97 38.93,44.97 39.3,45.35 39.3,51.19 37.78,52.72 37.78,54.06 39.03,55.31 39.03,56.17 v1(39.46,56.6) 39.33,56.6 38.81,57.12 38.81,58.93 39.36,59.48 39.36,65.97 39.29,66.05 39.29,68.06 38.47,68.87 38.47,71.93 37.78,72.62 37.78,73.97 38.78,74.98 38.78,77.61 39.47,78.29 v1(39.47,78.92) 39.66,79.11 39.66,81.24 39.06,81.84 39.06,84.46 38.78,84.74 38.78,85.31 38.96,85.49 38.96,88.43 38.78,88.61 38.78,89.03 38.16,89.65 38.16,90.28 38.3,90.43 38.3,92.29 38.45,92.44 38.8,92.44 38.92,92.32 38.92,90.08 v1(38.67,89.83)
  IN3 w0.089: v1(39.3,92.95) 38.42,92.06 38.42,90.08 v1(38.67,89.83)
  IN3 w0.102: v1(38.66,42.67) 38.44,42.67 37.96,43.15 37.96,52.46 37.86,52.56 37.38,52.56 37.29,52.65 37.29,52.78 37.38,52.87 37.87,52.87 37.95,52.95 37.95,53.08 37.86,53.17 37.21,53.17 37.12,53.26 37.12,53.39 37.21,53.48 37.86,53.48 37.95,53.57 37.95,53.69 37.86,53.78 37.21,53.78 37.12,53.87 37.12,54 37.21,54.09 37.86,54.09 37.95,54.18 37.95,54.32 37.87,54.39 37.2,54.39 37.12,54.47 37.12,54.61 37.21,54.7 37.51,54.7 37.6,54.79 37.6,54.91 37.51,55 37.21,55 37.12,55.09 37.12,55.22 37.21,55.31 37.51,55.31 37.6,55.4 37.6,55.54 37.53,55.61 37.3,55.61 37.2,55.71 37.2,55.82 37.3,55.92 37.6,55.92 37.81,56.12 38.24,56.12 38.34,56.22 38.34,56.4 38.25,56.49 37.87,56.49 37.78,56.58 37.78,56.7 37.87,56.79 38.25,56.79 38.34,56.88 38.34,57.09 38.21,57.21 38.21,57.63 39.52,58.94 39.64,58.94 39.8,58.78 39.92,58.78 40.01,58.87 40.01,59 39.86,59.15 39.86,59.28 39.95,59.37 40.08,59.37 40.23,59.22 40.36,59.22 40.45,59.3 40.45,59.43 40.29,59.59 40.29,59.71 40.47,59.89 46.69,59.89 46.78,59.98 46.78,60.35 46.87,60.44 47,60.44 47.09,60.35 47.09,59.98 47.17,59.89 47.3,59.89 47.39,59.98 47.39,60.35 47.48,60.44 47.61,60.44 47.7,60.35 47.7,59.98 47.78,59.89 47.91,59.89 48,59.98 48,60.35 48.09,60.44 48.22,60.44 48.3,60.35 48.3,59.98 48.39,59.89 48.66,59.89 48.83,60.06 48.83,61.16 52,64.32 52.34,64.32 52.51,64.49 56.14,64.49 57.24,65.59 57.24,66.07 62.83,71.66 65.64,71.66 66.29,72.31 68.4,72.31 68.97,72.88 72.68,72.88 73.03,73.24 74.62,73.24 74.71,73.33 74.71,73.48 74.8,73.57 74.92,73.57 75.01,73.48 75.01,73.33 75.1,73.24 75.23,73.24 75.32,73.33 75.32,73.48 75.41,73.57 75.53,73.57 75.62,73.47 75.62,73.33 75.71,73.24 76.4,73.24 76.88,72.76 77.1,72.76 v2(77.61,72.25)
  BOTTOM w0.076: U24.V43 77.35,72.51 v2(77.61,72.25)
M_B_DQ0: length 54.7
  TOP w0.102: U8.F7 v1(41.87,40.28)
  IN3 w0.089: v1(41.87,40.28) 41.87,40.74 42.7,41.57 43.79,41.57 44.26,42.04 46.57,42.04 46.96,42.43 48.21,42.43 50.59,44.81 56.68,44.81 58.82,46.95 58.82,47.52 63.88,52.58 64.17,52.58 66.06,54.47 69.28,54.47 69.57,54.76 69.57,55.87 69.48,55.96 68.97,55.96 68.88,56.05 68.88,56.23 68.97,56.32 69.48,56.32 69.57,56.41 69.57,56.59 69.48,56.67 68.97,56.67 68.88,56.76 68.88,56.94 68.97,57.03 69.48,57.03 69.57,57.12 69.57,57.3 69.48,57.39 68.97,57.39 68.88,57.47 68.88,57.65 68.97,57.74 69.47,57.74 71.9,60.17 71.9,60.86 72.24,61.2 72.24,63.91 72.71,64.38 72.71,65.47 v2(71.97,66.2)
  BOTTOM w0.079: v2(71.97,66.2) 72.48,66.72 74.05,66.72 74.13,66.63 74.43,66.63 74.88,66.86 U24.AK48
M_B_DQ1: length 55
  TOP w0.102: U8.J7 v1(40.27,40.28)
  IN3 w0.089: v2(70.85,66.2) 70.85,65.87 71.14,65.59 71.14,65.21 70.5,64.57 69.87,64.57 69.38,64.08 69.38,63.84 69.19,63.66 69.19,63.2 69.41,62.99 69.41,58.87 68.77,58.23 68.36,58.23 66.19,56.07 64.89,56.07 64.25,55.43 64.25,53.46 63.86,53.07 63.69,53.07 58.34,47.72 58.34,47.18 56.45,45.29 50.39,45.29 48.01,42.91 46.7,42.91 46.3,42.52 43.92,42.52 43.55,42.15 42.33,42.15 40.46,40.28 v1(40.27,40.28)
  BOTTOM w0.079: v2(70.85,66.2) 71.68,67.03 71.68,67.64 71.99,67.95 73.55,67.95 73.65,67.86 73.94,67.86 74.07,67.73 75.3,67.73 75.49,67.77 76.09,67.77 76.27,67.59 U24.AK45
M_B_DQ2: length 53.4
  TOP w0.102: U8.H7 v1(41.07,40.28)
  IN3 w0.089: v1(41.07,40.28) 42.65,41.86 43.67,41.86 44.09,42.28 46.47,42.28 46.86,42.67 48.11,42.67 50.49,45.05 56.58,45.05 58.58,47.05 58.58,47.62 63.78,52.82 64.03,52.82 66.18,54.97 67.37,54.97 67.5,55.1 67.5,55.74 67.65,55.89 68.56,55.89 68.64,55.97 68.64,56.17 68.56,56.25 67.31,56.25 67.22,56.34 67.22,56.51 67.31,56.6 68.43,56.6 68.64,56.82 68.64,57.76 69.65,58.77 69.65,61.07 71.99,63.41 71.99,64.17 72.45,64.63 72.45,65.01 71.41,66.05 v2(71.41,66.2)
  BOTTOM w0.076: v2(71.41,66.2) 72.09,66.88 74.3,66.88 U24.AK49
M_B_DQ3: length 54.2
  TOP w0.102: v1(41.08,42.02) 40.93,42.02 U8.J3
  IN3 w0.089: v2(66.23,62.48) 66.23,61.68 64.83,60.28 64.83,59.34 61.79,56.3 61.79,54.33 59.48,52.02 59.23,52.02 56.17,48.96 56.17,48.22 55.78,47.83 49.8,47.83 48.87,46.91 41.92,46.91 41.46,47.36 41.15,47.36 40.86,47.07 40.86,45.17 40.67,44.98 40.67,44.79 40.45,44.57 40.45,42.65 v1(41.08,42.02)
  BOTTOM w0.079: U24.AG47 75.27,67.94 75.14,67.89 74.14,67.89 74.01,68.02 73.72,68.02 73.62,68.12 71.9,68.12 71.46,67.68 71.46,67.46 68.38,64.38 68.38,63.75 67.1,62.48 66.48,62.48
  BOTTOM w0.102: 66.48,62.48 v2(66.23,62.48)
M_B_DQ4: length 54.9
  TOP w0.102: U8.H8 v1(41.07,39.48)
  IN3 w0.089: v2(72.54,66.2) 72.54,66.19 72.96,65.77 72.96,64.29 72.48,63.81 72.48,61.07 72.14,60.74 72.14,60.07 71.47,59.4 71.47,59.28 71.82,58.92 71.82,58.79 71.7,58.67 71.57,58.67 71.21,59.02 71.09,59.02 70.96,58.9 70.96,58.77 71.32,58.42 71.32,58.29 71.19,58.16 71.07,58.16 70.71,58.52 70.59,58.52 69.81,57.75 69.81,54.66 69.38,54.23 66.16,54.23 64.27,52.34 63.98,52.34 59.07,47.42 59.07,46.85 56.78,44.57 50.69,44.57 48.31,42.19 47.06,42.19 46.67,41.79 44.44,41.79 43.97,41.32 43.15,41.32 42.27,40.45 42.27,40.11 42.04,39.88 41.47,39.88 v1(41.07,39.48)
  BOTTOM w0.079: U24.AK47 75.41,66.86 75.12,66.57 74.99,66.57 74.68,66.57 74.47,66.46 74.06,66.46 73.98,66.55 72.89,66.55 v2(72.54,66.2)
M_B_DQ5: length 54.3
  TOP w0.102: U8.G2 v1(41.07,43.48)
  IN3 w0.089: v2(67.02,63.36) 67.02,60.8 66.41,60.2 66.41,59.42 66.61,59.22 66.61,58.53 66.23,58.15 64.32,58.15 62.27,56.1 62.27,54.13 59.68,51.54 59.43,51.54 56.65,48.76 56.65,47.99 56.01,47.35 50,47.35 48.68,46.04 46.34,46.04 46.25,46.13 46.25,46.33 46.17,46.42 45.99,46.42 45.9,46.33 45.9,46.13 45.81,46.04 45.63,46.04 45.54,46.13 45.54,46.33 45.45,46.42 45.28,46.42 45.19,46.33 45.19,46.13 45.1,46.04 44.92,46.04 44.83,46.13 44.83,46.33 44.74,46.42 44.57,46.42 44.48,46.33 44.48,46.13 44.39,46.04 44.05,46.04 43.67,46.42 42.05,46.42 41.34,45.71 41.34,44.68 41.47,44.56 41.47,44.06 41.07,43.66 v1(41.07,43.48)
  BOTTOM w0.076: U24.AG45 75.92,68.3 ; v2(67.02,63.36) 67.12,63.46 67.12,64.1
  BOTTOM w0.079: 75.92,68.3 75.65,68.42 74.83,68.42 74.62,68.46 74.61,68.46 74.43,68.53 73.93,68.53 73.83,68.62 71.64,68.62 67.12,64.1
M_B_DQ6: length 53.2
  TOP w0.102: v1(41.07,44.29) 41.07,44.28 U8.H2
  IN3 w0.089: v1(41.07,44.29) 41.1,44.32 41.1,46.61 41.35,46.87 41.52,46.87 41.72,46.66 46.72,46.66 46.81,46.58 46.81,46.37 46.9,46.28 47.08,46.28 47.17,46.37 47.17,46.58 47.26,46.66 47.43,46.66 47.52,46.58 47.52,46.37 47.61,46.28 47.79,46.28 47.88,46.37 47.88,46.58 47.97,46.66 48.15,46.66 48.23,46.58 48.23,46.37 48.32,46.28 48.5,46.28 48.59,46.37 48.59,46.58 48.68,46.66 48.97,46.66 49.9,47.59 55.9,47.59 56.41,48.11 56.41,48.86 59.33,51.78 59.58,51.78 62.03,54.23 62.03,56.2 65.07,59.24 65.07,60.18 65.37,60.49 65.5,60.49 65.78,60.21 65.91,60.21 66.03,60.33 66.03,60.46 65.75,60.74 65.75,60.86 65.88,60.99 66,60.99 66.29,60.71 66.41,60.71 66.54,60.83 66.54,60.96 66.25,61.24 66.25,61.37 66.64,61.75 v2(66.64,62.91)
  BOTTOM w0.076: 67.3,64.02 67.3,63.69 67.5,63.49 67.5,63.21 67.2,62.91 v2(66.64,62.91)
  BOTTOM w0.079: 67.3,64.02 71.73,68.45 73.76,68.45 73.86,68.36 74.4,68.36 74.55,68.31 U24.AG48
M_B_DQ7: length 52.4
  TOP w0.102: U8.H3 v1(41.07,42.68)
  IN3 w0.089: v2(67.7,63.89) 67.39,63.58 67.39,63.11 67.26,62.97 67.26,60.7 66.65,60.1 66.65,59.58 66.86,59.37 66.86,58.43 66.28,57.85 64.94,57.85 62.51,55.42 62.51,54.03 59.78,51.29 59.53,51.29 56.89,48.66 56.89,47.88 56.13,47.11 50.1,47.11 48.78,45.8 47.43,45.8 47.34,45.71 47.34,45.27 47.25,45.19 47.07,45.19 46.98,45.27 46.98,45.71 46.89,45.8 46.71,45.8 46.63,45.71 46.63,45.27 46.54,45.19 46.36,45.19 46.27,45.27 46.27,45.71 46.18,45.8 46,45.8 45.91,45.71 45.91,45.27 45.83,45.19 45.65,45.19 45.56,45.27 45.56,45.71 45.47,45.8 43.63,45.8 43.06,45.23 43.06,44.9 42.03,43.88 41.71,43.88 41.47,43.64 41.47,43.08 v1(41.07,42.68)
  BOTTOM w0.079: v2(67.7,63.89) 67.7,64.02 71.21,67.52 71.21,67.68 71.82,68.29 73.69,68.29 73.79,68.19 74.26,68.19 U24.AG49
M_B_DQ8: length 58.8
  TOP w0.102: v1(44.51,40.63) 44.51,40.68 44.28,40.91 44.28,43.45 44.67,43.83 U8.C2
  IN3 w0.089: v1(44.51,40.63) 45.5,40.63 46.07,41.2 46.63,41.2 47.22,41.79 48.73,41.79 50.48,43.55 56.58,43.55 59.46,46.43 59.46,47.26 61.49,49.29 62.32,49.29 66.22,53.19 69.28,53.19 70.88,54.8 71.94,54.8 72.71,55.56 72.71,55.84 72.45,56.1 72.45,57.18 71.99,57.64 71.99,58.29 72.89,59.19 72.89,60.41 73.37,60.89 73.37,65.26 74.14,66.04 74.14,66.16 73.94,66.37 73.94,66.5 74.06,66.62 74.19,66.62 74.4,66.42 74.52,66.42 74.65,66.54 74.65,66.67 74.44,66.87 74.44,67 74.57,67.13 74.69,67.13 74.9,66.92 75.02,66.92 76.04,67.93 77.13,67.93 77.4,68.2 79.27,68.2 v2(79.82,67.65)
  BOTTOM w0.079: U24.AJ38 79.82,67.32 v2(79.82,67.65)
M_B_DQ9: length 58.4
  TOP w0.102: U8.C8 v1(45.07,38.68)
  IN3 w0.089: v1(45.07,38.68) 45.4,38.35 45.4,38.12 45.47,38.05 45.47,37.64 45.85,37.25 47.09,37.25 47.45,37.61 47.45,38.08 48.53,39.15 57.51,39.15 58.71,40.35 58.71,40.89 58.8,40.97 59.16,40.97 59.24,41.06 59.24,41.18 59.16,41.26 58.8,41.26 58.71,41.35 58.71,41.47 58.8,41.56 59.16,41.56 59.24,41.64 59.24,41.76 59.16,41.85 58.8,41.85 58.71,41.93 58.71,42.51 61.02,44.82 62.07,44.82 64.09,46.84 68.69,46.84 72.46,50.6 72.46,51.14 72.75,51.43 73.52,51.43 75.04,52.96 75.04,56.07 75.25,56.27 75.25,59.65 75.53,59.93 75.53,63.89 76.01,64.37 76.01,64.9 77.45,66.35 78.1,66.35 78.1,66.35 78.81,66.35 v2(79.19,66.74)
  BOTTOM w0.079: v2(79.19,66.74) 79.19,66.39 U24.AL39
M_B_DQ10: length 57.8
  TOP w0.102: v1(45.87,40.41) 45.49,40.41 44.67,41.23 U8.C3
  IN3 w0.089: v2(79.16,67.65) 78.78,68.03 77.47,68.03 77.2,67.75 76.2,67.75 73.61,65.16 73.61,60.79 73.13,60.31 73.13,59.06 72.23,58.16 72.23,57.74 72.69,57.28 72.69,56.2 72.95,55.94 72.95,55.46 71.53,54.04 71.4,54.04 71.01,54.43 70.89,54.43 70.76,54.3 70.76,54.18 71.15,53.79 71.15,53.66 71.03,53.54 70.9,53.54 70.51,53.93 70.39,53.93 70.26,53.8 70.26,53.68 70.65,53.29 70.65,53.16 70.44,52.95 66.32,52.95 62.4,49.03 61.57,49.03 59.7,47.16 59.7,46.33 56.68,43.31 50.62,43.31 48.87,41.55 47.32,41.55 46.73,40.96 46.17,40.96 45.87,40.65 v1(45.87,40.41)
  BOTTOM w0.076: v2(79.16,67.65) 79.16,67.63 79.3,67.49
  BOTTOM w0.079: U24.AJ39 79.3,67.49
M_B_DQ11: length 58.5
  TOP w0.102: U8.B8 v1(45.87,38.68)
  IN3 w0.089: v1(45.87,38.68) 45.87,38.51 46.27,38.11 46.27,37.85 46.63,37.5 46.99,37.5 47.21,37.71 47.21,38.18 48.43,39.39 49.67,39.39 49.75,39.48 49.75,39.78 49.84,39.86 50.02,39.86 50.11,39.78 50.11,39.48 50.2,39.39 50.38,39.39 50.47,39.48 50.47,39.78 50.55,39.86 50.73,39.86 50.82,39.78 50.82,39.48 50.91,39.39 57.41,39.39 58.47,40.45 58.47,42.7 62.11,46.34 63.26,46.34 63.99,47.08 68.59,47.08 69.55,48.03 69.55,48.16 69.39,48.31 69.39,48.44 69.52,48.56 69.64,48.56 69.8,48.41 69.92,48.41 70.05,48.53 70.05,48.66 69.89,48.81 69.89,48.94 70.02,49.06 70.14,49.06 70.3,48.91 70.43,48.91 70.55,49.04 70.55,49.16 70.4,49.32 70.4,49.44 70.52,49.57 70.65,49.57 70.8,49.41 70.93,49.41 71.05,49.54 71.05,49.66 70.9,49.82 70.9,49.94 71.03,50.07 71.15,50.07 71.31,49.92 71.43,49.92 71.56,50.04 71.56,50.17 71.4,50.32 71.4,50.45 71.53,50.57 71.65,50.57 71.81,50.42 71.93,50.42 72.22,50.7 72.22,51.24 72.65,51.68 73.42,51.68 74.8,53.06 74.8,56.34 74.93,56.47 74.93,59.74 75.29,60.09 75.29,64.09 75.74,64.55 75.74,64.9 77.56,66.71 v2(77.69,66.71)
  BOTTOM w0.076: 77.35,66.39 77.67,66.71 v2(77.69,66.71)
  BOTTOM w0.079: 77.35,66.39 U24.AL43
M_B_DQ12: length 58.6
  TOP w0.102: U8.C7 v1(45.07,39.48)
  IN3 w0.089: v2(79.82,66.74) 79.82,66.53 79.46,66.17 78.17,66.17 78.17,66.17 77.53,66.17 76.39,65.03 76.39,60.45 75.5,59.56 75.5,56.04 75.28,55.83 75.28,52.78 73.04,50.53 72.73,50.53 68.79,46.6 64.19,46.6 61.32,43.72 61.19,43.72 59.49,42.02 59.49,40.79 57.61,38.91 48.63,38.91 47.69,37.98 47.69,37.51 47.2,37.01 45.09,37.01 44.67,37.43 44.67,39.08 v1(45.07,39.48)
  BOTTOM w0.076: v2(79.82,66.74) 79.95,66.61 79.95,66.43
  BOTTOM w0.079: U24.AL38 79.95,66.43
M_B_DQ13: length 57.6
  TOP w0.102: U8.A3 46.27,40.81 v1(46.67,40.41)
  IN3 w0.089: v2(77.64,67.63) 77.57,67.56 76.35,67.56 73.85,65.06 73.85,60.69 73.37,60.21 73.37,58.14 72.93,57.7 72.93,56.3 73.19,56.04 73.19,55.36 71,53.18 71,52.11 70.06,51.17 67.63,51.17 66.99,50.53 64.58,50.53 62.16,48.12 61.83,48.12 56.78,43.06 54.42,43.06 54.33,42.98 54.33,42.58 54.24,42.49 54.06,42.49 53.97,42.58 53.97,42.98 53.88,43.06 53.71,43.06 53.62,42.98 53.62,42.45 53.53,42.36 53.35,42.36 53.26,42.45 53.26,42.98 53.17,43.06 52.99,43.06 52.91,42.98 52.91,42.45 52.82,42.36 52.64,42.36 52.55,42.45 52.55,42.98 52.46,43.06 52.28,43.06 52.19,42.98 52.19,42.45 52.11,42.36 51.93,42.36 51.84,42.45 51.84,42.98 51.75,43.06 51.57,43.06 51.48,42.98 51.48,42.45 51.39,42.36 51.22,42.36 51.13,42.45 51.13,42.98 51.04,43.06 50.76,43.06 49.01,41.31 47.58,41.31 v1(46.67,40.41)
  BOTTOM w0.079: v2(77.64,67.63) 77.64,67.56 U24.AJ42
M_B_DQ14: length 57.3
  TOP w0.102: U8.D7 44.27,39.48 v1(44.27,39.48)
  IN3 w0.089: v1(44.27,39.48) 43.83,39.03 43.83,37.71 44.76,36.77 47.39,36.77 48.58,37.96 48.91,37.96 49.62,38.67 57.71,38.67 59.73,40.69 59.73,41.24 61.4,42.91 61.51,42.91 62.03,43.43 62.03,44.09 64.29,46.35 68.89,46.35 72.83,50.29 73.14,50.29 75.53,52.68 75.53,54.32 76.34,55.13 76.34,59.88 76.63,60.17 76.63,65.02 76.96,65.36 77.88,65.36 v2(78.32,65.8)
  BOTTOM w0.076: U24.AL42 78,66.12 v2(78.32,65.8)
M_B_DQ15: length 57.4
  TOP w0.102: v1(43.88,40.63) 43.93,40.68 43.93,43.02 U8.D3
  IN3 w0.089: v1(43.88,40.63) 44.51,39.99 46.92,39.99 47.94,41.01 49.04,41.01 49.52,41.48 54.71,41.48 54.8,41.57 54.8,42.35 54.89,42.44 55.07,42.44 55.16,42.35 55.16,41.57 55.25,41.48 55.43,41.48 55.51,41.57 55.51,42.35 55.6,42.44 55.78,42.44 55.87,42.35 55.87,41.57 55.96,41.48 56.16,41.48 56.23,41.55 56.23,42.15 61.94,47.87 62.29,47.87 64.72,50.29 69.54,50.29 71.25,51.99 71.25,53.08 73.43,55.26 73.43,56.16 73.17,56.42 73.17,57.6 73.61,58.04 73.61,60.11 74.09,60.59 74.09,64.96 76.15,67.02 v2(76.77,67.02)
  BOTTOM w0.079: v2(76.77,67.02) 76.95,67.19 U24.AJ43
M_B_DQ16: length 42.4
  TOP w0.102: v1(45.07,55.8) 44.92,55.96 44.92,55.98 U6.C3
  IN3 w0.089: v2(66.99,71.18) 66.86,71.18 65.77,70.1 65.77,69.65 65.38,69.26 64.63,69.26 64.35,68.98 63.66,68.98 60.09,65.41 60.09,63.83 58.87,62.6 58.87,61.65 58.42,61.2 57.04,61.2 56.86,61.38 54.72,61.38 53.93,60.59 52.49,60.59 52.41,60.52 52.41,60.36 52.49,60.29 52.92,60.29 53.05,60.16 53.05,59.57 52.77,59.3 51.29,59.3 50.98,58.99 50.98,58.1 49.06,56.18 48.7,56.18 48.55,56.02 48.41,56.02 48.25,56.18 48.12,56.18 47.96,56.02 47.83,56.02 47.67,56.18 47.54,56.18 47.38,56.02 47.24,56.02 47.09,56.18 45.45,56.18 v1(45.07,55.8)
  BOTTOM w0.079: v2(66.99,71.18) 66.99,71.42 67.14,71.57 67.44,71.57 68.46,72.59 70.96,72.59 72.88,70.67 73.22,70.67 73.39,70.51 74.21,70.51 U24.AB49
M_B_DQ17: length 42.6
  TOP w0.102: U6.C2 v1(45.07,56.63)
  IN3 w0.089: v1(45.07,56.63) 45.07,56.95 45.16,57.03 46.32,57.03 46.33,57.05 46.84,57.05 47.43,56.45 48.99,56.45 49.39,56.85 49.39,56.97 49.17,57.2 49.17,57.32 49.25,57.4 49.38,57.4 49.6,57.18 49.72,57.18 50.74,58.2 50.74,59.22 51.06,59.54 51.4,59.54 51.5,59.64 51.5,59.97 51.69,60.16 51.98,60.16 52.17,60.36 52.17,60.65 52.35,60.83 53.83,60.83 54.62,61.63 56.96,61.63 57.14,61.44 58.32,61.44 58.59,61.71 58.59,62.67 59.85,63.93 59.85,65.51 63.56,69.22 64.24,69.22 64.53,69.51 65.09,69.51 v2(65.24,69.66)
  BOTTOM w0.079: 66.61,71.49 66.86,71.74 67.37,71.74 68.39,72.76 71.03,72.76 72.95,70.84 73.29,70.84 73.46,70.68 73.98,70.68 74.16,70.86 74.4,70.86 74.55,70.81 U24.AB48
  BOTTOM w0.102: 66.61,71.49 66.61,70.85 65.47,69.71 65.29,69.71 v2(65.24,69.66)
M_B_DQ18: length 42.8
  TOP w0.102: v1(44.47,53.58) 44.41,53.58 U6.D7
  IN3 w0.089: v2(69.05,70.78) 68.97,70.85 68.77,70.85 67.96,70.04 67.96,69.12 66.18,67.35 65.43,67.35 64.19,66.11 63.51,66.11 62.01,64.62 62.01,63.03 60.79,61.81 60.79,60.86 57.43,57.5 57.27,57.5 57.18,57.41 57.18,57.3 57.1,57.21 56.98,57.21 56.89,57.3 56.89,57.41 56.81,57.5 56.69,57.5 56.6,57.41 56.6,57.3 56.51,57.21 56.39,57.21 56.31,57.3 56.31,57.41 56.22,57.5 55.15,57.5 54.71,57.06 54.71,56.15 54.31,55.75 51.62,55.75 50.07,54.21 50.07,53.91 49.03,52.87 45.44,52.87 45.27,53.03 44.86,53.03 44.47,53.42 v1(44.47,53.58)
  BOTTOM w0.079: v2(69.05,70.78) 69.25,70.98 70.67,70.98 72.22,69.43 74.26,69.43 U24.AE49
M_B_DQ19: length 43.5
  TOP w0.102: U6.C8 v1(45.07,51.83)
  IN3 w0.089: v2(68.9,69.91) 68.46,69.48 68.46,68.95 66.38,66.86 65.63,66.86 64.39,65.63 63.71,65.63 62.5,64.42 62.5,62.83 61.28,61.61 61.28,60.66 57.17,56.55 55.87,56.55 54.45,55.14 54.09,55.14 53.4,54.44 51.06,54.44 50.61,53.99 50.61,53.76 49.13,52.28 48.3,52.28 48.21,52.19 48.21,51.89 48.12,51.8 47.94,51.8 47.85,51.89 47.85,52.19 47.77,52.28 47.59,52.28 47.5,52.19 47.5,51.89 47.41,51.8 47.23,51.8 47.14,51.89 47.14,52.19 47.05,52.28 46.88,52.28 46.79,52.19 46.79,51.89 46.7,51.8 46.52,51.8 46.43,51.89 46.43,52.19 46.34,52.28 45.35,52.28 45.07,52 v1(45.07,51.83)
  BOTTOM w0.079: U24.AE47 75.41,69.36 75.12,69.07 74.99,69.07 74.68,69.07 74.47,68.96 74.1,68.96 73.99,69.08 72.1,69.08 71.22,69.96 68.95,69.96 v2(68.9,69.91)
M_B_DQ20: length 43.5
  TOP w0.102: v1(45.07,52.63) 45.47,52.23 U6.B8
  IN3 w0.089: v1(45.07,52.63) 45.13,52.57 49.08,52.57 50.32,53.81 50.32,54.11 51.62,55.41 53.24,55.41 53.32,55.32 53.32,55.07 53.41,54.99 53.53,54.99 53.61,55.07 53.61,55.32 53.7,55.41 54.37,55.41 54.95,55.99 54.95,56.7 55.17,56.92 55.17,57.15 55.25,57.24 55.37,57.24 55.46,57.15 55.46,56.92 55.54,56.83 55.67,56.83 55.75,56.92 55.75,57.15 55.84,57.24 55.96,57.24 56.04,57.15 56.04,56.92 56.13,56.83 56.3,56.83 56.4,56.93 56.7,56.93 56.81,56.83 57.1,56.83 61.03,60.76 61.03,61.71 62.25,62.93 62.25,64.52 63.61,65.87 64.29,65.87 65.53,67.11 66.28,67.11 68.21,69.04 68.21,69.91 68.64,70.34 69.1,70.34 69.3,70.14 69.51,70.14 69.66,70.29 v2(69.66,70.6)
  BOTTOM w0.079: U24.AE48 74.88,69.36 74.43,69.13 74.17,69.13 74.05,69.25 72.16,69.25 71.2,70.22 70.04,70.22 v2(69.66,70.6)
M_B_DQ21: length 42.9
  TOP w0.102: v1(46.67,55.78) 46.44,56.01 46.44,56.06 U6.A3
  IN3 w0.089: v1(46.67,55.78) 49,55.78 51.22,58 51.22,58.89 51.39,59.05 52.87,59.05 53.29,59.47 53.29,60.12 53.51,60.34 54.51,60.34 54.6,60.43 54.6,60.92 54.68,61.01 54.81,61.01 54.89,60.92 54.89,60.43 54.98,60.34 55.22,60.34 55.3,60.43 55.3,60.47 55.39,60.56 55.51,60.56 55.6,60.47 55.6,60.43 55.68,60.34 55.8,60.34 55.89,60.43 55.89,60.47 55.97,60.56 56.09,60.56 56.18,60.47 56.18,60.43 56.27,60.34 56.39,60.34 56.47,60.43 56.47,60.47 56.56,60.56 56.68,60.56 56.76,60.47 56.76,60.43 56.85,60.34 56.97,60.34 57.06,60.43 57.06,60.78 57.14,60.86 57.26,60.86 57.35,60.78 57.35,60.43 57.43,60.34 57.62,60.34 57.69,60.42 57.69,60.77 57.81,60.88 58.44,60.88 59.11,61.55 59.11,62.5 60.34,63.73 60.34,65.31 63.76,68.74 64.45,68.74 64.73,69.02 65.48,69.02 66.01,69.55 66.01,70 66.74,70.73 67.09,70.73 v2(67.58,71.21)
  BOTTOM w0.079: v2(67.58,71.21) 68.79,72.42 70.89,72.42 72.81,70.5 73.16,70.5 73.32,70.34 74.33,70.34 74.48,70.42 74.81,70.42 74.84,70.4 75.11,70.4 75.48,70.63 U24.AB47
M_B_DQ22: length 42.4
  TOP w0.102: U6.C7 v1(45.1,53.46)
  IN3 w0.089: v1(45.1,53.46) 45.23,53.32 45.4,53.32 45.56,53.16 48.98,53.16 49.83,54.01 49.83,54.31 51.52,55.99 54.12,55.99 54.47,56.34 54.47,57.16 55.05,57.74 57.33,57.74 60.55,60.96 60.55,61.91 61.77,63.13 61.77,64.72 63.41,66.36 64.09,66.36 65.33,67.59 66.08,67.59 67.7,69.21 67.7,70.17 68.69,71.15 73.11,71.15 v2(73.16,71.21)
  BOTTOM w0.079: U24.AB45 75.98,70.92 74.83,70.92 74.62,70.96 74.61,70.96 74.43,71.03 74.09,71.03 73.91,70.84 73.53,70.84 v2(73.16,71.21)
M_B_DQ23: length 43.9
  TOP w0.102: U6.D3 v1(44.27,55.83)
  IN3 w0.089: v1(44.27,55.83) 44.72,55.38 48.95,55.38 51.69,58.12 53.02,58.12 53.3,58.4 53.3,59.15 53.83,59.68 54.85,59.68 55.01,59.52 57.42,59.52 59.35,61.45 59.35,62.4 60.58,63.63 60.58,65.21 63.86,68.5 64.55,68.5 64.83,68.78 65.58,68.78 66.25,69.45 66.25,69.9 66.84,70.48 67.22,70.48 67.56,70.83 67.78,70.83 v2(68.16,71.21)
  BOTTOM w0.079: U24.AE45 76.27,70.2 76.13,70.34 75.63,70.34 75.51,70.23 74.47,70.23 74.37,70.17 73.25,70.17 73.09,70.34 72.74,70.34 70.83,72.25 69.2,72.25 v2(68.16,71.21)
M_B_DQ24: length 53.7
  TOP w0.102: U6.G2 v1(41.87,56.63)
  IN3 w0.089: v2(79.59,70.37) 79.11,70.85 78.77,70.85 77.83,71.79 75.04,71.79 74.08,70.83 70.9,70.83 66.53,66.46 65.78,66.46 64.56,65.24 64.03,65.24 62.89,64.1 62.89,62.67 61.67,61.45 61.67,60.5 56.58,55.41 55.28,55.41 54.98,55.11 54.98,54.67 54.35,54.04 51.45,54.04 48.81,51.4 44.91,51.4 43.85,52.46 43.85,55.88 43.53,56.2 42.3,56.2 v1(41.87,56.63)
  BOTTOM w0.079: v2(79.59,70.37) 79.95,70.01 U24.AD38
M_B_DQ25: length 54.3
  TOP w0.102: U6.H2 v1(41.07,56.63)
  IN3 w0.089: v2(79.01,70.37) 78.34,71.03 77.51,71.03 77.38,71.16 76.31,71.16 76.13,70.98 74.48,70.98 74.15,70.65 70.97,70.65 66.6,66.28 65.94,66.28 64.64,64.98 64.12,64.98 63.13,64 63.13,62.57 61.91,61.35 61.91,60.4 57.1,55.59 57.1,54.49 56.81,54.19 54.84,54.19 54.45,53.8 51.55,53.8 48.91,51.16 47.4,51.16 46.73,50.49 44.92,50.49 44.67,50.75 44.67,51.23 43.56,52.34 43.56,54.94 42.54,55.96 41.74,55.96 v1(41.07,56.63)
  BOTTOM w0.079: U24.AD39 79.3,70.07 v2(79.01,70.37)
M_B_DQ26: length 54.4
  TOP w0.102: U6.H8 41.11,51.79 41.11,51.04 41.34,50.81 v1(41.34,50.28)
  IN3 w0.089: v2(78.93,68.57) 78.93,68.69 78.68,68.94 77.58,68.94 77.51,68.87 76.47,68.87 75.91,69.43 75.6,69.43 75.11,68.93 71.54,68.93 67.54,64.94 67.54,64.81 65.59,62.86 65.59,61.95 64.19,60.54 64.19,59.6 61.16,56.56 61.16,54.59 59.22,52.65 58.96,52.65 55.59,49.27 50.3,49.27 48.99,47.97 43.69,47.97 43.13,48.52 42.94,48.52 42.86,48.44 42.74,48.44 42.61,48.57 42.61,48.7 42.7,48.79 42.7,48.95 42.63,49.03 42.44,49.03 42.36,48.95 42.24,48.95 41.79,49.39 41.79,49.53 42.1,49.84 42.1,50.04 41.8,50.34 41.4,50.34 v1(41.34,50.28)
  BOTTOM w0.079: v2(78.93,68.57) 78.93,68.65 U24.AE39
M_B_DQ27: length 56.2
  TOP w0.102: U6.H7 v1(41.07,53.43)
  IN3 w0.089: v1(41.07,53.43) 41.39,53.43 41.47,53.35 41.47,50.78 41.62,50.63 41.85,50.63 44.03,48.45 46.98,48.45 47.07,48.54 47.07,48.73 47.16,48.82 47.33,48.82 47.42,48.73 47.42,48.54 47.51,48.45 48.79,48.45 50.11,49.77 50.36,49.77 50.45,49.86 50.45,50.3 50.53,50.39 50.71,50.39 50.8,50.3 50.8,49.86 50.89,49.77 52.76,49.77 52.85,49.86 52.85,50.19 52.94,50.28 53.12,50.28 53.21,50.19 53.21,49.86 53.3,49.77 54.8,49.77 54.97,49.94 54.97,50.32 55.07,50.42 55.24,50.42 55.33,50.33 55.33,50 55.43,49.9 55.52,49.9 58.25,52.62 58.25,52.75 58.09,52.91 58.09,53.03 58.21,53.16 58.34,53.16 58.5,53 58.63,53 58.88,53.25 58.88,54.99 59.13,55.25 59.26,55.25 59.31,55.2 59.43,55.2 59.56,55.33 59.56,55.45 59.51,55.5 59.51,55.63 59.64,55.75 59.76,55.75 59.81,55.7 59.94,55.7 60.06,55.83 60.06,55.96 60.01,56.01 60.01,56.13 63.71,59.82 63.71,60.74 65.11,62.15 65.11,63.06 67.06,65.01 67.06,65.14 71.56,69.65 74.93,69.65 75.12,69.84 76.41,69.84 v2(76.8,69.46)
  BOTTOM w0.079: v2(76.8,69.46) 77.23,69.02 U24.AE43
M_B_DQ28: length 54.8
  TOP w0.102: v1(42.39,49.5) 42.66,49.77 42.66,52.59 42.27,52.98 U6.F7
  IN3 w0.089: v1(42.39,49.5) 42.56,49.5 43.86,48.21 48.89,48.21 50.2,49.52 55.49,49.52 59.12,53.15 59.12,54.47 59.33,54.68 60.65,54.68 60.91,54.94 60.91,55.27 60.56,55.62 60.56,56.32 63.95,59.7 63.95,60.64 65.35,62.05 65.35,62.96 67.3,64.91 67.3,65.04 71.44,69.18 75.1,69.18 75.57,69.64 76.06,69.64 76.65,69.05 77.13,69.05 77.2,69.12 79.35,69.12 79.61,69.38 v2(79.61,69.48)
  BOTTOM w0.079: v2(79.61,69.48) 79.95,69.15 U24.AE38
M_B_DQ29: length 55.1
  TOP w0.102: v1(40.96,54.88) 40.83,55 40.83,55.27 U6.J3
  IN3 w0.089: v2(77.79,70.39) 77.79,70.54 77.68,70.64 77.37,70.64 77.24,70.77 76.51,70.77 76.22,70.48 74.48,70.48 74.3,70.29 71.12,70.29 66.73,65.9 66.24,65.9 64.81,64.47 64.28,64.47 63.61,63.8 63.61,62.37 62.41,61.16 62.41,60.21 57.59,55.39 57.59,54.26 56.74,53.41 56.74,52.82 56.36,52.45 50.88,52.45 48.44,50.01 44.31,50.01 43.99,50.34 43.98,50.34 43.58,50.74 43.58,50.75 43.02,51.31 43.02,54.77 42.42,55.37 41.21,55.37 40.96,55.12 v1(40.96,54.88)
  BOTTOM w0.079: U24.AD43 77.35,69.96 v2(77.79,70.39)
