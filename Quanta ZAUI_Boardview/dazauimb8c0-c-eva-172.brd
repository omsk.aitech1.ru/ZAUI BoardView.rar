# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Library data of the parts (continued)
R12 R21 R31 R125 R126 R132 R133 R140 R141 R146 R151 R161 R166 R168 R169 R171 R172 R174 R177 R181 R182 R185 R186 R191-R193 R255 R300 R364 R365 R679 R704 = RES_BGM: tolerance: CS21001JE14
R13 R14 R24 R52 R55 R83 R100 R103 R222 R224 R225 R244 R249 R261 R262 R306 R342 R355 R369-R371 R376 R377 R390-R392 R414 R418 R424 R434 R556 R557 R630 R632 R635 R639 R640 R644 R648 R650-R653 R659 R673 R729 R732 R733 R737 R763 R795 R797 R806 R827 = RES_BGM: tolerance: CS31002JB28
R15 = RES_BGM: tolerance: CS16802JB27
R16 R25 = RES_BGM: tolerance: CS01002JB22
R18 R22 R27 R64 R187 R324 R351 R388 R482 R490 R492 R496 R503 R504 R535 R654 R783 R814 R815 R821 R826 R829 R838-R840 = RES_BGM: tolerance: CS41002FB28
R20 R28 R194 R195 R281 R336 R344 R345 R374 R464 R804 = SHORTPAD_BGM: tolerance: CS00002JB38
R26 R149 R158 R855 = RES_BGM: tolerance: CS21002FB24
R29 R50 R56 R60 R86 R447 R454 R478-R480 R494 R508 R513 R525-R528 R537 R548 R550 R555 R562-R564 R570 R621 = RES_BGM: tolerance: CS31002FB26
R30 = RES_BGM: tolerance: CS31502FB24
R32 R310 R318 R368 R393-R395 R402 R410 R430 R487 R516 R517 R682-R684 R687 R751 = RES_BGM: tolerance: CS03301JE09
R34 R38 R41 R178 R214 R219 R221 R358 R420 R432 R442-R445 R452 R453 R518 R596 R616 R623 R710 R719 R773 R780 R818 = RES_BGM: tolerance: CS00003J951
R35 R49 = RES_BGM: tolerance: CS21332FB11
R36 R45 = RES_BGM: tolerance: CS15492FB29
R40 R43 = RES_BGM: tolerance: CS19312FB11
R46 R59 R308 R541 R637 = RES_BGM: tolerance: CS06041FE00
R48 R154 = RES_BGM: tolerance: CS02492FB29
R51 = RES_BGM: tolerance: CS-2703J911
R54 R65 = RES_BGM: tolerance: CS21802FB10
R66-R80 R85 R87-R92 R94 R95 R101 R108 R109 R139 = RES_BGM: tolerance: CS03902FB11
R82 R84 = RES_BGM: tolerance: CS04022FB28
R93 R235 R290 R301 R303 R334 R337 R405 R408 R656 R665 R666 R725 R735 R739 R747 R750 R765 R767 R799 R853 R854 = RES_BGM: tolerance: CS32001FE00
R96 R712 R716 = RES_BGM: tolerance: CS51001JE10
R104 R115 R118 R122 R130 R137 R145 R150 R160 R211 R218 R251 R252 R313 R360 R385 R389 R403 R411 R417 R421 R425-R428 R448 R458 R463 R534 R544 R629 R631 R634 R645-R647 R649 R694 R730 R731 R738 R746 R754 R756 R772 R812 = RES_BGM: tolerance: *
R106 R107 R163 R164 R257 R260 R356 R357 R361 R367 R415 R558-R561 R779 R801 = RES_BGM: tolerance: CS22201JE00
R110 R116 R119 R123 R131 R142 R148 R155 R170 R197 R199 R210 R217 R242 R246 R247 R254 R265 R270 R271 R282 R288 R297 R349 R372 R379-R381 R398 R400 R412 R416 R441 R455 R456 R467 R473 R475 R484 R491 R495 R497 R498 R571 R578 R586 R587 R590 R592 R598 R602 R604 R608 R622 R627 R668 R669 R674-R676 R680 R689 R692 R696 R699 R702 R703 R711 R717 R723 R726 R727 R755 R776 R790 R792 R819 R830-R832 R834 R835 R837 R843-R852 = RES_BGM: tolerance: CS00001JE18
R111 R117 R121 R124 R138 R144 R153 R157 = RES_BGM: tolerance: CS14702FB18
R112 = RES_BGM: tolerance: CS04992FB31
R113 R189 R228 R294 = RES_BGM: tolerance: CS12402FB03
R127 R134-R136 R147 R152 R162 R167 R176 R179 R180 R183 R184 R250 R258 R309 R327 R333 R362 R378 R468 R483 R658 R698 R700 R718 R741 R742 R825 R828 = RES_BGM: tolerance: CS31001FE14
R128 R129 R143 R156 R594 R600 R603 R607 = RES_BGM: tolerance: CS05101FE13
R159 = RES_BGM: tolerance: CS-2003F900
R173 R230 R240 R296 R591 = RES_BGM: tolerance: CS04991FE00
R188 R196 = R_3: tolerance: CS21002FB24
R201 R203 R205-R208 R212 R213 R216 R220 R615 = RES_BGM: tolerance: CS12401FE00
R223 = RES_BGM: tolerance: CS33902FB16
R226 R259 R326 R512 = RES_BGM: tolerance: CS12001FE01
R231 R233 R236 R237 = RES_BGM: tolerance: CS01001JE11
R232 R238 = RES_BGM: tolerance: CS06202FB13
R239 R241 R266 R269 R291 R339 R359 R474 R581 R628 R660-R662 R667 R670 R681 R685 R688 R701 R706 R708 R709 R714 R721 R728 R753 R760 R762 R771 R786 R789 = RES_BGM: tolerance: CS41001JE00
R243 R302 R311 R672 = RES_BGM: tolerance: CS37501FE00
R253 R256 R272 R276 R286 R287 R299 R317 R330 R383 R572-R574 R580 R643 R657 R671 R678 R713 R768 R816 = RES_BGM: tolerance: CS31001JE16
R277 R593 = RES_BGM: tolerance: CS41001FE08
R278 = RES_BGM: tolerance: CS14701FE00
R285 = RES_BGM: tolerance: CS11131FE01
R292 R575-R577 R579 R585 R597 R599 = RES_BGM: tolerance: CS11001FE00
R307 R329 = RES_BGM: tolerance: CS02201FE00
R312 R323 R335 R363 R382 R744 R759 R761 R777 R793 = RES_BGM: tolerance: CS02202FB12
R319-R321 = RES_BGM: tolerance: CS07502FB17
R325 R791 = RES_S_BGM: tolerance: CS31001FE14
R332 R611 = RES_BGM: tolerance: CS02204JA18
R348 R459 R462 = RES_S_BGM: tolerance: CS41001JE00
R350 R396 R404 = RES_BGM: tolerance: CS37502FB12
R352 R614 R625 = RES_BGM: tolerance: CS18662FB00
R354 = RES_BGM: tolerance: CS04302JB13
R386 R612 R618 = RES_BGM: tolerance: CS52002FB06
R387 R613 R624 = RES_BGM: tolerance: CS51002JB21
R397 = RES_BGM: tolerance: CS28201FE00
R401 R507 R794 R803 = RES_BGM: tolerance: CS-2203J913
R406 R740 R833 = RES_BGM: tolerance: CS42001FE00
R409 = R_3: tolerance: *
R419 = RES_BGM: tolerance: CS02202JB22
R423 = RES_BGM: tolerance: CS21201JE03
R439 = RES_BGM: tolerance: CS37152FB11
R457 = SHORTPAD_V01_BGM: tolerance: TMPSHT00201
R472 = RES_BGM: tolerance: CS44222FB14
R493 = RES_BGM: tolerance: CS14703F914
R523 R530 = RES_BGM: tolerance: CS11202FB11
R524 R531 = RES_BGM: tolerance: CS08061FE00
R553 = RES_BGM: tolerance: CS33012FB18
R582 R584 R633 R638 = RES_BGM: tolerance: CS21001FE04
R583 = RES_BGM: tolerance: CS14991FE00
R588 = RES_BGM: tolerance: CS05601FE01
R589 R595 R601 R606 = RES_BGM: tolerance: CS11502FB21
R610 R617 R724 = RES_BGM: tolerance: CS11501FE01
R619 = SHORTPAD_V01_BGM: tolerance: TMPSHT00603
R620 = RES_BGM: tolerance: CS04704JA38
R693 = RES_BGM: tolerance: CS61001JE00
R695 = SHORTPAD_BGM: tolerance: CS00003J951
R707 = RES_BGM: tolerance: CS32202JB28
R715 = RES_BGM: tolerance: CS42002FB12
R749 = RES_BGM: tolerance: CS02201JE00
R757 R758 = RES_BGM: tolerance: CS34991FE02
R808 R809 = RES_BGM: tolerance: CS24702JB38
R841 = RES_BGM: tolerance: CS34532FB18
R842 = RES_BGM: tolerance: CS21502JB16
RV1 RV2 = TPD4E02B04DQAR_BGM: tolerance: BC00176SZ00
RV3 = TVS_DIODE_DUAL_BGM: tolerance: BC005N92Z00
SW1 = SW_4P_BGM: tolerance: DHPT3AL2300
SW2 = SW_6P_BGM: tolerance: DHP00532W00
SW3 = SW_6P_R_BGM: tolerance: DHP000G1A06
TP1-TP34 TP36-TP38 TP41 TP50-TP58 TP60-TP82 TP84-TP97 = TP_BGM
TP35 TP39 TP40 TP42-TP44 TP46-TP48 TP59 = TP_BGM: tolerance: TMPTST00003
TP45 TP49 TP83 TP98-TP101 = TP_BGM: tolerance: *
U1 = RTL8111HSH-CG_BGM: tolerance: AL008111011
U2 U4 U6 U8 = DDR4_96P_BGM: tolerance: AKD5QGST512
U3 = PTN3366BS_BGM: tolerance: *
U5 U11 = LXESEABAA6-046_0: tolerance: BC106506000
U7 = SLGC55544VTR_BGM: tolerance: AL055544000
U9 U10 U29 = 7SH08_0: tolerance: AL001G32009
U12 U14 = NL17SZ08DFT2G_5P_BGM: tolerance: AL17SZ08006
U13 = IT5571E-I-128/CX_128P_BGM: tolerance: AJ055710F01
U15 = NPCT750AAAYX_32P_BGM: tolerance: *
U16 = LIS3DHTR_BGM: tolerance: *
U17 = SN75LVCP601RTJR_BGM: tolerance: ALLVC601000
U18 U25 = M74VHC1GT08DFT2G_5P_BGM: tolerance: AL01GT08011
U19 = Logic_AND_BGM: tolerance: AL17SZ08006
U20 = NL17SZ32DFT2G_BGM: tolerance: AL17SZ32004
U21 = NS680016_0: tolerance: DB0LL1LAN00
U22 = GPU_N16S-GTR_595P_BGM: tolerance: AJ0N17S0T02
U23 = APL3512ABI-TRG_BGM: tolerance: AL003512000
U24 = CPU_ICL_U_1526P_0p8_BGM: tolerance: AJ0QPWAVT00
U26 = 74AUP1G07GW_BGM: tolerance: AL001G07K00
U27 = MC74VHC1G08DFT2G_5P_BGM: tolerance: AL001G08050
U28 = MAX8863_2: tolerance: AL000524007
U30 = ALC255-CG_BGM_0: tolerance: AL000255000
U31 = AP2821KTR-G1_BGM: tolerance: AL003512000
U32 = SST25LF080A_0: tolerance: DG008000012
U33 = SPI_WND_8P_BGM: tolerance: AKE3DF-KN01
U34 = PI2EQX632EXUBE_0: tolerance: AL000632000
U35 = MAX8863_2: tolerance: AL000524009
U36 = TPS25810RVC/SSOP_0: tolerance: AL025810000
VC1 = CAP_NON-POL_BGM: tolerance: CY000220Z00
VRAM1 VRAM2 = GDDR5_170P_BGM: tolerance: AKG5QGUTW34
Y1 = CRYSTAL_4P_BGM: tolerance: BG625000181
Y2 = CRYSTAL_4P_BGM: tolerance: BG627000035
Y3 = CRYSTAL_2P_BGM: tolerance: BG3327680A8
Y4 = CRYSTAL_4P_BGM: tolerance: BG638400018

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2D-BARCODE-6X6-S
  round 0.991 smd: 1(6,-3)
132F18-100000-A2-R-18P-L
  rect 0.305x0.838 smd: 1(-4.25,3.175) 2(-3.75,3.175) 3(-3.25,3.175) 4(-2.75,3.175) 5(-2.25,3.175) 6(-1.75,3.175) 7(-1.25,3.175) 8(-0.75,3.175) 9(-0.25,3.175) 10(0.25,3.175) 11(0.75,3.175) 12(1.25,3.175) 13(1.75,3.175) 14(2.25,3.175) 15(2.75,3.175) 16(3.25,3.175) 17(3.75,3.175) 18(4.25,3.175)
  rect 0.787x2.007 smd: 19(-5.95,0) 20(5.95,0)
50208-00401-V02-4P-L
  rect 0.508x0.991 smd: 1(-1.2,1.95) 2(-0.4,1.95) 3(0.4,1.95) 4(1.2,1.95)
  rect 1.194x1.702 smd: 5(-2.5,0) 6(2.5,0)
50281-00201-001-2P-L
  rect 0.787x2.007 smd: 1(-0.625,4.05) 2(0.625,4.05)
  rect 2.007x2.489 smd: 3(-2.825,0) 4(2.825,0)
50505-00401-V01-4P-L
  rect 0.61x1.295 smd: 1(-1.5,3.25) 2(-0.5,3.25) 3(0.5,3.25) 4(1.5,3.25)
  rect 0.991x2.007 smd: 5(-4.1,0) 6(4.1,0)
50584-0280N-V02-28P-L
  rect 0.61x1.092 smd: 1(-13.5,2.05) 2(-12.5,2.05) 3(-11.5,2.05) 4(-10.5,2.05) 5(-9.5,2.05) 6(-8.5,2.05) 7(-7.5,2.05) 8(-6.5,2.05) 9(-5.5,2.05) 10(-4.5,2.05) 11(-3.5,2.05) 12(-2.5,2.05) 13(-1.5,2.05) 14(-0.5,2.05) 15(0.5,2.05) 16(1.5,2.05) 17(2.5,2.05) 18(3.5,2.05) 19(4.5,2.05) 20(5.5,2.05) 21(6.5,2.05) 22(7.5,2.05) 23(8.5,2.05) 24(9.5,2.05) 25(10.5,2.05) 26(11.5,2.05) 27(12.5,2.05) 28(13.5,2.05)
  rect 2.159x2.997 smd: 29(-15.975,0) 30(15.975,0)
50951-0084N-V01-8P-SOCKET
  rect 0.66x1.346 smd: 1(-1.905,-3.825) 2(-0.635,-3.825) 3(0.635,-3.825) 4(1.905,-3.825) 5(1.905,3.825) 6(0.635,3.825) 7(-0.635,3.825) 8(-1.905,3.825)
51325-00401-001-4P-L
  rect 0.61x1.549 smd: 1(-1.5,3.875) 2(-0.5,3.875) 3(0.5,3.875) 4(1.5,3.875)
  rect 1.194x1.803 smd: 5(-2.8,0) 6(2.8,0)
51614-00601-V01-6P-L
  rect 0.305x0.787 smd: 1(-1.25,2.5) 2(-0.75,2.5) 3(-0.25,2.5) 4(0.25,2.5) 5(0.75,2.5) 6(1.25,2.5)
  rect 0.406x0.787 smd: 7(-2.25,0) 8(2.25,0)
51619-04001-V04-40P-L
  rect 0.305x1.295 smd: 1(-9.75,2.8) 2(-9.25,2.8) 3(-8.75,2.8) 4(-8.25,2.8) 5(-7.75,2.8) 6(-7.25,2.8) 7(-6.75,2.8) 8(-6.25,2.8) 9(-5.75,2.8) 10(-5.25,2.8) 11(-4.75,2.8) 12(-4.25,2.8) 13(-3.75,2.8) 14(-3.25,2.8) 15(-2.75,2.8) 16(-2.25,2.8) 17(-1.75,2.8) 18(-1.25,2.8) 19(-0.75,2.8) 20(-0.25,2.8) 21(0.25,2.8) 22(0.75,2.8) 23(1.25,2.8) 24(1.75,2.8) 25(2.25,2.8) 26(2.75,2.8) 27(3.25,2.8) 28(3.75,2.8) 29(4.25,2.8) 30(4.75,2.8) 31(5.25,2.8) 32(5.75,2.8) 33(6.25,2.8) 34(6.75,2.8) 35(7.25,2.8) 36(7.75,2.8) 37(8.25,2.8) 38(8.75,2.8) 39(9.25,2.8) 40(9.75,2.8)
  rect 1.803x1.397 smd: 41(-11.4,0) 42(11.4,0)
51625-01201-001-12P-L
  rect 0.305x0.838 smd: 1(-2.75,3.555) 2(-2.25,3.555) 3(-1.75,3.555) 4(-1.25,3.555) 5(-0.75,3.555) 6(-0.25,3.555) 7(0.25,3.555) 8(0.75,3.555) 9(1.25,3.555) 10(1.75,3.555) 11(2.25,3.555) 12(2.75,3.555)
  rect 0.991x1.448 smd: 13(-4.54,0) 14(4.54,0)
196047-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-3.5,2.65) 2(-2.5,2.65) 3(-1.5,2.65) 4(-0.5,2.65) 5(0.5,2.65) 6(1.5,2.65) 7(2.5,2.65) 8(3.5,2.65)
  rect 1.803x1.397 smd: 9(-5.65,0) 10(5.65,0)
196241-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-1.75,2.7) 2(-1.25,2.7) 3(-0.75,2.7) 4(-0.25,2.7) 5(0.25,2.7) 6(0.75,2.7) 7(1.25,2.7) 8(1.75,2.7)
  rect 1.854x1.397 smd: 9(-3.425,0) 10(3.425,0)
196538-40041-3-40P-L
  rect 0.305x0.838 smd: 1(-9.75,3.175) 2(-9.25,3.175) 3(-8.75,3.175) 4(-8.25,3.175) 5(-7.75,3.175) 6(-7.25,3.175) 7(-6.75,3.175) 8(-6.25,3.175) 9(-5.75,3.175) 10(-5.25,3.175) 11(-4.75,3.175) 12(-4.25,3.175) 13(-3.75,3.175) 14(-3.25,3.175) 15(-2.75,3.175) 16(-2.25,3.175) 17(-1.75,3.175) 18(-1.25,3.175) 19(-0.75,3.175) 20(-0.25,3.175) 21(0.25,3.175) 22(0.75,3.175) 23(1.25,3.175) 24(1.75,3.175) 25(2.25,3.175) 26(2.75,3.175) 27(3.25,3.175) 28(3.75,3.175) 29(4.25,3.175) 30(4.75,3.175) 31(5.25,3.175) 32(5.75,3.175) 33(6.25,3.175) 34(6.75,3.175) 35(7.25,3.175) 36(7.75,3.175) 37(8.25,3.175) 38(8.75,3.175) 39(9.25,3.175) 40(9.75,3.175)
  rect 0.787x2.007 smd: 41(-11.45,0) 42(11.45,0)
BGA96-MICRON-MT41J64M16JT-187EG
  round 0.356 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
BGA170-HYNIX-H5GQ1H24MJR
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
BGA595-NVIDIA-N13P-GV2-S-A2
  round 0.381 smd: A2(-10.7,-9.9) A3(-10.7,-9.1) A4(-10.7,-8.3) A6(-10.7,-6.6) A7(-10.7,-5.8) A9(-10.7,-4.12) A10(-10.7,-3.32) A12(-10.7,-1.64) A13(-10.7,-0.84) A15(-10.7,0.84) A16(-10.7,1.64) A18(-10.7,3.32) A19(-10.7,4.12) A21(-10.7,5.8) A22(-10.7,6.6) A24(-10.7,8.3) A25(-10.7,9.1) A26(-10.7,9.9) AA1(5.8,-10.7) AA2(5.8,-9.9) AA3(5.8,-9.1) AA4(5.8,-8.3) AA5(5.8,-7.5) AA6(5.8,-6.66) AA7(5.8,-5.8) AA8(5.8,-4.96) AA9(5.86,-4.12) AA10(5.86,-3.32) AA12(5.86,-1.64) AA13(5.86,-0.84) AA14(5.86,0) AA15(5.86,0.84) AA16(5.86,1.64) AA18(5.86,3.32) AA19(5.86,4.12) AA20(5.8,4.96) AA21(5.8,5.8) AA22(5.8,6.66) AA23(5.8,7.5) AA24(5.8,8.3) AA25(5.8,9.1) AA26(5.8,9.9) AA27(5.8,10.7) AB1(6.6,-10.7) AB2(6.6,-9.9) AB3(6.6,-9.1) AB4(6.6,-8.3) AB5(6.6,-7.5) AB6(6.6,-6.6) AB7(6.66,-5.8) AB8(6.66,-4.96) AB9(6.66,-4.12) AB10(6.66,-3.32) AB11(6.66,-2.48) AB12(6.66,-1.64) AB13(6.66,-0.84) AB14(6.66,0) AB15(6.66,0.84) AB16(6.66,1.64) AB17(6.66,2.48) AB18(6.66,3.32) AB19(6.66,4.12) AB20(6.66,4.96) AB21(6.66,5.8) AB22(6.6,6.6) AB23(6.6,7.5) AB24(6.6,8.3) AB25(6.6,9.1) AB26(6.6,9.9) AB27(6.6,10.7) AC2(7.45,-9.9) AC3(7.45,-9.1) AC4(7.45,-8.3) AC5(7.45,-7.45) AC6(7.5,-6.6) AC7(7.5,-5.8) AC8(7.5,-4.96) AC9(7.5,-4.12) AC10(7.5,-3.32) AC11(7.5,-2.48) AC12(7.5,-1.64) AC13(7.5,-0.84) AC14(7.5,0) AC15(7.5,0.84) AC16(7.5,1.64) AC17(7.5,2.48) AC18(7.5,3.32) AC19(7.5,4.12) AC20(7.5,4.96) AC21(7.5,5.8) AC22(7.5,6.6) AC23(7.45,7.45) AC24(7.45,8.3) AC25(7.45,9.1) AC26(7.45,9.9) AD1(8.3,-10.7) AD2(8.3,-9.9) AD3(8.3,-9.1) AD4(8.3,-8.3) AD5(8.3,-7.45) AD6(8.3,-6.6) AD7(8.3,-5.8) AD8(8.3,-4.96) AD9(8.3,-4.12) AD10(8.3,-3.32) AD11(8.3,-2.48) AD12(8.3,-1.64) AD13(8.3,-0.84) AD14(8.3,0) AD15(8.3,0.84) AD16(8.3,1.64) AD17(8.3,2.48) AD18(8.3,3.32) AD19(8.3,4.12) AD20(8.3,4.96) AD21(8.3,5.8) AD22(8.3,6.6) AD23(8.3,7.45) AD24(8.3,8.3) AD25(8.3,9.1) AD26(8.3,9.9) AD27(8.3,10.7) AE1(9.1,-10.7) AE2(9.1,-9.9) AE3(9.1,-9.1) AE4(9.1,-8.3) AE5(9.1,-7.45) AE6(9.1,-6.6) AE7(9.1,-5.8) AE8(9.1,-4.96) AE9(9.1,-4.12) AE10(9.1,-3.32) AE11(9.1,-2.48) AE12(9.1,-1.64) AE13(9.1,-0.84) AE14(9.1,0) AE15(9.1,0.84) AE16(9.1,1.64) AE17(9.1,2.48) AE18(9.1,3.32) AE19(9.1,4.12) AE20(9.1,4.96) AE21(9.1,5.8) AE22(9.1,6.6) AE23(9.1,7.45) AE24(9.1,8.3) AE25(9.1,9.1) AE26(9.1,9.9) AE27(9.1,10.7) AF1(9.9,-10.7) AF2(9.9,-9.9) AF3(9.9,-9.1) AF4(9.9,-8.3) AF5(9.9,-7.45) AF6(9.9,-6.6) AF7(9.9,-5.8) AF8(9.9,-4.96) AF9(9.9,-4.12) AF10(9.9,-3.32) AF11(9.9,-2.48) AF12(9.9,-1.64) AF13(9.9,-0.84) AF14(9.9,0) AF15(9.9,0.84) AF16(9.9,1.64) AF17(9.9,2.48) AF18(9.9,3.32) AF19(9.9,4.12) AF20(9.9,4.96) AF21(9.9,5.8) AF22(9.9,6.6) AF23(9.9,7.45) AF24(9.9,8.3) AF25(9.9,9.1) AF26(9.9,9.9) AF27(9.9,10.7) AG2(10.7,-9.9) AG3(10.7,-9.1) AG4(10.7,-8.3) AG6(10.7,-6.6) AG7(10.7,-5.8) AG9(10.7,-4.12) AG10(10.7,-3.32) AG12(10.7,-1.64) AG13(10.7,-0.84) AG15(10.7,0.84) AG16(10.7,1.64) AG18(10.7,3.32) AG19(10.7,4.12) AG21(10.7,5.8) AG22(10.7,6.6) AG24(10.7,8.3) AG25(10.7,9.1) AG26(10.7,9.9) B1(-9.9,-10.7) B2(-9.9,-9.9) B3(-9.9,-9.1) B4(-9.9,-8.3) B5(-9.9,-7.45) B6(-9.9,-6.6) B7(-9.9,-5.8) B8(-9.9,-4.96) B9(-9.9,-4.12) B10(-9.9,-3.32) B11(-9.9,-2.48) B12(-9.9,-1.64) B13(-9.9,-0.84) B14(-9.9,0) B15(-9.9,0.84) B16(-9.9,1.64) B17(-9.9,2.48) B18(-9.9,3.32) B19(-9.9,4.12) B20(-9.9,4.96) B21(-9.9,5.8) B22(-9.9,6.6) B23(-9.9,7.45) B24(-9.9,8.3) B25(-9.9,9.1) B26(-9.9,9.9) B27(-9.9,10.7) C1(-9.1,-10.7) C2(-9.1,-9.9) C3(-9.1,-9.1) C4(-9.1,-8.3) C5(-9.1,-7.45) C6(-9.1,-6.6) C7(-9.1,-5.8) C8(-9.1,-4.96) C9(-9.1,-4.12) C10(-9.1,-3.32) C11(-9.1,-2.48) C12(-9.1,-1.64) C13(-9.1,-0.84) C14(-9.1,0) C15(-9.1,0.84) C16(-9.1,1.64) C17(-9.1,2.48) C18(-9.1,3.32) C19(-9.1,4.12) C20(-9.1,4.96) C21(-9.1,5.8) C22(-9.1,6.6) C23(-9.1,7.45) C24(-9.1,8.3) C25(-9.1,9.1) C26(-9.1,9.9) C27(-9.1,10.7) D1(-8.3,-10.7) D2(-8.3,-9.9) D3(-8.3,-9.1) D4(-8.3,-8.3) D5(-8.3,-7.45) D6(-8.3,-6.6) D7(-8.3,-5.8) D8(-8.3,-4.96) D9(-8.3,-4.12) D10(-8.3,-3.32) D11(-8.3,-2.48) D12(-8.3,-1.64) D13(-8.3,-0.84) D14(-8.3,0) D15(-8.3,0.84) D16(-8.3,1.64) D17(-8.3,2.48) D18(-8.3,3.32) D19(-8.3,4.12) D20(-8.3,4.96) D21(-8.3,5.8) D22(-8.3,6.6) D23(-8.3,7.45) D24(-8.3,8.3) D25(-8.3,9.1) D26(-8.3,9.9) D27(-8.3,10.7) E2(-7.45,-9.9) E3(-7.45,-9.1) E4(-7.45,-8.3) E5(-7.45,-7.45) E6(-7.5,-6.6) E7(-7.5,-5.8) E8(-7.5,-4.96) E9(-7.5,-4.12) E10(-7.5,-3.32) E11(-7.5,-2.48) E12(-7.5,-1.64) E13(-7.5,-0.84) E14(-7.5,0) E15(-7.5,0.84) E16(-7.5,1.64) E17(-7.5,2.48) E18(-7.5,3.32) E19(-7.5,4.12) E20(-7.5,4.96) E21(-7.5,5.8) E22(-7.5,6.6) E23(-7.45,7.45) E24(-7.45,8.3) E25(-7.45,9.1) E26(-7.45,9.9) F1(-6.6,-10.7) F2(-6.6,-9.9) F3(-6.6,-9.1) F4(-6.6,-8.3) F5(-6.6,-7.5) F6(-6.6,-6.6) F7(-6.66,-5.8) F8(-6.66,-4.96) F9(-6.66,-4.12) F10(-6.66,-3.32) F11(-6.66,-2.48) F12(-6.66,-1.64) F13(-6.66,-0.84) F14(-6.66,0) F15(-6.66,0.84) F16(-6.66,1.64) F17(-6.66,2.48) F18(-6.66,3.32) F19(-6.66,4.12) F20(-6.66,4.96) F21(-6.66,5.8) F22(-6.6,6.6) F23(-6.6,7.5) F24(-6.6,8.3) F25(-6.6,9.1) F26(-6.6,9.9) F27(-6.6,10.7) G1(-5.8,-10.7) G2(-5.8,-9.9) G3(-5.8,-9.1) G4(-5.8,-8.3) G5(-5.8,-7.5) G6(-5.8,-6.66) G7(-5.8,-5.8) G8(-5.8,-4.96) G9(-5.86,-4.12) G10(-5.86,-3.32) G12(-5.86,-1.64) G13(-5.86,-0.84) G14(-5.86,0) G15(-5.86,0.84) G16(-5.86,1.64) G18(-5.86,3.32) G19(-5.86,4.12) G20(-5.8,4.96) G21(-5.8,5.8) G22(-5.8,6.66) G23(-5.8,7.5) G24(-5.8,8.3) G25(-5.8,9.1) G26(-5.8,9.9) G27(-5.8,10.7) H2(-4.96,-9.9) H3(-4.96,-9.1) H4(-4.96,-8.3) H5(-4.96,-7.5) H6(-4.96,-6.66) H22(-4.96,6.66) H23(-4.96,7.5) H24(-4.96,8.3) H25(-4.96,9.1) H26(-4.96,9.9) J1(-4.12,-10.7) J2(-4.12,-9.9) J3(-4.12,-9.1) J4(-4.12,-8.3) J5(-4.12,-7.5) J6(-4.12,-6.66) J7(-4.12,-5.86) J21(-4.12,5.86) J22(-4.12,6.66) J23(-4.12,7.5) J24(-4.12,8.3) J25(-4.12,9.1) J26(-4.12,9.9) J27(-4.12,10.7) K1(-3.32,-10.7) K2(-3.32,-9.9) K3(-3.32,-9.1) K4(-3.32,-8.3) K5(-3.32,-7.5) K6(-3.32,-6.66) K7(-3.32,-5.86) K21(-3.32,5.86) K22(-3.32,6.66) K23(-3.32,7.5) K24(-3.32,8.3) K25(-3.32,9.1) K26(-3.32,9.9) K27(-3.32,10.7) L2(-2.48,-9.9) L3(-2.48,-9.1) L4(-2.48,-8.3) L5(-2.48,-7.5) L6(-2.48,-6.66) L22(-2.48,6.66) L23(-2.48,7.5) L24(-2.48,8.3) L25(-2.48,9.1) L26(-2.48,9.9) M1(-1.64,-10.7) M2(-1.64,-9.9) M3(-1.64,-9.1) M4(-1.64,-8.3) M5(-1.64,-7.5) M6(-1.64,-6.66) M7(-1.64,-5.86) M21(-1.64,5.86) M22(-1.64,6.66) M23(-1.64,7.5) M24(-1.64,8.3) M25(-1.64,9.1) M26(-1.64,9.9) M27(-1.64,10.7) N1(-0.84,-10.7) N2(-0.84,-9.9) N3(-0.84,-9.1) N4(-0.84,-8.3) N5(-0.84,-7.5) N6(-0.84,-6.66) N7(-0.84,-5.86) N21(-0.84,5.86) N22(-0.84,6.66) N23(-0.84,7.5) N24(-0.84,8.3) N25(-0.84,9.1) N26(-0.84,9.9) N27(-0.84,10.7) P2(0,-9.9) P3(0,-9.1) P4(0,-8.3) P5(0,-7.5) P6(0,-6.66) P22(0,6.66) P23(0,7.5) P24(0,8.3) P25(0,9.1) P26(0,9.9) R1(0.84,-10.7) R2(0.84,-9.9) R3(0.84,-9.1) R4(0.84,-8.3) R5(0.84,-7.5) R6(0.84,-6.66) R7(0.84,-5.86) R21(0.84,5.86) R22(0.84,6.66) R23(0.84,7.5) R24(0.84,8.3) R25(0.84,9.1) R26(0.84,9.9) R27(0.84,10.7) T1(1.64,-10.7) T2(1.64,-9.9) T3(1.64,-9.1) T4(1.64,-8.3) T5(1.64,-7.5) T6(1.64,-6.66) T7(1.64,-5.86) T21(1.64,5.86) T22(1.64,6.66) T23(1.64,7.5) T24(1.64,8.3) T25(1.64,9.1) T26(1.64,9.9) T27(1.64,10.7) U2(2.48,-9.9) U3(2.48,-9.1) U4(2.48,-8.3) U5(2.48,-7.5) U6(2.48,-6.66) U22(2.48,6.66) U23(2.48,7.5) U24(2.48,8.3) U25(2.48,9.1) U26(2.48,9.9) V1(3.32,-10.7) V2(3.32,-9.9) V3(3.32,-9.1) V4(3.32,-8.3) V5(3.32,-7.5) V6(3.32,-6.66) V7(3.32,-5.86) V21(3.32,5.86) V22(3.32,6.66) V23(3.32,7.5) V24(3.32,8.3) V25(3.32,9.1) V26(3.32,9.9) V27(3.32,10.7) W1(4.12,-10.7) W2(4.12,-9.9) W3(4.12,-9.1) W4(4.12,-8.3) W5(4.12,-7.5) W6(4.12,-6.66) W7(4.12,-5.86) W21(4.12,5.86) W22(4.12,6.66) W23(4.12,7.5) W24(4.12,8.3) W25(4.12,9.1) W26(4.12,9.9) W27(4.12,10.7) Y2(4.96,-9.9) Y3(4.96,-9.1) Y4(4.96,-8.3) Y5(4.96,-7.5) Y6(4.96,-6.66) Y22(4.96,6.66) Y23(4.96,7.5) Y24(4.96,8.3) Y25(4.96,9.1) Y26(4.96,9.9)
  round 0.4 smd: K10(-4,-4) K11(-4,-3) K12(-4,-2) K13(-4,-1) K14(-4,0) K15(-4,1) K16(-4,2) K17(-4,3) K18(-4,4) L10(-3,-4) L11(-3,-3) L12(-3,-2) L13(-3,-1) L14(-3,0) L15(-3,1) L16(-3,2) L17(-3,3) L18(-3,4) M10(-2,-4) M11(-2,-3) M12(-2,-2) M13(-2,-1) M14(-2,0) M15(-2,1) M16(-2,2) M17(-2,3) M18(-2,4) N10(-1,-4) N11(-1,-3) N12(-1,-2) N13(-1,-1) N14(-1,0) N15(-1,1) N16(-1,2) N17(-1,3) N18(-1,4) P10(0,-4) P11(0,-3) P12(0,-2) P13(0,-1) P14(0,0) P15(0,1) P16(0,2) P17(0,3) P18(0,4) R10(1,-4) R11(1,-3) R12(1,-2) R13(1,-1) R14(1,0) R15(1,1) R16(1,2) R17(1,3) R18(1,4) T10(2,-4) T11(2,-3) T12(2,-2) T13(2,-1) T14(2,0) T15(2,1) T16(2,2) T17(2,3) T18(2,4) U10(3,-4) U11(3,-3) U12(3,-2) U13(3,-1) U14(3,0) U15(3,1) U16(3,2) U17(3,3) U18(3,4) V10(4,-4) V11(4,-3) V12(4,-2) V13(4,-1) V14(4,0) V15(4,1) V16(4,2) V17(4,3) V18(4,4)
BGA1526-INTEL-ICL-U
  round 0.356 smd: A3(-24.365,-10.767) A48(-24.365,11.405) A49(-23.905,11.865) B2(-23.816,-11.309) C1(-23.255,-11.865) DW1(23.905,-11.865) DW2(24.365,-11.405) DW48(24.365,11.405) DW49(23.905,11.865)
  round 0.33 smd: A4(-24.365,-10.117) A47(-24.365,10.755) B3(-23.723,-10.666) B48(-23.737,11.237) C2(-23.172,-11.22) C49(-23.255,11.865) D1(-22.605,-11.865) DE12(17.032,-6.31) DE13(17.032,-5.48) DE15(17.032,-4.65) DE17(17.032,-3.82) DE18(17.032,-2.99) DE20(17.032,-2.16) DE22(17.032,-1.33) DE23(17.032,-0.5) DE26(17.032,0.33) DE28(17.032,1.16) DE29(17.032,1.99) DE31(17.032,2.82) DE33(17.032,3.65) DF12(17.682,-6.31) DF13(17.682,-5.48) DF15(17.682,-4.65) DF17(17.682,-3.82) DF18(17.682,-2.99) DF20(17.682,-2.16) DF22(17.682,-1.33) DF23(17.682,-0.5) DF26(17.682,0.33) DF28(17.682,1.16) DF29(17.682,1.99) DF31(17.682,2.82) DF33(17.682,3.65) DG12(18.332,-6.31) DG13(18.332,-5.48) DG15(18.332,-4.65) DG17(18.332,-3.82) DG18(18.332,-2.99) DG20(18.332,-2.16) DG22(18.332,-1.33) DG23(18.332,-0.5) DG26(18.332,0.33) DG28(18.332,1.16) DG29(18.332,1.99) DG31(18.332,2.82) DG33(18.332,3.65) DU1(23.255,-11.865) DU49(23.255,11.865) DV2(23.737,-11.237) DV48(23.737,11.237) DW3(24.365,-10.755) DW47(24.365,10.755)
  round 0.305 smd: A5(-24.365,-9.467) A7(-24.365,-8.658) A33(-24.365,3.593) A43(-24.365,8.707) A44(-24.365,9.455) A46(-24.365,10.105) AA12(-14.312,-6.127) AA35(-14.311,4.855) AA37(-14.311,5.778) AA45(-14.246,9.59) AA47(-14.246,10.861) AB3(-13.923,-10.893) AB5(-13.923,-9.905) AB6(-13.855,-9.189) AB7(-13.855,-8.539) AB9(-13.855,-7.889) AB10(-13.855,-7.239) AB11(-13.855,-6.589) AB13(-13.855,-5.665) AB34(-13.853,4.393) AB36(-13.853,5.316) AB38(-13.853,6.24) AB39(-13.853,6.89) AB41(-13.853,7.54) AB42(-13.853,8.19) AB43(-13.853,8.84) AB45(-13.626,9.915) AB47(-13.626,10.565) AC3(-13.249,-10.565) AC5(-13.249,-9.915) AC12(-13.397,-6.127) AC35(-13.396,4.855) AC37(-13.396,5.778) AC45(-12.995,9.59) AC46(-12.995,10.241) AD3(-12.686,-10.89) AD4(-12.686,-10.24) AD6(-12.94,-9.189) AD7(-12.94,-8.539) AD9(-12.94,-7.889) AD10(-12.94,-7.239) AD11(-12.94,-6.589) AD34(-12.938,4.393) AD35(-12.481,4.855) AD36(-12.938,5.316) AD37(-12.481,5.778) AD38(-12.938,6.24) AD39(-12.938,6.89) AD41(-12.938,7.54) AD42(-12.938,8.19) AD43(-12.938,8.84) AE3(-12.123,-10.565) AE5(-12.123,-9.915) AE6(-12.025,-9.189) AE7(-12.025,-8.539) AE9(-12.025,-7.889) AE11(-12.025,-6.965) AE36(-12.023,5.316) AE38(-12.023,6.24) AE39(-12.023,6.89) AE41(-12.023,7.54) AE42(-12.023,8.19) AE43(-12.023,8.84) AE45(-12.364,9.915) AE47(-12.364,10.565) AF10(-11.567,-7.427) AF37(-11.566,5.778) AF45(-11.744,9.59) AF47(-11.744,10.861) AG3(-11.449,-10.893) AG5(-11.449,-9.905) AG6(-11.11,-9.189) AG7(-11.11,-8.539) AG9(-11.11,-7.889) AG11(-11.11,-6.965) AG36(-11.108,5.316) AG38(-11.108,6.24) AG39(-11.108,6.89) AG41(-11.108,7.54) AG42(-11.108,8.19) AG43(-11.108,8.84) AG45(-11.124,9.915) AG47(-11.124,10.565) AH10(-10.652,-7.427) AH37(-10.651,5.778) AH45(-10.493,9.59) AH46(-10.493,10.241) AJ3(-10.195,-10.489) AJ5(-10.195,-9.839) AJ6(-10.195,-9.189) AJ7(-10.195,-8.539) AJ9(-10.195,-7.889) AJ11(-10.195,-6.965) AJ36(-10.193,5.316) AJ38(-10.193,6.24) AJ39(-10.193,6.89) AJ41(-10.193,7.54) AJ42(-10.193,8.19) AJ43(-10.193,8.84) AK10(-9.737,-7.427) AK37(-9.736,5.778) AK45(-9.862,9.915) AK47(-9.862,10.565) AL3(-9.28,-10.489) AL5(-9.28,-9.839) AL6(-9.28,-9.189) AL7(-9.28,-8.539) AL9(-9.28,-7.889) AL11(-9.28,-6.965) AL36(-9.278,5.316) AL38(-9.278,6.24) AL39(-9.278,6.89) AL41(-9.278,7.54) AL42(-9.278,8.19) AL43(-9.278,8.84) AL45(-9.242,9.59) AL47(-9.242,10.861) AM10(-8.822,-7.427) AM37(-8.821,5.778) AM45(-8.622,9.915) AM47(-8.622,10.565) AN3(-8.365,-10.489) AN5(-8.365,-9.839) AN6(-8.365,-9.189) AN7(-8.365,-8.539) AN9(-8.365,-7.889) AN11(-8.365,-6.965) AN36(-8.363,5.316) AN38(-8.363,6.24) AN39(-8.363,6.89) AN41(-8.363,7.54) AN42(-8.363,8.19) AN43(-8.363,8.84) AN45(-7.991,9.59) AN46(-7.991,10.241) AP10(-7.907,-7.427) AP37(-7.906,5.778) AR3(-7.45,-10.489) AR5(-7.45,-9.839) AR6(-7.45,-9.189) AR7(-7.45,-8.539) AR9(-7.45,-7.889) AR10(-6.992,-7.427) AR11(-7.45,-6.965) AR36(-7.448,5.316) AR37(-6.991,5.778) AR38(-7.448,6.24) AR39(-7.448,6.89) AR41(-7.448,7.54) AR42(-7.448,8.19) AR43(-7.448,8.84) AR45(-7.36,9.915) AR47(-7.36,10.565) AT3(-6.535,-10.489) AT5(-6.535,-9.839) AT6(-6.535,-9.189) AT7(-6.535,-8.539) AT9(-6.535,-7.889) AT11(-6.535,-6.965) AT36(-6.533,5.316) AT38(-6.533,6.24) AT39(-6.533,6.89) AT41(-6.533,7.54) AT42(-6.533,8.19) AT43(-6.533,8.84) AT45(-6.74,9.59) AT47(-6.74,10.861) AU10(-6.077,-7.427) AU37(-6.076,5.778) AU45(-6.12,9.915) AU47(-6.12,10.565) AV3(-5.62,-10.489) AV5(-5.62,-9.839) AV6(-5.62,-9.189) AV7(-5.62,-8.539) AV9(-5.62,-7.889) AV11(-5.62,-6.965) AV36(-5.618,5.316) AV38(-5.618,6.24) AV39(-5.618,6.89) AV41(-5.618,7.54) AV42(-5.618,8.19) AV43(-5.618,8.84) AV45(-5.489,9.59) AV46(-5.489,10.241) AW10(-5.162,-7.427) AW37(-5.161,5.778) AY3(-4.705,-10.489) AY5(-4.705,-9.839) AY6(-4.705,-9.189) AY7(-4.705,-8.539) AY9(-4.705,-7.889) AY11(-4.705,-6.965) AY36(-4.703,5.316) AY38(-4.703,6.24) AY39(-4.703,6.89) AY41(-4.703,7.54) AY42(-4.703,8.19) AY43(-4.703,8.84) AY45(-4.858,9.915) AY47(-4.858,10.565) B4(-23.723,-10.016) B7(-23.715,-8.658) B33(-23.715,3.593) B43(-23.715,8.707) B45(-23.577,9.956) B47(-23.737,10.587) BA10(-4.247,-7.427) BA37(-4.246,5.778) BA45(-4.238,9.59) BA47(-4.238,10.861) BB3(-3.79,-10.489) BB5(-3.79,-9.839) BB6(-3.79,-9.189) BB7(-3.79,-8.539) BB9(-3.79,-7.889) BB11(-3.79,-6.965) BB36(-3.788,5.316) BB38(-3.788,6.24) BB39(-3.788,6.89) BB41(-3.788,7.54) BB42(-3.788,8.19) BB43(-3.788,8.84) BB45(-3.618,9.915) BB47(-3.618,10.565) BC10(-3.332,-7.427) BC37(-3.331,5.778) BD3(-2.875,-10.489) BD5(-2.875,-9.839) BD6(-2.875,-9.189) BD7(-2.875,-8.539) BD9(-2.875,-7.889) BD11(-2.875,-6.965) BD36(-2.873,5.316) BD38(-2.873,6.24) BD39(-2.873,6.89) BD41(-2.873,7.54) BD42(-2.873,8.19) BD43(-2.873,8.84) BD45(-2.987,9.59) BD46(-2.987,10.241) BE10(-2.417,-7.427) BE37(-2.416,5.778) BE45(-2.356,9.915) BE47(-2.356,10.565) BF3(-1.96,-10.489) BF5(-1.96,-9.839) BF6(-1.96,-9.189) BF7(-1.96,-8.539) BF9(-1.96,-7.889) BF10(-1.502,-7.427) BF11(-1.96,-6.965) BF36(-1.958,5.316) BF37(-1.501,5.778) BF38(-1.958,6.24) BF39(-1.958,6.89) BF41(-1.958,7.54) BF42(-1.958,8.19) BF43(-1.958,8.84) BF45(-1.736,9.59) BF47(-1.736,10.861) BG3(-1.045,-10.489) BG5(-1.045,-9.839) BG6(-1.045,-9.189) BG7(-1.045,-8.539) BG9(-1.045,-7.889) BG11(-1.045,-6.965) BG36(-1.043,5.316) BG38(-1.043,6.24) BG39(-1.043,6.89) BG41(-1.043,7.54) BG42(-1.043,8.19) BG43(-1.043,8.84) BG45(-1.116,9.915) BG47(-1.116,10.565) BH10(-0.587,-7.427) BH37(-0.586,5.778) BJ3(-0.13,-10.489) BJ5(-0.13,-9.839) BJ6(-0.13,-9.189) BJ7(-0.13,-8.539) BJ9(-0.13,-7.889) BJ11(-0.13,-6.965) BJ36(-0.128,5.316) BJ38(-0.128,6.24) BJ39(-0.128,6.89) BJ41(-0.128,7.54) BJ42(-0.128,8.19) BJ43(-0.128,8.84) BJ45(-0.485,9.59) BJ46(-0.485,10.241) BL10(0.328,-7.427) BL37(0.33,5.778) BL45(0.146,9.915) BL47(0.146,10.565) BM3(0.786,-10.489) BM5(0.786,-9.839) BM6(0.786,-9.189) BM7(0.786,-8.539) BM9(0.786,-7.889) BM11(0.786,-6.965) BM36(0.787,5.316) BM38(0.787,6.24) BM39(0.787,6.89) BM41(0.787,7.54) BM42(0.787,8.19) BM43(0.787,8.84) BM45(0.766,9.59) BM47(0.766,10.861) BN10(1.243,-7.427) BN37(1.245,5.778) BN45(1.386,9.915) BN47(1.386,10.565) BP3(1.701,-10.489) BP5(1.701,-9.839) BP6(1.701,-9.189) BP7(1.701,-8.539) BP9(1.701,-7.889) BP11(1.701,-6.965) BP36(1.702,5.316) BP38(1.702,6.24) BP39(1.702,6.89) BP41(1.702,7.54) BP42(1.702,8.19) BP43(1.702,8.84) BR10(2.158,-7.427) BR37(2.16,5.778) BR45(2.017,9.59) BR46(2.017,10.241) BT3(2.616,-10.489) BT5(2.616,-9.839) BT6(2.616,-9.189) BT7(2.616,-8.539) BT9(2.616,-7.889) BT11(2.616,-6.965) BT36(2.617,5.316) BT38(2.617,6.24) BT39(2.617,6.89) BT41(2.617,7.54) BT42(2.617,8.19) BT43(2.617,8.84) BT45(2.648,9.915) BT47(2.648,10.565) BU10(3.073,-7.427) BU37(3.075,5.778) BU45(3.268,9.59) BU47(3.268,10.861) BV3(3.531,-10.489) BV5(3.531,-9.839) BV6(3.531,-9.189) BV7(3.531,-8.539) BV9(3.531,-7.889) BV11(3.531,-6.965) BV36(3.532,5.316) BV38(3.532,6.24) BV39(3.532,6.89) BV41(3.532,7.54) BV42(3.532,8.19) BV43(3.532,8.84) BV45(3.888,9.915) BV47(3.888,10.565) BW3(4.446,-10.489) BW5(4.446,-9.839) BW6(4.446,-9.189) BW7(4.446,-8.539) BW9(4.446,-7.889) BW10(3.988,-7.427) BW11(4.446,-6.965) BW36(4.447,5.316) BW37(3.99,5.778) BW38(4.447,6.24) BW39(4.447,6.89) BW41(4.447,7.54) BW42(4.447,8.19) BW43(4.447,8.84) BY10(4.903,-7.427) BY37(4.905,5.778) BY45(4.519,9.59) BY46(4.519,10.241) C3(-23.079,-10.577) C5(-23.079,-9.927) C6(-23.393,-9.332) C7(-23.065,-8.658) C8(-23.39,-8.095) C9(-23.065,-7.532) C11(-23.393,-6.858) C12(-23.065,-6.184) C13(-23.39,-5.621) C14(-23.065,-5.058) C16(-23.393,-4.384) C33(-23.065,3.593) C34(-23.361,4.176) C35(-23.065,4.795) C38(-23.065,6.077) C39(-23.361,6.73) C40(-23.065,7.383) C43(-23.065,8.707) C44(-23.359,9.336) C47(-23.087,10.479) C48(-23.087,11.234) CA3(5.361,-10.489) CA5(5.361,-9.839) CA6(5.361,-9.189) CA7(5.361,-8.539) CA9(5.361,-7.889) CA11(5.361,-6.965) CA36(5.362,5.316) CA38(5.362,6.24) CA39(5.362,6.89) CA41(5.362,7.54) CA42(5.362,8.19) CA43(5.362,8.84) CA45(5.15,9.915) CA47(5.15,10.565) CB10(5.818,-7.427) CB37(5.82,5.778) CB45(5.77,9.59) CB47(5.77,10.861) CC3(6.149,-10.893) CC5(6.149,-9.905) CC6(6.276,-9.189) CC7(6.276,-8.539) CC9(6.276,-7.889) CC11(6.276,-6.965) CC36(6.277,5.316) CC38(6.277,6.24) CC39(6.277,6.89) CC41(6.277,7.54) CC42(6.277,8.19) CC43(6.277,8.84) CC45(6.39,9.915) CC47(6.39,10.565) CD3(6.823,-10.565) CD5(6.823,-9.915) CD10(6.733,-7.427) CE3(7.386,-10.89) CE4(7.386,-10.24) CE6(7.191,-9.189) CE7(7.191,-8.539) CE9(7.191,-7.889) CE11(7.191,-6.965) CE34(7.192,4.29) CE35(7.192,4.94) CE37(7.192,5.59) CE38(7.192,6.24) CE39(7.192,6.89) CE41(7.192,7.54) CE42(7.192,8.19) CE43(7.192,8.84) CE45(7.021,9.59) CE46(7.021,10.241) CF3(7.949,-10.565) CF5(7.949,-9.915) CF10(7.648,-7.427) CF33(7.65,3.828) CF45(7.652,9.915) CF47(7.652,10.565) CG6(8.106,-9.189) CG7(8.106,-8.539) CG9(8.106,-7.889) CG11(8.106,-6.965) CG32(8.107,3.366) CG34(8.107,4.29) CG35(8.107,4.94) CG37(8.107,5.59) CG38(8.107,6.24) CG39(8.107,6.89) CG41(8.107,7.54) CG42(8.107,8.19) CG43(8.107,8.84) CG45(8.272,9.59) CG47(8.272,10.861) CH3(8.623,-10.893) CH5(8.623,-9.905) CH10(8.563,-7.427) CH33(8.689,3.828) CH45(8.892,9.915) CH47(8.892,10.565) CJ3(9.297,-10.565) CJ5(9.297,-9.915) CJ6(9.021,-9.189) CJ7(9.021,-8.539) CJ9(9.021,-7.889) CJ11(9.021,-6.965) CJ32(9.272,3.366) CJ34(9.272,4.29) CJ35(9.272,4.94) CJ37(9.272,5.59) CJ38(9.272,6.24) CJ39(9.272,6.89) CJ41(9.272,7.54) CJ42(9.272,8.19) CJ43(9.272,8.84) CK3(9.86,-10.89) CK4(9.86,-10.24) CK6(9.936,-9.189) CK7(9.936,-8.539) CK9(9.936,-7.889) CK10(9.478,-7.427) CK11(9.936,-6.965) CK33(9.73,3.828) CK45(9.523,9.59) CK46(9.523,10.241) CL3(10.423,-10.565) CL5(10.423,-9.915) CL10(10.393,-7.427) CL32(10.187,3.366) CL34(10.187,4.29) CL35(10.187,4.94) CL37(10.187,5.59) CL38(10.187,6.24) CL39(10.187,6.89) CL41(10.187,7.54) CL42(10.187,8.19) CL43(10.187,8.84) CL45(10.154,9.915) CL47(10.154,10.565) CM6(10.851,-9.189) CM7(10.851,-8.539) CM9(10.851,-7.889) CM11(10.851,-6.965) CM33(10.645,3.828) CM45(10.774,9.59) CM47(10.774,10.861) CN3(11.097,-10.893) CN5(11.097,-9.905) CN10(11.308,-7.427) CN32(11.102,3.366) CN34(11.102,4.29) CN35(11.102,4.94) CN37(11.102,5.59) CN38(11.102,6.24) CN39(11.102,6.89) CN41(11.102,7.54) CN42(11.102,8.19) CN43(11.102,8.84) CN45(11.394,9.915) CN47(11.394,10.565) CP3(11.771,-10.565) CP5(11.771,-9.915) CP6(11.766,-9.189) CP7(11.766,-8.539) CP9(11.766,-7.889) CP11(11.766,-6.965) CP33(11.56,3.828) CR3(12.334,-10.89) CR4(12.334,-10.24) CR10(12.223,-7.427) CR32(12.017,3.366) CR34(12.017,4.29) CR35(12.017,4.94) CR37(12.017,5.59) CR38(12.017,6.24) CR39(12.017,6.89) CR41(12.017,7.54) CR42(12.017,8.19) CR43(12.017,8.84) CR45(12.025,9.59) CR46(12.025,10.241) CT3(12.897,-10.565) CT5(12.897,-9.915) CT6(12.681,-9.189) CT7(12.681,-8.539) CT9(12.681,-7.889) CT11(12.681,-6.965) CT32(12.932,3.366) CT33(12.475,3.828) CT34(12.932,4.29) CT35(12.932,4.94) CT37(12.932,5.59) CT38(12.932,6.24) CT39(12.932,6.89) CT41(12.932,7.54) CT42(12.932,8.19) CT43(12.932,8.84) CT45(12.656,9.915) CT47(12.656,10.565) CU10(13.138,-7.427) CU33(13.39,3.828) CU45(13.276,9.59) CU47(13.276,10.861) CV3(13.571,-10.893) CV5(13.571,-9.905) CV6(13.596,-9.189) CV7(13.596,-8.539) CV9(13.596,-7.889) CV11(13.596,-6.965) CV32(13.847,3.366) CV34(13.847,4.29) CV35(13.847,4.94) CV37(13.847,5.59) CV38(13.847,6.24) CV39(13.847,6.89) CV41(13.847,7.54) CV42(13.847,8.19) CV43(13.847,8.84) CV45(13.896,9.915) CV47(13.896,10.565) CW3(14.245,-10.565) CW5(14.245,-9.915) CW10(14.053,-7.427) CW33(14.305,3.828) CY3(14.808,-10.89) CY4(14.808,-10.24) CY6(14.511,-9.189) CY7(14.511,-8.539) CY9(14.511,-7.889) CY11(14.511,-6.965) CY32(14.762,3.366) CY34(14.762,4.29) CY35(14.762,4.94) CY37(14.762,5.59) CY38(14.762,6.24) CY39(14.762,6.89) CY41(14.762,7.54) CY42(14.762,8.19) CY43(14.762,8.84) CY45(14.527,9.59) CY46(14.527,10.241) D2(-22.522,-11.22) D4(-22.459,-10.381) D7(-22.415,-8.658) D8(-22.74,-8.095) D9(-22.415,-7.532) D12(-22.415,-6.184) D13(-22.74,-5.621) D14(-22.415,-5.058) D33(-22.415,3.593) D35(-22.415,4.795) D36(-22.741,5.424) D38(-22.415,6.077) D40(-22.415,7.383) D42(-22.741,8.036) D43(-22.415,8.707) D44(-22.492,9.354) D47(-22.545,10.866) D49(-22.605,11.865) DA3(15.371,-10.565) DA5(15.371,-9.915) DA6(15.426,-9.189) DA7(15.426,-8.539) DA9(15.426,-7.889) DA10(14.968,-7.427) DA11(15.426,-6.965) DA33(15.22,3.828) DA45(15.158,9.915) DA47(15.158,10.565) DB10(15.883,-7.427) DB32(15.677,3.366) DB34(15.677,4.29) DB35(15.677,4.94) DB37(15.677,5.59) DB38(15.677,6.24) DB39(15.677,6.89) DB41(15.677,7.54) DB42(15.677,8.19) DB43(15.677,8.84) DB45(15.778,9.59) DB47(15.778,10.861) DC3(16.045,-10.893) DC5(16.045,-9.905) DC6(16.341,-9.189) DC7(16.341,-8.539) DC9(16.341,-7.889) DC11(16.341,-6.965) DC33(16.135,3.828) DC45(16.398,9.915) DC47(16.398,10.565) DD3(16.719,-10.565) DD5(16.719,-9.915) DD34(16.592,4.29) DD35(16.592,4.94) DD37(16.592,5.59) DD38(16.592,6.24) DD39(16.592,6.89) DD41(16.592,7.54) DD42(16.592,8.19) DD43(16.592,8.84) DE3(17.282,-10.89) DE4(17.282,-10.24) DE6(17.256,-9.189) DE7(17.256,-8.539) DE9(17.256,-7.889) DE10(17.256,-7.239) DE45(17.029,9.59) DE46(17.029,10.241) DF3(17.845,-10.565) DF5(17.845,-9.915) DF34(17.507,4.29) DF35(17.507,4.94) DF37(17.507,5.59) DF38(17.507,6.24) DF39(17.507,6.89) DF41(17.507,7.54) DF42(17.507,8.19) DF43(17.507,8.84) DF45(17.66,9.915) DF47(17.66,10.565) DG6(18.171,-9.189) DG7(18.171,-8.539) DG9(18.171,-7.889) DG10(18.171,-7.239) DG34(18.332,4.476) DG36(18.332,5.391) DG38(18.332,6.306) DG40(18.332,7.221) DG42(18.332,8.136) DG44(18.332,9.051) DG47(18.288,10.861) DH3(18.519,-10.893) DH5(18.519,-9.905) DH45(18.871,9.915) DH47(18.871,10.565) DJ3(19.193,-10.565) DJ5(19.193,-9.915) DJ6(18.982,-9.249) DJ8(18.982,-8.334) DJ10(18.982,-7.419) DJ11(18.982,-6.504) DJ13(18.982,-5.589) DJ15(18.982,-4.674) DJ17(18.982,-3.759) DJ19(18.982,-2.844) DJ21(18.982,-1.929) DJ22(18.982,-1.014) DJ24(18.982,-0.099) DJ27(18.982,0.816) DJ29(18.982,1.731) DJ31(18.982,2.646) DJ33(18.982,3.561) DJ34(18.982,4.476) DJ36(18.982,5.391) DJ38(18.982,6.306) DJ40(18.982,7.221) DJ42(18.982,8.136) DJ44(18.982,9.051) DK3(19.756,-10.89) DK4(19.756,-10.24) DK6(19.632,-9.249) DK8(19.632,-8.334) DK10(19.632,-7.419) DK11(19.632,-6.504) DK13(19.632,-5.589) DK15(19.632,-4.674) DK17(19.632,-3.759) DK19(19.632,-2.844) DK21(19.632,-1.929) DK22(19.632,-1.014) DK24(19.632,-0.099) DK27(19.632,0.816) DK29(19.632,1.731) DK31(19.632,2.646) DK33(19.632,3.561) DK34(19.632,4.476) DK36(19.632,5.391) DK38(19.632,6.306) DK40(19.632,7.221) DK42(19.632,8.136) DK44(19.632,9.051) DK46(19.524,10.24) DL3(20.319,-10.565) DL5(20.319,-9.915) DL6(20.282,-9.249) DL8(20.282,-8.334) DL10(20.282,-7.419) DL11(20.282,-6.504) DL13(20.282,-5.589) DL15(20.282,-4.674) DL17(20.282,-3.759) DL19(20.282,-2.844) DL21(20.282,-1.929) DL22(20.282,-1.014) DL24(20.282,-0.099) DL27(20.282,0.816) DL29(20.282,1.731) DL31(20.282,2.646) DL33(20.282,3.561) DL34(20.282,4.476) DL36(20.282,5.391) DL38(20.282,6.306) DL40(20.282,7.221) DL42(20.282,8.136) DL44(20.282,9.051) DL45(20.177,9.915) DL47(20.177,10.565) DN3(20.993,-10.893) DN5(20.993,-9.905) DN6(20.932,-9.249) DN8(20.932,-8.334) DN10(20.932,-7.419) DN11(20.932,-6.504) DN13(20.932,-5.589) DN15(20.932,-4.674) DN17(20.932,-3.759) DN19(20.932,-2.844) DN21(20.932,-1.929) DN22(20.932,-1.014) DN24(20.932,-0.099) DN27(20.932,0.816) DN29(20.932,1.731) DN31(20.932,2.646) DN33(20.932,3.561) DN34(20.932,4.476) DN36(20.932,5.391) DN38(20.932,6.306) DN40(20.932,7.221) DN42(20.932,8.136) DN44(20.932,9.051) DN47(21.305,10.565) DP1(21.667,-11.865) DP3(21.667,-10.565) DP5(21.667,-9.915) DP6(21.582,-9.249) DP8(21.582,-8.334) DP10(21.582,-7.419) DP11(21.582,-6.504) DP13(21.582,-5.589) DP15(21.582,-4.674) DP17(21.582,-3.759) DP19(21.582,-2.844) DP21(21.582,-1.929) DP22(21.582,-1.014) DP24(21.582,-0.099) DP27(21.582,0.816) DP29(21.582,1.731) DP31(21.582,2.646) DP33(21.582,3.561) DP34(21.582,4.476) DP36(21.582,5.391) DP38(21.582,6.306) DP40(21.582,7.221) DP42(21.582,8.136) DP44(21.582,9.051) DP45(21.629,9.915) DR5(22.316,-9.948) DR47(21.955,10.565) DR48(21.955,11.215) DR49(21.955,11.865) DT1(22.605,-11.865) DT2(22.437,-11.237) DT3(22.437,-10.587) DT6(22.415,-9.306) DT7(22.74,-8.67) DT8(22.415,-8.017) DT10(22.415,-7.36) DT11(22.415,-6.703) DT12(22.74,-6.05) DT14(22.415,-5.397) DT15(22.415,-4.74) DT16(22.415,-4.083) DT18(22.74,-3.43) DT19(22.415,-2.777) DT20(22.415,-2.12) DT22(22.415,-1.463) DT23(22.74,-0.81) DT24(22.415,-0.157) DT27(22.415,0.5) DT28(22.415,1.157) DT29(22.74,1.81) DT30(22.415,2.463) DT32(22.415,3.12) DT33(22.415,3.777) DT34(22.74,4.43) DT36(22.415,5.083) DT37(22.415,5.74) DT38(22.415,6.397) DT40(22.74,7.05) DT41(22.415,7.703) DT42(22.415,8.36) DT44(22.416,9.026) DT45(22.48,9.676) DT47(22.527,10.906) DT49(22.605,11.865) DU2(23.087,-11.237) DU3(23.087,-10.587) DU6(23.065,-9.323) DU10(23.39,-7.36) DU15(23.39,-4.74) DU20(23.39,-2.12) DU27(23.39,0.5) DU32(23.39,3.12) DU37(23.39,5.74) DU42(23.39,8.36) DU44(23.066,9.026) DU45(23.13,9.676) DU47(23.084,10.566) DU48(23.087,11.236) DV3(23.737,-10.587) DV4(23.41,-10.023) DV6(23.715,-9.426) DV44(23.716,9.026) DV45(23.733,9.936) DV47(23.734,10.586) DW4(24.365,-10.105) DW6(24.365,-9.426) DW44(24.366,9.026) DW46(24.365,10.105) E1(-21.955,-11.865) E3(-21.994,-10.836) E5(-22.002,-9.87) E6(-22.4,-9.332) E11(-22.4,-6.858) E16(-22.4,-4.384) E34(-22.091,4.176) E36(-22.091,5.424) E39(-22.091,6.73) E42(-22.091,8.036) E46(-22.394,10.226) E48(-22.101,11.43) F6(-21.697,-9.282) F8(-21.697,-8.367) F10(-21.697,-7.452) F11(-21.697,-6.537) F13(-21.697,-5.622) F15(-21.697,-4.707) F17(-21.765,-3.728) F33(-21.765,3.593) F45(-21.874,9.59) F47(-21.89,10.809) G1(-21.379,-11.542) G3(-21.346,-10.893) G5(-21.346,-9.905) G6(-21.047,-9.282) G8(-21.047,-8.367) G10(-21.047,-7.452) G11(-21.047,-6.537) G13(-21.047,-5.622) G15(-21.047,-4.707) G17(-21.115,-3.728) G33(-21.115,3.593) G34(-21.344,4.404) G36(-21.344,5.319) G38(-21.173,6.24) G39(-21.173,6.89) G41(-21.173,7.54) G42(-21.173,8.19) G43(-21.173,8.84) G45(-21.259,9.915) G47(-21.259,10.565) G48(-21.314,11.215) G49(-21.314,11.865) H1(-20.671,-11.865) H3(-20.671,-10.565) H5(-20.671,-9.915) H17(-20.465,-3.728) H33(-20.465,3.593) H34(-20.694,4.404) H36(-20.694,5.319) H45(-20.641,9.59) H46(-20.641,10.24) J3(-20.108,-10.89) J4(-20.108,-10.24) J6(-20.397,-9.282) J8(-20.397,-8.367) J10(-20.397,-7.452) J11(-20.397,-6.537) J13(-20.397,-5.622) J15(-20.397,-4.707) J16(-20.003,-4.185) J18(-20.003,-3.27) J20(-20.003,-2.355) J22(-20.003,-1.44) J23(-20.003,-0.525) J26(-20.003,0.39) J28(-20.003,1.305) J30(-20.003,2.22) J32(-20.003,3.135) J34(-20.044,4.404) J36(-20.044,5.319) J38(-20.258,6.24) J39(-20.258,6.89) J41(-20.258,7.54) J42(-20.258,8.19) J43(-20.258,8.84) J45(-19.988,9.915) J47(-19.988,10.565) K3(-19.545,-10.565) K5(-19.545,-9.915) K6(-19.747,-9.282) K8(-19.747,-8.367) K10(-19.747,-7.452) K11(-19.747,-6.537) K13(-19.747,-5.622) K15(-19.541,-4.643) K17(-19.541,-3.728) K19(-19.541,-2.813) K21(-19.541,-1.898) K23(-19.541,-0.983) K24(-19.541,-0.068) K27(-19.541,0.848) K29(-19.541,1.763) K31(-19.541,2.678) K33(-19.541,3.593) L6(-19.097,-9.282) L8(-19.097,-8.367) L10(-19.097,-7.452) L11(-19.097,-6.537) L13(-19.097,-5.622) L34(-19.394,4.404) L36(-19.394,5.319) L38(-19.343,6.24) L39(-19.343,6.89) L41(-19.343,7.54) L42(-19.343,8.19) L43(-19.343,8.84) L45(-19.335,9.59) L47(-19.335,10.861) M3(-18.871,-10.893) M5(-18.871,-9.905) M6(-18.447,-9.282) M8(-18.447,-8.367) M10(-18.447,-7.452) M11(-18.447,-6.537) M13(-18.447,-5.622) M34(-18.744,4.404) M36(-18.744,5.319) M38(-18.428,6.24) M39(-18.428,6.89) M41(-18.428,7.54) M42(-18.428,8.19) M43(-18.428,8.84) M45(-18.682,9.915) M47(-18.682,10.565) N3(-18.197,-10.565) N5(-18.197,-9.915) N34(-18.094,4.404) N36(-18.094,5.319) N45(-18.029,9.59) N46(-18.029,10.24) P3(-17.634,-10.89) P4(-17.634,-10.24) P6(-17.797,-9.282) P8(-17.797,-8.367) P10(-17.797,-7.452) P11(-17.797,-6.537) P13(-17.797,-5.622) P38(-17.513,6.24) P39(-17.513,6.89) P41(-17.513,7.54) P42(-17.513,8.19) P43(-17.513,8.84) R3(-17.071,-10.565) R5(-17.071,-9.915) R12(-17.057,-6.127) R35(-17.056,4.855) R37(-17.056,5.778) R45(-17.376,9.915) R47(-17.376,10.565) T6(-16.6,-9.189) T7(-16.6,-8.539) T9(-16.6,-7.889) T10(-16.6,-7.239) T11(-16.6,-6.589) T13(-16.6,-5.665) T34(-16.598,4.393) T36(-16.598,5.316) T38(-16.598,6.24) T39(-16.598,6.89) T41(-16.598,7.54) T42(-16.598,8.19) T43(-16.598,8.84) T45(-16.748,9.59) T47(-16.748,10.861) U3(-16.397,-10.893) U5(-16.397,-9.905) U12(-16.142,-6.127) U35(-16.141,4.855) U37(-16.141,5.778) U45(-16.128,9.915) U47(-16.128,10.565) V3(-15.723,-10.565) V5(-15.723,-9.915) V6(-15.685,-9.189) V7(-15.685,-8.539) V9(-15.685,-7.889) V10(-15.685,-7.239) V11(-15.685,-6.589) V13(-15.685,-5.665) V34(-15.683,4.393) V36(-15.683,5.316) V38(-15.683,6.24) V39(-15.683,6.89) V41(-15.683,7.54) V42(-15.683,8.19) V43(-15.683,8.84) V45(-15.497,9.59) V46(-15.497,10.241) W3(-15.16,-10.89) W4(-15.16,-10.24) W12(-15.227,-6.127) W35(-15.226,4.855) W37(-15.226,5.778) Y3(-14.597,-10.565) Y5(-14.597,-9.915) Y6(-14.77,-9.189) Y7(-14.77,-8.539) Y9(-14.77,-7.889) Y10(-14.77,-7.239) Y11(-14.77,-6.589) Y13(-14.77,-5.665) Y34(-14.768,4.393) Y36(-14.768,5.316) Y38(-14.768,6.24) Y39(-14.768,6.89) Y41(-14.768,7.54) Y42(-14.768,8.19) Y43(-14.768,8.84) Y45(-14.866,9.915) Y47(-14.866,10.565)
  oval 0.33x0.254 smd: A9(-24.365,-7.532) A11(-24.043,-6.858) A12(-24.365,-6.184) A14(-24.365,-5.058) A16(-24.043,-4.384) A36(-24.041,5.424) A38(-24.365,6.077) A39(-24.041,6.73) A40(-24.365,7.383) A42(-24.041,8.036) B9(-23.715,-7.532) B12(-23.715,-6.184) B14(-23.715,-5.058) B38(-23.715,6.077) B40(-23.715,7.383) C36(-23.391,5.424) C42(-23.391,8.036) DU7(23.39,-8.67) DU8(23.065,-8.017) DU11(23.065,-6.703) DU12(23.39,-6.05) DU14(23.065,-5.397) DU16(23.065,-4.083) DU18(23.39,-3.43) DU19(23.065,-2.777) DU22(23.065,-1.463) DU23(23.39,-0.81) DU24(23.065,-0.157) DU28(23.065,1.157) DU29(23.39,1.81) DU30(23.065,2.463) DU33(23.065,3.777) DU34(23.39,4.43) DU36(23.065,5.083) DU38(23.065,6.397) DU40(23.39,7.05) DU41(23.065,7.703) DV8(23.715,-8.017) DV11(23.715,-6.703) DV14(23.715,-5.397) DV16(23.715,-4.083) DV19(23.715,-2.777) DV22(23.715,-1.463) DV24(23.715,-0.157) DV28(23.715,1.157) DV30(23.715,2.463) DV33(23.715,3.777) DV36(23.715,5.083) DV38(23.715,6.397) DV41(23.715,7.703) DW7(24.04,-8.67) DW8(24.365,-8.017) DW10(24.04,-7.36) DW11(24.365,-6.703) DW12(24.04,-6.05) DW14(24.365,-5.397) DW15(24.04,-4.74) DW16(24.365,-4.083) DW18(24.04,-3.43) DW19(24.365,-2.777) DW20(24.04,-2.12) DW22(24.365,-1.463) DW23(24.04,-0.81) DW24(24.365,-0.157) DW27(24.04,0.5) DW28(24.365,1.157) DW29(24.04,1.81) DW30(24.365,2.463) DW32(24.04,3.12) DW33(24.365,3.777) DW34(24.04,4.43) DW36(24.365,5.083) DW37(24.04,5.74) DW38(24.365,6.397) DW40(24.04,7.05) DW41(24.365,7.703) DW42(24.04,8.36)
  round 0.406 smd: A17(-24.365,-3.728) A19(-24.365,-2.813) A21(-24.365,-1.898) A23(-24.365,-0.983) A24(-24.365,-0.068) A27(-24.365,0.848) A29(-24.365,1.763) A31(-24.365,2.678) B17(-23.715,-3.728) B19(-23.715,-2.813) B21(-23.715,-1.898) B23(-23.715,-0.983) B24(-23.715,-0.068) B27(-23.715,0.848) B29(-23.715,1.763) B31(-23.715,2.678) C17(-23.065,-3.728) C19(-23.065,-2.813) C21(-23.065,-1.898) C23(-23.065,-0.983) C24(-23.065,-0.068) C27(-23.065,0.848) C29(-23.065,1.763) C31(-23.065,2.678) D17(-22.415,-3.728) D19(-22.415,-2.813) D21(-22.415,-1.898) D23(-22.415,-0.983) D24(-22.415,-0.068) D27(-22.415,0.848) D29(-22.415,1.763) D31(-22.415,2.678) F19(-21.765,-2.813) F21(-21.765,-1.898) F23(-21.765,-0.983) F24(-21.765,-0.068) F27(-21.765,0.848) F29(-21.765,1.763) F31(-21.765,2.678) G19(-21.115,-2.813) G21(-21.115,-1.898) G23(-21.115,-0.983) G24(-21.115,-0.068) G27(-21.115,0.848) G29(-21.115,1.763) G31(-21.115,2.678) H19(-20.465,-2.813) H21(-20.465,-1.898) H23(-20.465,-0.983) H24(-20.465,-0.068) H27(-20.465,0.848) H29(-20.465,1.763) H31(-20.465,2.678)
  oval 0.305x0.203 smd: A34(-24.011,4.176) A35(-24.365,4.795) B35(-23.715,4.795)
  oval 0.203x0.305 smd: AA49(-14.246,11.511) AB48(-13.626,11.215) AB49(-13.626,11.865) AC47(-12.995,10.891) AC49(-12.995,11.541) AE48(-12.364,11.215) AE49(-12.364,11.865) AF49(-11.744,11.511) AG48(-11.124,11.215) AG49(-11.124,11.865) AH1(-10.706,-11.865) AH2(-10.706,-11.215) AH47(-10.493,10.891) AH49(-10.493,11.541) AJ1(-10.056,-11.865) AJ2(-10.056,-11.215) AK48(-9.862,11.215) AK49(-9.862,11.865) AL1(-9.406,-11.865) AL2(-9.406,-11.215) AL49(-9.242,11.511) AM1(-8.756,-11.865) AM2(-8.756,-11.215) AM48(-8.622,11.215) AM49(-8.622,11.865) AN1(-8.106,-11.865) AN2(-8.106,-11.215) AN47(-7.991,10.891) AN49(-7.991,11.541) AR1(-7.456,-11.865) AR2(-7.456,-11.215) AR48(-7.36,11.215) AR49(-7.36,11.865) AT1(-6.806,-11.865) AT2(-6.806,-11.215) AT49(-6.74,11.511) AU1(-6.156,-11.865) AU2(-6.156,-11.215) AU48(-6.12,11.215) AU49(-6.12,11.865) AV1(-5.506,-11.865) AV2(-5.506,-11.215) AV47(-5.489,10.891) AV49(-5.489,11.541) AY1(-4.856,-11.865) AY2(-4.856,-11.215) AY48(-4.858,11.215) AY49(-4.858,11.865) BA1(-4.206,-11.865) BA2(-4.206,-11.215) BA49(-4.238,11.511) BB1(-3.556,-11.865) BB2(-3.556,-11.215) BB48(-3.618,11.215) BB49(-3.618,11.865) BD1(-2.906,-11.865) BD2(-2.906,-11.215) BD47(-2.987,10.891) BD49(-2.987,11.541) BE1(-2.256,-11.865) BE2(-2.256,-11.215) BE48(-2.356,11.215) BE49(-2.356,11.865) BF1(-1.606,-11.865) BF2(-1.606,-11.215) BF49(-1.736,11.511) BG48(-1.116,11.215) BG49(-1.116,11.865) BH1(-0.956,-11.865) BH2(-0.956,-11.215) BJ1(-0.306,-11.865) BJ2(-0.306,-11.215) BJ47(-0.485,10.891) BJ49(-0.485,11.541) BL1(0.344,-11.865) BL2(0.344,-11.215) BL48(0.146,11.215) BL49(0.146,11.865) BM1(0.994,-11.865) BM2(0.994,-11.215) BM49(0.766,11.511) BN48(1.386,11.215) BN49(1.386,11.865) BP1(1.644,-11.865) BP2(1.644,-11.215) BR1(2.294,-11.865) BR2(2.294,-11.215) BR47(2.017,10.891) BR49(2.017,11.541) BT1(2.944,-11.865) BT2(2.944,-11.215) BT48(2.648,11.215) BT49(2.648,11.865) BU49(3.268,11.511) BV1(3.594,-11.865) BV2(3.594,-11.215) BV48(3.888,11.215) BV49(3.888,11.865) BW1(4.244,-11.865) BW2(4.244,-11.215) BY1(4.894,-11.865) BY2(4.894,-11.215) BY47(4.519,10.891) BY49(4.519,11.541) CA48(5.15,11.215) CA49(5.15,11.865) CB1(5.544,-11.865) CB2(5.544,-11.215) CB49(5.77,11.511) CC48(6.39,11.215) CC49(6.39,11.865) CE47(7.021,10.891) CE49(7.021,11.541) CF48(7.652,11.215) CF49(7.652,11.865) CG49(8.272,11.511) CH48(8.892,11.215) CH49(8.892,11.865) CK47(9.523,10.891) CK49(9.523,11.541) CL48(10.154,11.215) CL49(10.154,11.865) CM49(10.774,11.511) CN48(11.394,11.215) CN49(11.394,11.865) CR47(12.025,10.891) CR49(12.025,11.541) CT48(12.656,11.215) CT49(12.656,11.865) CU49(13.276,11.511) CV48(13.896,11.215) CV49(13.896,11.865) CY47(14.527,10.891) CY49(14.527,11.541) DA48(15.158,11.215) DA49(15.158,11.865) DB49(15.778,11.511) DC48(16.398,11.215) DC49(16.398,11.865) DE47(17.029,10.891) DE49(17.029,11.541) DF48(17.66,11.215) DF49(17.66,11.865) T49(-16.748,11.511) U48(-16.128,11.215) U49(-16.128,11.865) V47(-15.497,10.891) V49(-15.497,11.541) Y48(-14.866,11.215) Y49(-14.866,11.865)
  oval 0.254x0.33 smd: AB1(-13.923,-11.543) AC1(-13.249,-11.865) AC2(-13.249,-11.215) AE1(-12.123,-11.865) AE2(-12.123,-11.215) AG1(-11.449,-11.543) CC1(6.149,-11.543) CD1(6.823,-11.865) CD2(6.823,-11.215) CF1(7.949,-11.865) CF2(7.949,-11.215) CH1(8.623,-11.543) CJ1(9.297,-11.865) CJ2(9.297,-11.215) CL1(10.423,-11.865) CL2(10.423,-11.215) CN1(11.097,-11.543) CP1(11.771,-11.865) CP2(11.771,-11.215) CT1(12.897,-11.865) CT2(12.897,-11.215) CV1(13.571,-11.543) CW1(14.245,-11.865) CW2(14.245,-11.215) DA1(15.371,-11.865) DA2(15.371,-11.215) DC1(16.045,-11.543) DD1(16.719,-11.865) DD2(16.719,-11.215) DF1(17.845,-11.865) DF2(17.845,-11.215) DG49(18.288,11.511) DH1(18.519,-11.543) DH48(18.871,11.215) DH49(18.871,11.865) DJ1(19.193,-11.865) DJ2(19.193,-11.215) DK47(19.524,10.89) DK49(19.524,11.54) DL1(20.319,-11.865) DL2(20.319,-11.215) DL48(20.177,11.215) DL49(20.177,11.865) DM47(20.741,10.89) DM49(20.741,11.54) DN1(20.993,-11.543) DN48(21.305,11.215) DN49(21.305,11.865) DP2(21.667,-11.215) H2(-20.671,-11.215) H47(-20.641,10.89) H49(-20.641,11.54) J48(-19.988,11.215) J49(-19.988,11.865) K1(-19.545,-11.865) K2(-19.545,-11.215) L49(-19.335,11.54) M1(-18.871,-11.543) M48(-18.682,11.215) M49(-18.682,11.865) N1(-18.197,-11.865) N2(-18.197,-11.215) N47(-18.029,10.89) N49(-18.029,11.54) R1(-17.071,-11.865) R2(-17.071,-11.215) R48(-17.376,11.215) R49(-17.376,11.865) U1(-16.397,-11.543) V1(-15.723,-11.865) V2(-15.723,-11.215) Y1(-14.597,-11.865) Y2(-14.597,-11.215)
