# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TP_DV47: length 16.4
  BOTTOM w0.102: TP97.1 67.84,23.79 68.37,24.32 73.33,24.32 75.32,26.31 75.32,28.52 76.13,29.33 76.13,30.28 75.77,30.65 75.77,32.87 75.6,33.03 U24.DV47
TP_DW3: length 6.6
  BOTTOM w0.102: U24.DW3 96.95,32.64 97.29,32.29 99.34,32.29 101.11,30.53 101.11,29.9 101.51,29.5 TP85.1
TP_DW4: length 8.9
  BOTTOM w0.079: U24.DW4 96.29,32.59 97,31.89 97.34,31.89
  BOTTOM w0.102: TP88.1 102.7,28.31 102.25,28.76 101.49,28.76 100.65,29.6 100.65,30.34 99.1,31.89 97.34,31.89
TP_DW6: length 8.8
  BOTTOM w0.079: U24.DW6 95.66,32.64 96.18,32.11 96.3,32.11 96.93,31.48 97.22,31.48
  BOTTOM w0.102: TP89.1 100.67,28.21 100.19,28.69 100.19,30.15 98.86,31.48 97.22,31.48
TP_DW47: length 14.4
  BOTTOM w0.102: TP95.1 68.57,24.62 73.32,24.62 75.09,26.4 75.09,28.61 75.91,29.42 75.91,30.19 75.53,30.57 75.53,32.54 U24.DW47
TP_E1: length 6.2
  BOTTOM w0.079: U24.E1 98.13,78.96 98.77,79.59 98.77,79.77 99.06,80.06
  BOTTOM w0.102: 99.06,80.06 99.26,80.26 99.26,81.35 101,83.09 TP65.1
TP_F15: length 8.6
  BOTTOM w0.102: U24.F15 90.9,81.5 91.25,81.85 91.25,83.81 90.94,84.11 90.38,84.11 90.13,83.86 89.72,83.86 88.86,84.72 TP61.1
TP_G15: length 9.6
  BOTTOM w0.102: TP63.1 91.35,84.34 92.29,83.4 92.29,82.42 92.73,81.99 92.73,79.25 92.55,79.07 91.66,79.07 91.43,78.84 91.43,78.58 U24.G15
TP_I2C_CLK: length 24.5
  TOP w0.102: R449.1 75.13,18.19 R434.1 ; R434.1 v1(75.13,19.97) ; R434.1 75.19,19.09 v2(75.75,19.09)
  IN3 w0.089: v2(75.75,19.09) 75.75,19.23 76.07,19.56 79.05,19.56 81.35,21.87 81.35,22.67 82.71,24.03 82.71,25.99 83.7,26.98 83.7,28.15 85.13,29.58 85.51,29.58 v2(86.02,30.09)
  BOTTOM w0.079: 86.6,31.99 86.77,32.16 86.77,32.81 86.74,32.86 86.74,33.04 86.8,33.2 86.8,33.4 86.74,33.51 86.74,33.7 86.78,33.79 87,34.01 U24.DT23
  BOTTOM w0.102: v2(86.02,30.09) 86.02,30.42 86.14,30.54 86.14,31.53 86.6,31.99
TP_I2C_DATA: length 31.5
  TOP w0.102: R433.1 R424.1 69.76,20.46 v1(69.2,19.9) 69.2,19.47 v1(69.53,19.14)
  IN3 w0.089: v2(85.43,30.09) 85.27,29.92 84.99,29.92 83.35,28.28 83.35,27.11 82.37,26.14 82.37,24.17 81.01,22.81 81.01,22.01 78.9,19.9 75.93,19.9 75.18,19.15 73.96,19.15 73.52,18.71 72.07,18.71 71.64,19.14 v1(69.53,19.14)
  BOTTOM w0.079: U24.DT24 86.6,34.25 86.6,33.8 86.59,33.76 86.58,33.73 86.58,33.47 86.64,33.36 86.64,33.23 86.58,33.07 86.58,32.81 86.6,32.77 86.6,32.45 86.14,31.99 86.07,31.99
  BOTTOM w0.102: v2(85.43,30.09) 85.43,30.33 85.79,30.69 85.79,31.71 86.07,31.99
TP_INTH#_L: length 12.4
  BOTTOM w0.102: Q43.1 64.66,23.4 65.07,22.99 67.36,22.99 68.46,24.09 70.22,24.09 70.74,23.57 v1(71.33,23.57) 71.69,23.21 71.69,22.11 71.53,21.95 R798.2 R797.1 70.32,21.92 CN12.7
TP_L34: length 27.9
  TOP w0.102: v2(82.26,76.17) 81.88,76.56 81.88,79.21 81.57,79.51 81.57,80.25 82,80.68 82,84.36 80.17,86.19 78.26,86.19 76.72,87.74 76.72,91.8 73.94,94.58 70.32,94.58 TP7.1
  BOTTOM w0.114: U24.L34 82.01,76.17 v2(82.26,76.17)
TP_M34: length 30
  TOP w0.102: TP8.1 73.85,94.35 76.49,91.71 76.49,87.64 78.17,85.97 80.07,85.97 81.77,84.26 81.77,80.78 81.34,80.34 81.34,79.42 81.65,79.11 81.65,76.16 82.28,75.53 v2(82.28,75.18)
  BOTTOM w0.102: v2(82.28,75.18) 82.28,75.25 U24.M34
TP_PWR_C: length 4.6
  BOTTOM w0.254: CN2.30 58.35,107.93 58.38,107.96 v1(58.38,108.32) 58.61,108.09 58.61,107.94 58.85,107.7 CN2.31
  BOTTOM w0.305: CN2.30 58.35,106.54 58.61,106.29 ; 58.61,106.29 58.85,106.53 CN2.31 ; 58.61,106.29 v1(58.61,106.16)
  vias: v1(59.04,105.14)
TP_R1: length 7
  BOTTOM w0.079: U24.R1 98.22,74.24 99.05,74.24 99.53,74.71 100.28,74.71 100.56,74.99
  BOTTOM w0.102: 100.56,74.99 101.66,74.99 101.88,74.78 102.06,74.78 TP71.1
TP_SMB_CLK: length 8.2
  TOP w0.102: R469.1 71.6,14.77 C460.1 70.88,15.41 v1(70.74,15.41) ; v1(70.74,15.41) 70.83,15.5 70.83,17.36 71.28,17.82 71.36,17.82 v1(71.39,17.84) ; v1(70.74,15.41) 71.22,15.9 Q21.3
  BOTTOM w0.102: v1(71.39,17.84) 71.39,19.49 71.32,19.56 CN12.6
TP_SMB_DATA: length 5.6
  TOP w0.102: v1(72.02,20.78) 72.02,20.15 72.23,19.95 R429.1 72.23,19.24 v1(72.32,19.14) 72.44,19.02 C439.1 72.32,18.28 72.32,17.42 72.54,17.2 Q21.6
  BOTTOM w0.102: CN12.5 v1(72.32,19.14)
TPCLK: length 139.3
  TOP w0.102: v2(200.04,25.21) 199.86,25.38 U13.89
  IN2 w0.089: v2(200.04,25.21) 198.51,25.21 197.89,24.59 194,24.59 192.94,23.53 191.17,23.53 190.34,22.69 189.25,22.69 188.28,23.66 186.68,23.66 186.4,23.38 185.76,23.38 185.04,22.66 183.37,22.66 182.7,23.33 179.09,23.33 178.86,23.1 177.18,23.1 176.8,23.48 170.14,23.48 169.76,23.11 168.15,23.11 168.08,23.18 165.8,23.18 165,23.98 160.08,23.98 160.05,23.95 157.72,23.95 157.54,24.13 155.28,24.13 154.83,23.68 143.91,23.68 142.12,25.46 137.99,25.46 137.6,25.86 134.61,25.86 134.46,25.7 127.3,25.7 126.29,24.69 123.36,24.69 122.79,25.26 121.5,25.26 121.18,24.94 118.78,24.94 118.54,24.7 115.94,24.7 114.6,23.36 112.55,23.36 111.48,22.29 95.63,22.29 94.59,23.33 92.01,23.33 91.77,23.57 91.09,23.57 90.91,23.75 90.73,23.75 89.6,24.88 88.21,24.88 87.74,25.35 83.31,25.35 82.49,24.53 82.49,23.61 79.37,20.5 77.87,20.5 77.43,20.94 v1(77.15,20.94)
  BOTTOM w0.102: v1(77.15,20.94) 77.15,21.7 76.95,21.91 76.95,23.43 76.54,23.84 76.03,23.84 75.88,23.68 R787.2 75.55,22.75 L16.1
TPCLK-1: length 3.4
  BOTTOM w0.102: L16.2 75.43,21.86 74.71,21.86 74.62,21.95 C681.1 74.33,21.73 75.32,20.74 CN12.2
TPD_EN: length 175.8
  TOP w0.102: R318.2 197.09,32.37 197.09,33.06 196.75,33.4 v2(196.75,33.43)
  IN2 w0.089: v1(68.64,21.2) 69.16,20.68 73.86,20.68 74.42,20.12 76.34,20.12 77.15,19.31 79.29,19.31 83.5,23.52 89.33,23.52 91.07,21.78 v1(91.58,21.78) ; v2(196.75,33.43) 196.75,33.4 197.19,32.96 197.19,29.93 199.71,27.42 201.74,27.42 202.25,27.93 204.53,27.93 205.04,27.42 206.54,27.42 206.92,27.04 206.92,26.48 207.09,26.31 207.09,25.24 206.38,24.52 204.46,24.52 203.79,23.85 202.16,23.85 200.58,22.27 200.35,22.27 198.56,20.48 197.92,20.48 197.17,19.73 196.59,19.73 195.81,18.95 193.58,18.95 192.83,18.21 191.71,18.21 190.53,19.39 188.02,19.39 187.44,18.81 186.77,18.81 186.11,19.47 180.99,19.47 180.54,19.93 179.17,19.93 178.7,19.46 176.26,19.46 175.68,20.05 173.52,20.05 173.33,19.85 170.8,19.85 170.42,19.47 170.14,19.47 169.96,19.29 169.96,19.01 169.56,18.6 161.08,18.6 160.83,18.86 155.13,18.86 154.66,19.33 151.18,19.33 150.07,18.22 145.43,18.22 144.88,18.77 137.36,18.77 137.03,19.1 126.72,19.1 126.5,18.88 124.33,18.88 124.07,19.14 121.84,19.14 120.41,17.71 114.14,17.71 112.77,16.34 111.19,16.34 110.91,16.62 110.17,16.62 108.84,15.3 94.63,15.3 94.19,15.73 v2(94.19,15.94)
  BOTTOM w0.102: v1(68.64,21.2) 68.64,21.58 68.77,21.7 68.77,22.21 68.26,22.72 R795.1 R796.2 ; v2(94.19,15.94) 94.19,15.96 94.02,16.14 94.02,19.34 v1(92.1,21.26) v1(91.58,21.78)
TPD_INT#: length 57.5
  TOP w0.079: v2(88.61,37.02) 88.96,36.66 88.96,35.66
  TOP w0.102: v2(90.56,22.97) 90.87,22.97 93.41,25.51 93.41,26.3 93,26.7 R378.1 92.93,27.01 93.56,27.01 93.74,27.19 93.74,28.48 93.43,28.78 93.43,29.55 92.47,30.51 92.47,32.04 91.81,32.7 v1(91.76,32.7) 91.27,32.7 90.03,33.94 90.03,34.59 88.96,35.66
  IN2 w0.089: v2(90.56,22.97) 89.83,23.71 83.42,23.71 79.21,19.5 77.23,19.5 76.42,20.31 74.5,20.31 73.94,20.87 69.52,20.87 69.18,21.22 69.18,21.54 68.57,22.15 66.2,22.15 65.82,21.77 64.16,21.77 62.5,23.43 v1(62.27,23.43)
  BOTTOM w0.079: U24.DL21 88.28,36.72 88.58,37.02 v2(88.61,37.02)
  BOTTOM w0.102: R820.1 63.99,19.21 63.71,19.49 63.71,21.3 62.27,22.74 v1(62.27,22.78) v1(62.27,23.43)
TPD_INT#_EC: length 183.4
  TOP w0.102: v2(180.66,32.22) 181.19,32.75 182.08,32.75 R309.1 182.46,33.42 v1(182.56,33.52) 182.66,33.62 183.75,33.62 183.98,33.39 183.98,32.9 183.93,32.85 R310.2
  IN2 w0.089: v1(113.68,23.79) 113.65,23.79 113.63,23.81 113.6,23.81 113.12,24.29 112.71,24.29 110.98,22.57 95.77,22.57 94.82,23.52 92.09,23.52 91.85,23.76 91.17,23.76 90.99,23.94 90.84,23.94 89.69,25.09 88.26,25.09 87.82,25.54 83.23,25.54 82.3,24.61 82.3,23.93 81.93,23.56 80.83,23.56 79.11,21.83 78.14,21.83 77.68,21.37 76.87,21.37 76.33,20.83 75.08,20.83 74.02,21.89 72.35,21.89 71.72,22.53 66.12,22.53 65.65,23 64.68,23 64.2,23.48 v1(63.43,23.48) ; v2(180.66,32.22) 180.53,32.09 179.44,32.09 179,32.52 179,33.11 178.38,33.73 167.12,33.73 166.87,33.48 166.38,33.48 166.17,33.69 165.07,33.69 164.29,34.47 164.13,34.47 163.77,34.83 162.87,34.83 162.03,35.66 159.57,35.66 159.2,36.04 156.49,36.04 155.85,35.4 153.42,35.4 153.17,35.65 148.57,35.65 148.22,36 148.22,36.42 147.67,36.98 147.28,36.98 144.16,40.1 144.16,45.34 143.16,46.34 139,46.34 137.86,47.48 134.3,47.48 133.15,48.63 128.43,48.63 125.82,46.02 122.83,46.02 120.78,48.07 114.64,48.07 112.2,50.51 v1(112.2,50.91)
  IN3 w0.089: v1(112.2,50.91) 112.2,50.57 112.44,50.33 112.44,49.5 111.62,48.68 111.62,46.85 113.55,44.92 113.55,40.36 113.79,40.12 113.79,37.91 114.44,37.26 116.13,37.26 118.24,35.15 118.24,33.87 116.92,32.55 114.84,32.55 113.08,30.79 113.08,24.38 v1(113.68,23.79)
  BOTTOM w0.102: R807.1 64.25,20.23 63.94,20.53 63.94,21.58 63.43,22.08 v1(63.43,22.21) v1(63.43,23.48)
TPDAT-1: length 3.3
  BOTTOM w0.102: CN12.3 74.32,20.97 73.34,21.95 C680.1 L15.2
TPDATA: length 145.5
  TOP w0.102: v2(200.24,25.97) 200.05,25.78 U13.90
  IN2 w0.089: v1(77.28,20.31) 79.45,20.31 82.68,23.54 82.68,24.45 83.31,25.08 87.59,25.08 88.02,24.65 89.56,24.65 90.65,23.56 90.83,23.56 91.01,23.38 91.69,23.38 91.93,23.14 94.51,23.14 95.58,22.07 111.53,22.07 112.63,23.17 114.71,23.17 116.04,24.5 118.61,24.5 118.86,24.75 121.33,24.75 121.64,25.06 122.72,25.06 123.28,24.5 126.37,24.5 127.36,25.49 134.51,25.49 134.69,25.67 137.52,25.67 137.95,25.23 142.08,25.23 143.83,23.49 154.91,23.49 155.36,23.94 157.46,23.94 157.64,23.76 160.13,23.76 160.16,23.79 164.92,23.79 165.74,22.97 168.01,22.97 168.06,22.92 169.84,22.92 170.22,23.29 176.67,23.29 177.06,22.9 178.93,22.9 179.17,23.14 182.62,23.14 183.29,22.47 186.05,22.47 186.98,23.4 188.27,23.4 189.18,22.5 190.41,22.5 191.25,23.34 193.02,23.34 194.07,24.38 197.96,24.38 198.38,24.8 200.24,24.8 200.49,25.06 200.49,25.72 v2(200.24,25.97)
  BOTTOM w0.102: L15.1 73.76,24.27 v1(74.12,24.27) 74.48,24.27 74.99,24.77 R784.2 75.61,24.77 75.88,24.5 75.88,24.24 76.06,24.07 76.64,24.07 77.18,23.52 77.18,22.21 77.58,21.8 77.58,20.46 77.43,20.31 v1(77.28,20.31)
TPM_LRESET#: length 3
  TOP w0.102: U15.17 123.09,23.52 122.87,23.74 R398.2 122.9,24.3 v1(123.66,24.3)
TRA_V_DAC: length 17.8
  TOP w0.508: C97.1 29.14,102.34 29.14,102.07 v1(29.65,101.56)
  BOTTOM w0.508: 32.07,100.82 v1(31.2,100.82) 30.16,100.82 29.65,101.33 v1(29.65,101.56) 29.41,101.56 28.9,102.07 U21.10 ; 32.07,100.82 31.9,100.99 U21.7 ; 32.07,100.82 34.99,100.82 ; U21.4 34.9,100.91 34.99,100.82 ; U21.1 37.9,101.77 36.95,100.82 34.99,100.82
TS_EN: length 223
  TOP w0.102: v2(203.39,24.32) 202.96,23.89 202.63,23.89 202.42,23.68 202.42,23.13 202.53,23.02 R410.1 ; R33.2 56.84,105.41 57.19,105.75 v2(57.19,105.96)
  IN2 w0.089: v2(57.19,105.96) 57.19,107.15 57.62,107.58 57.62,109.79 58.05,110.22 61.02,110.22 61.15,110.1 61.66,110.1 62.42,109.33 64.35,109.33 65.96,107.73 65.96,106.82 70.43,102.35 73.32,102.35 73.5,102.16 74.43,102.16 75.6,100.99 78.87,100.99 82.8,97.05 82.8,96.43 83.28,95.96 83.28,91.01 83.63,90.66 83.63,86.9 83.94,86.59 85.08,86.59 86.52,85.15 86.52,82.28 86.82,81.99 89.1,81.99 90.09,81 90.61,81 92.38,79.23 93.32,79.23 94.72,77.84 95.77,77.84 97.62,75.98 100.65,75.98 103.43,73.2 103.43,63.02 103.9,62.55 103.9,61.61 102.88,60.59 102.88,57.06 104.83,55.1 106.72,55.1 111.36,50.46 111.36,49.59 112,48.96 112.76,48.96 114.24,47.48 120.57,47.48 122.6,45.45 126.05,45.45 128.67,48.06 132.91,48.06 134.06,46.91 135.7,46.91 136.84,45.77 140.54,45.77 140.84,45.47 140.84,43.61 141.69,42.77 141.69,41.11 142.86,39.94 143.51,39.94 146.72,36.73 146.72,36.2 147.25,35.67 147.74,35.67 148.33,35.08 152.93,35.08 153.18,34.83 156.09,34.83 156.67,35.41 158.95,35.41 159.26,35.09 161.8,35.09 162.63,34.26 163.53,34.26 163.89,33.9 164.03,33.9 164.81,33.11 165.94,33.11 166.14,32.91 167.11,32.91 167.34,33.14 175.42,33.14 176.81,31.75 179.22,31.75 179.77,31.2 182.46,31.2 183.05,31.79 186.8,31.79 188.17,33.16 189.49,33.16 189.86,32.79 190.92,32.79 192.95,30.76 196.1,30.76 199.63,27.23 201.82,27.23 202.32,27.74 204.45,27.74 204.96,27.23 206.46,27.23 206.73,26.96 206.73,26.4 206.9,26.23 206.9,25.31 206.3,24.71 203.78,24.71 v2(203.39,24.32)
TS_EN_C: length 4.5
  TOP w0.102: U13.81 199.62,22.18 199.77,22.34 200.59,22.34 C390.1 201.64,22.56 202.59,22.56 202.61,22.57 R410.2
TS_EN_R: length 2.8
  TOP w0.102: R33.1 56.06,105.03 56.6,105.57 v2(56.6,105.95)
  BOTTOM w0.102: v2(56.6,105.95) 57.35,106.7 CN2.28
TSEN_1: length 1.7
  BOTTOM w0.102: v1(143.37,57.17) 143.1,56.91 PR178.2
  BOTTOM w0.203: PR181.1 143.1,55.74 PR178.2
TSEN_2: length 0.7
  BOTTOM w0.178: PR180.1 140.14,56.12 PR177.2
TYPEC_SBU1: length 9.5
  TOP w0.254: v1(10.6,12.43) 10.86,12.43 TP45.1 11.23,12.82 D19.2
  IN3 w0.254: v1(8.98,16.77) 8.72,16.77 8.32,16.37 8.32,14.08 9.33,13.07 9.97,13.07 v1(10.6,12.43)
  BOTTOM w0.254: v1(8.98,16.77) 8.72,16.77 8.6,16.65 CN14.A8
TYPEC_SBU2: length 10.7
  IN1 w0.127: CN14.B8 5.23,16.07 5.78,16.62 5.78,16.88 5.65,17 5.65,17.39 5.9,17.77 5.9,17.89 6.49,18.48 7.58,18.48 8.7,19.59 v1(8.7,19.67)
  BOTTOM w0.254: D39.2 11.11,18.54 11.11,19.42 10.48,20.05 TP98.1 9.08,20.05 v1(8.7,19.67)
TYPEC_STRAP: length 8.3
  TOP w0.102: U13.77 199.65,20.58 199.83,20.76 199.83,21.32 200.06,21.55 201.28,21.55 201.41,21.68 204.07,21.68 R421.2 204.68,22.29 v1(205.19,22.29) 205.67,22.77 R407.1
U42_L_U43E_Z: length 6.9
  BOTTOM w0.079: 96.42,81.74 96.62,81.53 96.62,81.17 96.49,81.04 96.49,80.39 96.47,80.36 96.47,79.88 96.57,79.78 U24.D4
  BOTTOM w0.254: 96.42,81.74 96.11,82.04 95.77,82.04 95.16,82.66 R581.2 R580.1
UART2_RXD: length 8.9
  BOTTOM w0.079: 87.98,32.46 87.98,32.52 87.88,32.8 87.88,33.11 87.91,33.21 87.91,33.38 87.87,33.47 87.86,33.48 87.86,33.73 87.91,33.85 87.91,34.04 87.86,34.13 87.65,34.33 U24.DT22
  BOTTOM w0.102: 87.98,32.46 87.98,31.37 86.8,30.19 86.8,28.62 86.32,28.14 TP90.1 86.32,27.8 86.68,27.44 87,27.44 87.16,27.29 R758.1
UART2_TXD: length 6.3
  BOTTOM w0.102: R757.1 85.63,27.39 85.89,27.65 85.89,28.13 86.37,28.61 TP86.1 86.55,29.48 86.55,30.26 86.78,30.48 86.78,30.49 87.18,30.9 87.18,31.22 87.79,31.83 87.79,32.49 U24.DW22
UFS_RESET#: length 6.6
  TOP w0.102: v2(96.45,51.17) 95.9,51.73 95.41,51.73 95.18,51.95 95.18,53 95.41,53.22 95.41,54.06 94.88,54.6 TP18.1
  BOTTOM w0.079: U24.CD3 96.86,50.28 96.86,50.66 96.45,51.07 v2(96.45,51.17)
ULT_EDP_HPD: length 194
  TOP w0.102: R343.2 94.75,29.96 v2(94.32,30.39) 94.07,30.64 R327.1 ; R32.1 55.05,103.75 C91.2 54.29,102.99 54.29,102.22 54.72,101.79 54.72,100.6 v2(54.8,100.52)
  IN1 w0.089: v2(54.06,13.58) 54.76,14.27 54.76,17.11 52.98,18.88 52.16,18.88 51.2,19.84 51.2,22.93 50.79,23.35 50.26,23.35 47.94,25.66 47.94,27.82 44.56,31.2 44.56,31.58 42.58,33.56 36.05,33.56 35.26,34.36 30.98,34.36 26.73,38.61 26.73,39.59 26.61,39.71 26.61,56.68 27.43,57.5 27.43,62.54 26.81,63.15 26.81,64.49 27.44,65.11 27.44,66.44 28.09,67.09 v2(29.3,67.09)
  IN3 w0.089: v2(54.8,100.52) 54.8,100.37 54.52,100.09 51.65,100.09 50.99,99.43 44.51,99.43 42.85,97.76 32.5,97.76 29.98,95.25 29.98,92.9 28.34,91.26 28.34,88.52 26.43,86.6 26.06,86.6 25.77,86.31 25.77,85.13 25.46,84.82 25.08,84.82 23.94,83.68 23.94,78.44 25.86,76.52 25.86,75.4 27.15,74.11 28.05,74.11 29.01,73.14 29.01,67.38 v2(29.3,67.09) ; v2(94.32,30.39) 94.02,30.09 93.38,30.09 92.19,28.89 92.19,28.48 91.96,28.26 91.21,28.26 89.04,26.08 89.04,24.29 86.16,21.41 84.81,21.41 80.14,16.74 75.42,16.74 73.62,14.93 69.92,14.93 69.85,14.86 55.35,14.86 v2(54.06,13.58)
  BOTTOM w0.079: U24.DW11 92.98,32.55 92.98,31.88 94.32,30.54 v2(94.32,30.39)
ULT_EDP_HPD_R: length 2.3
  TOP w0.102: R32.2 55.05,105.78 v2(55.47,106.19)
  BOTTOM w0.102: v2(55.47,106.19) 55.47,106.19 55.47,106.21 55.85,106.58 CN2.25
USB2_COMP: length 1.6
  TOP w0.254: v2(96.58,35.8) 95.92,36.46 R285.1
  BOTTOM w0.203: U24.DN5 96.37,36.01 v2(96.58,35.8)
USB3_SS0RX+: length 2.9
  BOTTOM w0.102: C700.1 20.75,20.59 20.51,20.59 20.24,20.85 20.24,21.51 20.12,21.63 19.98,21.63 19.89,21.54 U34.5
USB3_SS0RX-: length 2.9
  BOTTOM w0.102: U34.4 19.89,21.94 19.98,21.85 20.21,21.85 20.46,21.6 20.46,20.94 20.6,20.8 20.77,20.8 C695.1
USB3_SS0TX+: length 2
  BOTTOM w0.102: U34.2 19.89,22.74 19.98,22.83 20.24,22.83 20.42,22.66 20.66,22.66 20.81,22.51 C684.1
USB3_SS0TX-: length 2
  BOTTOM w0.102: U34.1 19.89,23.14 19.98,23.05 20.33,23.05 20.51,22.87 20.69,22.87 20.81,23 C675.1
USB30_RX1+: length 162.3
  TOP w0.102: v1(16.2,52.04) 16.39,52.23 16.67,52.23 17.12,52.68 19.91,52.68 20.56,53.33 22.62,53.33 23.09,52.86 24.48,52.86 25.08,53.45 25.08,54.47 24.59,54.96 23.74,54.96 C287.2 22.98,54.98 22.41,54.98 22.32,55.07 R202.2
  IN3 w0.089: v1(16.2,52.04) 15.88,52.04 15.62,51.78 15.62,50.09 17.46,48.25 17.46,45.35 19.39,43.42 19.39,42.73 21,41.12 21,38.45 22.05,37.4 23.95,37.4 24.69,36.66 24.69,36.16 25.31,35.53 25.31,33.9 24.27,32.86 23.58,32.86 20.38,29.67 20.38,26.2 19.12,24.93 19.12,21.44 19.49,21.07 19.49,19.21 20.41,18.3 20.41,16.98 21.14,16.24 21.14,13.5 21.35,13.3 21.35,11.45 21.55,11.25 21.55,9.27 22.99,7.83 24.59,7.83 24.78,7.64 25.87,7.64 27.23,9 37.92,9 41.12,12.21 44.56,12.21 47.13,14.77 47.13,16.62 49.16,18.66 52.72,18.66 53.3,19.24 53.3,19.98 53.91,20.59 64.96,20.59 66.71,22.34 73.19,22.34 73.63,21.9 74.04,21.9 74.21,22.07 74.21,22.61 74.55,22.95 74.81,22.95 76.1,24.24 77.75,24.24 78.46,24.95 79.43,24.95 80.5,26.03 80.5,26.56 81.21,27.27 81.21,30.04 82.96,31.79 84.77,31.79 85.08,32.09 87.35,32.09 87.51,32.25 87.51,33.26 87.82,33.56 87.82,34.68 88.02,34.89 88.02,35.06 87.94,35.15 87.94,36.05 88.02,36.13 88.02,37.76 89.11,38.85 93.33,38.85 93.89,38.29 94.47,38.29 94.7,38.06 94.7,37.73 94.83,37.61 v2(94.98,37.61)
  BOTTOM w0.102: v2(94.98,37.61) 95.39,38.02 U24.DJ6
USB30_RX1+_C: length 11.2
  TOP w0.102: R202.1 21.54,55.07 21.45,54.98 21.02,54.98 20.38,54.34 20,54.34 19.65,53.99 17.12,53.99 U5.10 16.92,53.99 15.99,53.99 15.47,53.47 15.47,53.11 14.76,52.4 14.45,52.4 13.59,51.54 13.35,51.54 13.1,51.78 CN5.6
USB30_RX1-: length 162.3
  TOP w0.102: v1(16.2,52.7) 16.2,52.68 16.43,52.45 16.58,52.45 17.03,52.89 19.82,52.89 20.47,53.54 22.71,53.54 23.18,53.07 24.39,53.07 24.87,53.54 24.87,54.38 24.5,54.74 23.74,54.74 C295.2 22.94,54.76 22.41,54.76 22.32,54.67 R204.2
  IN3 w0.089: v2(94.09,37.63) 94.4,37.63 94.5,37.73 94.5,37.98 94.39,38.09 93.81,38.09 93.25,38.64 89.2,38.64 88.23,37.67 88.23,36.05 88.14,35.96 88.14,35.23 88.23,35.15 88.23,34.8 88.02,34.6 88.02,33.48 87.72,33.18 87.72,32.17 87.44,31.89 85.16,31.89 84.86,31.58 83.04,31.58 81.42,29.96 81.42,27.19 80.71,26.48 80.71,25.94 79.51,24.75 78.55,24.75 77.84,24.04 76.19,24.04 74.89,22.74 74.64,22.74 74.42,22.52 74.42,21.98 74.13,21.69 73.55,21.69 73.1,22.13 66.8,22.13 65.04,20.38 54,20.38 53.5,19.89 53.5,19.15 52.8,18.45 49.24,18.45 47.33,16.54 47.33,14.68 44.65,12 41.21,12 38.01,8.8 27.32,8.8 25.96,7.44 24.7,7.44 24.51,7.63 22.9,7.63 21.35,9.19 21.35,11.16 21.14,11.37 21.14,13.21 20.94,13.41 20.94,16.16 20.2,16.89 20.2,18.22 19.29,19.13 19.29,20.98 18.92,21.36 18.92,25.02 20.18,26.28 20.18,29.75 23.49,33.06 24.19,33.06 25.11,33.98 25.11,35.45 24.48,36.07 24.48,36.57 23.86,37.2 21.97,37.2 20.8,38.37 20.8,41.04 19.19,42.65 19.19,43.34 17.26,45.27 17.26,48.16 15.42,50 15.42,51.87 16.2,52.65 v1(16.2,52.7)
  BOTTOM w0.102: U24.DJ8 94.52,38.02 94.14,37.63 v2(94.09,37.63)
USB30_RX1-_C: length 11.2
  TOP w0.102: CN5.5 13.1,51.07 13.35,51.32 13.68,51.32 14.54,52.18 14.85,52.18 15.68,53.02 15.68,53.38 16.08,53.77 18.83,53.77 U5.1 19,53.77 19.74,53.77 20.09,54.13 20.47,54.13 21.11,54.76 21.41,54.76 21.54,54.63 R204.1
USB30_RX2+: length 122.3
  TOP w0.102: R305.2 22.98,32.7 23.13,32.7 C363.2 23.56,32.8 23.62,32.74 24.03,32.74 24.32,32.45 24.32,31.79 24.5,31.61 v1(24.83,31.61)
  IN3 w0.089: v2(94.98,39.23) 94.6,38.85 94.14,38.85 93.2,39.79 91.85,39.79 91.13,40.51 90.66,40.51 90.29,40.87 90.29,41.22 90.22,41.29 88.13,41.29 87.77,40.92 87.77,39.65 86.52,38.41 86.52,33.84 86.14,33.46 84.29,33.46 83.63,32.8 82.49,32.8 79.31,29.62 79.31,28.76 78.55,28 78.55,27.55 78.09,27.09 77.28,27.09 77.2,27.16 76.64,27.16 76.38,26.9 76.38,26.67 73.47,23.76 68.43,23.76 68.28,23.91 66.44,23.91 66.1,23.57 66.1,23.2 65.72,22.82 64.99,22.82 64.31,22.13 55.01,22.13 54.5,21.63 52.39,21.63 50.46,19.7 48.56,19.7 45.17,16.31 45.17,14.31 44.06,13.2 40.71,13.2 37.59,10.07 26.9,10.07 25.5,8.67 25.17,8.67 25,8.85 24.25,8.85 23.13,9.98 23.13,13.82 22.91,14.04 22.91,16.86 21.89,17.88 21.89,19.03 20.96,19.95 20.96,25.37 21.47,25.88 21.47,29.35 23.73,31.61 v1(24.83,31.61)
  BOTTOM w0.102: v2(94.98,39.23) 94.73,38.98 U24.DG7
USB30_RX2+_C: length 10.7
  TOP w0.102: CN7.6 13.1,31.67 13.2,31.57 13.56,31.57 14.2,32.21 14.88,32.21 15.97,33.3 17.7,33.3 U11.10 17.87,33.3 20.09,33.3 20.67,32.71 21.35,32.71 R305.1
USB30_RX2-: length 122.2
  TOP w0.102: v1(24.83,30.97) 24.1,31.7 24.1,32.36 23.94,32.52 23.63,32.52 23.56,32.45 C368.2 23.2,32.49 22.92,32.49 R316.2
  IN3 w0.089: v2(94.4,39.23) 94.26,39.1 94.14,39.1 93.27,39.97 91.92,39.97 91.2,40.69 90.76,40.69 90.49,40.96 90.49,41.3 90.31,41.49 88.05,41.49 87.56,41.01 87.56,39.74 86.32,38.49 86.32,33.93 86.06,33.67 84.21,33.67 83.55,33.01 82.41,33.01 79.11,29.7 79.11,28.85 78.34,28.09 78.34,27.63 78.01,27.29 77.36,27.29 77.29,27.37 76.56,27.37 76.17,26.98 76.17,26.75 73.39,23.96 68.51,23.96 68.36,24.12 66.36,24.12 65.9,23.66 65.9,23.29 65.64,23.02 64.91,23.02 64.22,22.34 54.93,22.34 54.42,21.83 52.3,21.83 50.37,19.9 48.47,19.9 44.97,16.39 44.97,14.4 43.97,13.4 40.63,13.4 37.5,10.27 26.81,10.27 25.42,8.88 25.26,8.88 25.08,9.05 24.33,9.05 23.33,10.06 23.33,13.91 23.11,14.12 23.11,16.94 22.09,17.96 22.09,19.11 21.16,20.04 21.16,25.29 21.67,25.8 21.67,29.27 23.81,31.41 24.45,31.41 24.83,31.02 v1(24.83,30.97)
  BOTTOM w0.102: v2(94.4,39.23) 94.19,39.43 93.89,39.43 93.76,39.31 93.76,38.92 93.86,38.83 U24.DG9
USB30_RX2-_C: length 10.7
  TOP w0.102: CN7.5 13.1,31.19 13.27,31.36 13.65,31.36 14.29,31.99 14.97,31.99 16.06,33.08 19.58,33.08 U11.1 19.78,33.08 20,33.08 20.58,32.5 21.39,32.5 R316.1
USB30_RX3+: length 179.3
  IN1 w0.089: v2(25.3,10.62) 25.3,10.49 25.49,10.3 25.77,10.3 25.94,10.12 25.94,9.12 25.6,8.77 24.83,8.77 24.4,9.21 23.96,9.21 23.6,9.56 17,9.56 16.74,9.82 16.28,9.82 15.81,9.35 15.81,6.71 15.07,5.97 15.07,3.67 15.23,3.52 15.58,3.52 15.64,3.58 15.64,5.71 15.85,5.92 16.37,5.92 16.58,5.71 16.58,3.2 16.67,3.11 17.02,3.11 17.14,3.22 17.14,4.82 17.33,5.02 17.89,5.02 18.08,4.83 18.08,3.24 18.16,3.16 18.98,3.16 19.11,3.29 19.11,5.19 19.92,6.01 21.2,6.01 22.7,4.51 23.61,4.51 24.59,3.53 27.31,3.53 28.71,4.93 30.3,4.93 30.41,5.05 30.41,5.8 30.65,6.04 31.21,6.04 31.42,5.83 31.42,5.46 31.48,5.4 31.89,5.4 31.95,5.46 31.95,5.83 32.16,6.04 32.68,6.04 32.89,5.83 32.89,4.93 32.98,4.84 33.34,4.84 33.43,4.93 33.43,5.78 33.63,5.99 34.16,5.99 34.36,5.78 34.36,4.93 34.45,4.84 34.81,4.84 34.9,4.93 34.9,5.83 35.11,6.04 35.55,6.04 35.76,5.83 35.76,4.95 35.85,4.86 36.11,4.86 36.2,4.95 36.2,5.83 36.41,6.04 36.79,6.04 37.76,7.01 37.76,7.13 36.96,7.94 36.96,8.23 37.33,8.6 37.62,8.6 38.5,7.72 38.63,7.72 38.88,7.97 38.88,8.1 37.69,9.28 37.69,9.55 38.07,9.92 38.38,9.92 39.54,8.76 39.67,8.76 39.92,9.01 39.92,9.14 38.74,10.32 38.74,10.59 39.13,10.99 39.4,10.99 40.59,9.8 40.71,9.8 40.96,10.06 40.96,10.18 39.8,11.34 39.8,11.66 40.18,12.03 40.44,12.03 41.63,10.85 41.75,10.85 42.01,11.1 42.01,11.22 40.85,12.38 40.85,12.7 41.22,13.07 41.49,13.07 43.66,10.9 43.81,10.9 44.06,11.15 44.06,11.25 41.86,13.45 41.86,14.79 42.45,15.38 43.75,15.38 44.03,15.1 44.03,14.82 44.26,14.59 v2(44.46,14.59)
  IN3 w0.089: v2(94.42,40.21) 94.42,40.28 94.3,40.4 93.86,40.4 92.84,41.41 92,41.41 90.73,42.68 86.73,42.68 85.39,41.34 85.39,40.56 84.22,39.39 84.22,38.61 83.58,37.96 83.58,35.95 82.79,35.17 82.79,34.81 82.26,34.28 81.93,34.28 78.56,30.9 70.73,30.9 67.83,28 67.83,26.48 66.61,25.26 62.7,25.26 61.35,23.91 60.56,23.91 60.05,24.42 58.79,24.42 57.8,23.43 51.07,23.43 50.89,23.25 50.2,23.25 49.22,22.27 49.22,22.06 47.89,20.73 47.89,20.26 44.46,16.83 44.46,16.17 44.03,15.73 44.03,14.82 44.26,14.59 v2(44.46,14.59) ; v1(22.69,20.64) 22.89,20.84 22.96,20.84 24.31,19.49 24.31,18.13 24.62,17.82 25,17.82 25.63,17.19 25.63,11.96 26,11.59 26,10.58 25.68,10.26 25.55,10.26 25.3,10.51 v2(25.3,10.62)
  BOTTOM w0.102: C700.2 21.94,20.67 22.02,20.75 22.58,20.75 v1(22.69,20.64) ; U24.DE9 94.3,39.74 94.5,39.94 94.5,40.13 v2(94.42,40.21)
USB30_RX3-: length 179.4
  IN1 w0.089: v2(25.3,9.97) 25.42,10.1 25.68,10.1 25.74,10.04 25.74,9.21 25.51,8.98 24.91,8.98 24.48,9.41 24.04,9.41 23.68,9.77 17.08,9.77 16.83,10.02 16.19,10.02 15.61,9.44 15.61,6.79 14.87,6.06 14.87,3.58 15.14,3.31 15.66,3.31 15.84,3.5 15.84,5.63 15.93,5.72 16.29,5.72 16.38,5.63 16.38,3.11 16.58,2.91 17.11,2.91 17.34,3.14 17.34,4.74 17.42,4.81 17.81,4.81 17.88,4.74 17.88,3.15 18.07,2.96 19.07,2.96 19.32,3.2 19.32,5.11 20.01,5.8 21.12,5.8 22.62,4.3 23.52,4.3 24.5,3.32 27.39,3.32 28.8,4.73 30.38,4.73 30.62,4.96 30.62,5.72 30.73,5.83 31.13,5.83 31.22,5.75 31.22,5.38 31.4,5.19 31.97,5.19 32.16,5.38 32.16,5.75 32.24,5.83 32.6,5.83 32.69,5.75 32.69,4.84 32.9,4.63 33.42,4.63 33.63,4.84 33.63,5.69 33.72,5.78 34.07,5.78 34.16,5.69 34.16,4.84 34.37,4.63 34.89,4.63 35.1,4.84 35.1,5.75 35.19,5.83 35.47,5.83 35.56,5.75 35.56,4.87 35.76,4.66 36.2,4.66 36.41,4.87 36.41,5.75 36.5,5.83 36.87,5.83 37.96,6.92 37.96,7.22 37.16,8.02 37.16,8.14 37.41,8.4 37.54,8.4 38.42,7.52 38.71,7.52 39.08,7.89 39.08,8.18 37.9,9.37 37.9,9.47 38.15,9.72 38.3,9.72 39.46,8.56 39.75,8.56 40.12,8.93 40.12,9.22 38.94,10.41 38.94,10.51 39.22,10.79 39.32,10.79 40.5,9.6 40.8,9.6 41.17,9.97 41.17,10.27 40.01,11.43 40.01,11.58 40.26,11.83 40.36,11.83 41.54,10.64 41.84,10.64 42.21,11.01 42.21,11.31 41.05,12.47 41.05,12.62 41.3,12.87 41.4,12.87 43.58,10.7 43.9,10.7 44.27,11.07 44.27,11.34 42.07,13.54 42.07,14.7 42.54,15.18 43.67,15.18 43.83,15.01 43.83,14.69 v2(43.73,14.59)
  IN3 w0.089: v2(43.73,14.59) 43.83,14.69 43.83,15.82 44.26,16.25 44.26,16.91 47.69,20.34 47.69,20.81 49.02,22.14 49.02,22.35 50.12,23.46 50.8,23.46 50.98,23.63 57.71,23.63 58.7,24.62 60.13,24.62 60.64,24.12 61.27,24.12 62.61,25.46 66.53,25.46 67.63,26.56 67.63,28.08 70.64,31.1 78.47,31.1 81.85,34.48 82.17,34.48 82.59,34.89 82.59,35.25 83.37,36.04 83.37,38.04 84.02,38.69 84.02,39.48 85.18,40.64 85.18,41.43 86.64,42.89 90.82,42.89 92.09,41.62 92.92,41.62 93.94,40.6 94.58,40.6 94.97,40.21 v2(95.08,40.21) ; v1(22.69,21.27) 22.69,21.14 22.8,21.04 23.05,21.04 24.51,19.58 24.51,18.21 24.7,18.02 25.08,18.02 25.83,17.27 25.83,12.04 26.2,11.67 26.2,10.49 25.77,10.06 25.39,10.06 v2(25.3,9.97)
  BOTTOM w0.102: C695.2 22.17,20.97 22.41,20.97 22.69,21.25 v1(22.69,21.27) ; v2(95.08,40.21) 95.08,40.13 94.73,39.78 U24.DE7
USB30_RX+_TYPEC1: length 25.8
  TOP w0.102: v1(12.63,14.46) 12.42,14.68 12.16,14.68 11.73,15.12 RV1.1 RV1.10 10.28,15.12 10.19,15.21 9.9,15.21 9.7,15.01 9.7,13.94 9.21,13.45 8.63,13.45 8.33,13.75 8.33,14.32 8.2,14.45 7.92,14.45 7.78,14.31 7.78,13.93 7.54,13.69 5.52,13.69 CN14.B11
  IN1 w0.089: v1(12.63,14.46) 12.84,14.67 12.99,14.67 13.05,14.61 14.08,14.61 14.27,14.79 16.42,14.79 17.46,15.84 17.46,19.16 16.44,20.18 16.02,20.18 15.91,20.29 15.91,20.51 16.04,20.64 16.56,20.64 17.48,19.72 17.84,19.72 v2(17.97,19.6)
  BOTTOM w0.102: v2(17.97,19.6) 17.97,19.62 18.36,20.01 18.36,20.57 18.3,20.64 U34.7
USB30_RX+_TYPEC2: length 25.7
  IN1 w0.089: v2(12.3,23) 12.53,22.77 12.53,22.09 12.31,21.87 11.97,21.87 11.76,21.66 11.76,21.28 11.96,21.07 12.98,21.07 13.07,20.98 13.07,19.98 12.94,19.86 12.61,19.86 12.39,19.64 12.39,19.28 12.61,19.06 13.28,19.06 13.73,19.52 14.79,19.52 14.88,19.43 14.88,19.24 14.76,19.12 13.9,19.12 13.65,18.88 13.65,18.5 13.93,18.22 13.93,17.19 13.87,17.13 13.73,17.13 v1(13.47,17.39)
  BOTTOM w0.102: U34.14 16.41,23.14 16.33,23.06 15.95,23.06 15.87,22.99 14.15,22.99 13.46,23.67 12.75,23.67 12.55,23.47 12.55,23.24 v2(12.3,23) ; v1(13.47,17.39) 13.47,17.27 13.37,17.17 13.05,17.17 12.72,16.83 11.97,16.83 11.69,17.12 RV2.1 RV2.10 10.31,17.12 10.15,16.95 9.88,16.95 9.75,17.07 9.75,17.55 9.19,18.11 8.35,18.11 8.23,17.98 7.82,17.98 7.65,18.15 CN14.A11
USB30_RX-_TYPEC1: length 25.8
  TOP w0.102: CN14.B10 5.23,14.03 5.34,13.91 7.45,13.91 7.57,14.02 7.57,14.4 7.83,14.67 8.29,14.67 8.55,14.41 8.55,13.84 8.72,13.66 9.12,13.66 9.48,14.03 9.48,15.1 9.81,15.43 10.09,15.43 10.28,15.61 RV1.9 RV1.2 11.77,15.61 11.87,15.51 11.87,15.28 12.25,14.9 12.56,14.9 12.63,14.97 v1(12.63,15.1)
  IN1 w0.089: v1(12.63,15.1) 12.63,14.97 12.73,14.87 13.07,14.87 13.13,14.81 14,14.81 14.18,15 16.34,15 17.26,15.92 17.26,19.08 16.36,19.98 15.94,19.98 15.71,20.2 15.71,20.59 15.95,20.84 16.65,20.84 17.56,19.93 17.69,19.93 v2(17.97,20.2)
  BOTTOM w0.102: v2(17.97,20.2) 17.99,20.2 18.15,20.36 18.15,20.48 17.9,20.73 U34.8
USB30_RX-_TYPEC2: length 25.7
  IN1 w0.089: v2(12.99,23) 12.84,23 12.74,22.9 12.74,22.01 12.4,21.67 12.05,21.67 11.96,21.58 11.96,21.36 12.05,21.28 13.06,21.28 13.27,21.07 13.27,19.9 13.03,19.66 12.7,19.66 12.6,19.56 12.6,19.36 12.69,19.26 13.19,19.26 13.65,19.72 14.87,19.72 15.08,19.51 15.08,19.16 14.84,18.92 13.98,18.92 13.85,18.79 13.85,18.59 14.13,18.31 14.13,17.11 13.96,16.93 13.65,16.93 v1(13.45,16.72)
  BOTTOM w0.102: v2(12.99,23) 12.88,23 12.76,23.11 12.76,23.38 12.84,23.46 13.37,23.46 14.06,22.77 15.96,22.77 16.04,22.85 16.27,22.85 16.38,22.74 U34.13 ; CN14.A10 7.69,17.65 7.81,17.77 8.32,17.77 8.44,17.89 9.1,17.89 9.54,17.46 9.54,16.98 9.79,16.74 10.13,16.74 10.26,16.62 RV2.9 RV2.2 12.8,16.62 13.14,16.95 13.32,16.95 13.45,16.83 v1(13.45,16.72)
USB30_RX_N4: length 3.4
  TOP w0.102: R263.1 96.89,41.46 95.5,41.46 95.42,41.38 95.31,41.38 95.05,41.11 v2(95.05,41)
  BOTTOM w0.079: v2(95.05,41) 95.04,41 94.73,40.69 U24.DC7
USB30_RX_P4: length 3.2
  TOP w0.102: v2(94.4,41) 94.97,41.57 95.34,41.57 95.42,41.65 96.3,41.65 R263.2
  BOTTOM w0.079: v2(94.4,41) 94.08,40.68 U24.DC9
USB30_TX1+: length 173.6
  TOP w0.102: v1(16.06,59.82) 16.06,60.06 16.17,60.16 22.57,60.16 22.68,60.04 25.55,60.04 26.77,58.82 26.77,58.37 26.66,58.26 26.51,58.26 C272.1
  IN3 w0.089: v2(99.33,37.04) 98.9,37.47 97.7,37.47 97.31,37.87 96.6,37.87 95.8,38.67 94.04,38.67 93.43,39.28 91.13,39.28 90.89,39.52 90.89,39.99 90.56,40.32 88.63,40.32 88.17,39.86 88.17,39.48 86.93,38.24 86.93,33.57 86.29,32.93 84.32,32.93 83.78,32.4 82.66,32.4 79.74,29.48 79.74,27.09 79.58,26.92 78.78,26.92 77.98,26.12 76.41,26.12 73.64,23.35 70.21,23.35 69.8,22.95 66.42,22.95 64.66,21.18 52.63,21.18 50.71,19.26 48.91,19.26 45.88,16.24 45.88,15.56 46.04,15.4 46.04,14.57 44.26,12.8 40.88,12.8 37.71,9.64 27.02,9.64 25.63,8.24 25.03,8.24 24.83,8.44 24.06,8.44 22.64,9.87 22.64,11.16 22.03,11.77 22.03,16.28 21.02,17.29 21.02,18.55 20.35,19.22 20.35,21.51 19.72,22.14 19.72,24.69 21.07,26.04 21.07,29.51 23.72,32.16 24.56,32.16 25.92,33.51 25.92,35.77 25.28,36.4 25.28,37.03 24.31,38 22.37,38 21.6,38.76 21.6,41.69 21.02,42.28 21.02,45.71 18.73,47.99 18.73,48.47 17.18,50.02 17.18,57.42 15.43,59.17 15.43,59.87 15.69,60.13 15.99,60.13 16.06,60.06 v1(16.06,59.82)
  BOTTOM w0.079: U24.DJ1 97.9,37.81 97.8,37.71 97.8,37.56 97.91,37.45 98.92,37.45 v2(99.33,37.04)
USB30_TX1+_C: length 1.3
  TOP w0.102: C272.2 24.95,58.28 24.71,58.28 R198.2
USB30_TX1+_C_R: length 12.6
  TOP w0.102: CN5.9 13.1,57.69 13.27,57.52 13.69,57.52 14.19,57.01 15.12,57.01 15.32,57.21 16.94,57.21 U5.6 17.1,57.21 19.26,57.21 20.33,58.28 21.79,58.28 C270.1 22.55,58.26 23.15,58.26 R198.1
USB30_TX1-: length 173.6
  TOP w0.102: v1(16.06,60.58) 16.27,60.37 22.66,60.37 22.77,60.26 25.64,60.26 26.99,58.91 26.99,58.28 26.75,58.04 26.51,58.04 C277.1
  IN3 w0.089: v1(16.06,60.58) 15.82,60.34 15.61,60.34 15.23,59.96 15.23,59.08 16.98,57.33 16.98,49.94 18.53,48.39 18.53,47.91 20.81,45.62 20.81,42.19 21.4,41.61 21.4,38.68 22.28,37.79 24.23,37.79 25.08,36.94 25.08,36.32 25.72,35.68 25.72,33.6 24.48,32.36 23.63,32.36 20.86,29.59 20.86,26.12 19.51,24.77 19.51,22.06 20.15,21.42 20.15,19.14 20.81,18.47 20.81,17.21 21.83,16.19 21.83,11.69 22.44,11.08 22.44,9.78 23.98,8.24 24.74,8.24 24.95,8.04 25.71,8.04 27.11,9.43 37.8,9.43 40.96,12.6 44.35,12.6 46.24,14.49 46.24,15.49 46.09,15.64 46.09,16.16 48.99,19.06 50.79,19.06 52.71,20.98 64.74,20.98 66.51,22.74 69.89,22.74 70.29,23.15 73.72,23.15 76.49,25.92 78.07,25.92 78.87,26.72 79.66,26.72 79.94,27 79.94,29.39 82.75,32.19 83.87,32.19 84.4,32.73 86.37,32.73 87.13,33.49 87.13,38.15 88.38,39.4 88.38,39.78 88.72,40.12 90.51,40.12 90.71,39.92 90.71,39.41 91.02,39.1 93.36,39.1 93.97,38.49 95.69,38.49 96.52,37.66 97.23,37.66 97.62,37.27 98.52,37.27 v2(98.74,37.04)
  BOTTOM w0.079: U24.DJ2 97.52,37.81 97.63,37.69 97.63,37.49 97.84,37.28 98.5,37.28 v2(98.74,37.04)
USB30_TX1-_C: length 1.3
  TOP w0.102: R200.2 24.75,58.06 24.91,58.06 C277.2
USB30_TX1-_C_R: length 12.6
  TOP w0.102: R200.1 23.15,58.04 22.55,58.04 C280.1 21.75,58.06 20.42,58.06 19.34,56.99 19.02,56.99 U5.5 18.81,56.99 15.41,56.99 15.21,56.79 14.1,56.79 13.6,57.3 13.18,57.3 13.1,57.22 CN5.8
USB30_TX2+: length 128.7
  TOP w0.102: C349.1 25.2,37.59 25.47,37.59 v1(25.71,37.83)
  IN3 w0.089: v1(25.71,37.83) 25.72,37.83 25.83,37.71 26.6,37.71 27.11,37.2 27.11,33.61 26.1,32.59 26.1,30.31 24.93,29.14 24.93,27.14 22.87,25.08 22.87,23.82 24.21,22.48 24.21,20.83 25.72,19.32 25.72,18.53 26.5,17.74 26.5,12.41 27.37,11.54 28,11.54 28.51,11.04 37.42,11.04 40.43,14.04 40.99,14.04 43.5,16.55 43.5,17.14 46.85,20.49 46.85,24.62 47.52,25.29 47.98,25.29 48.53,25.84 49.56,25.84 49.61,25.89 54.59,25.89 55.21,26.52 57.02,26.52 57.34,26.84 60.77,26.84 61.81,27.88 63.5,27.88 63.86,28.23 66.82,28.23 70.4,31.81 73.68,31.81 74.05,32.19 74.05,32.44 74.7,33.09 78.38,33.09 80,34.71 80.5,34.71 81.52,35.72 81.52,38.48 82.27,39.23 83.11,39.23 83.35,39.47 83.35,39.79 83.85,40.29 83.85,40.92 84.19,41.25 84.19,41.38 86.38,43.57 91.1,43.57 92.37,42.3 93.21,42.3 93.94,41.58 95.29,41.58 95.35,41.64 96.23,41.64 97.42,40.46 97.42,38.68 97.83,38.26 98.53,38.26 v2(98.73,38.46)
  BOTTOM w0.079: v2(98.73,38.46) 98.52,38.25 97.94,38.25 97.82,38.2 97.62,38.2 97.5,38.24 97.27,38.24 97.17,38.19 97,38.19 96.77,38.29 96.45,38.29 96.28,38.11 96.28,37.98 U24.DJ5
USB30_TX2+_C: length 1.4
  TOP w0.102: C349.2 24.06,37.79 23.82,37.56 23.46,37.56 R280.2
USB30_TX2+_C_R: length 11.7
  TOP w0.102: R280.1 21.88,37.56 21.66,37.56 C345.1 20.86,37.54 20.42,37.54 20.19,37.31 20.19,36.7 20.01,36.52 17.84,36.52 U11.6 17.72,36.52 15.47,36.52 15.05,36.94 14.16,36.94 13.56,37.54 13.31,37.54 13.1,37.75 CN7.9
USB30_TX2-: length 128.7
  TOP w0.102: v1(25.71,37.2) 25.53,37.37 25.27,37.37 C351.1
  IN3 w0.089: v2(98.73,37.86) 98.53,38.06 97.75,38.06 97.22,38.59 97.22,40.37 96.15,41.44 95.44,41.44 95.38,41.38 93.85,41.38 93.13,42.1 92.28,42.1 91.01,43.37 86.46,43.37 84.39,41.3 84.39,41.17 84.05,40.83 84.05,40.21 83.55,39.71 83.55,39.39 83.19,39.03 82.36,39.03 81.72,38.39 81.72,35.64 80.59,34.5 80.08,34.5 78.47,32.89 74.78,32.89 74.25,32.36 74.25,32.1 73.76,31.61 70.49,31.61 66.9,28.03 63.94,28.03 63.59,27.67 61.89,27.67 60.86,26.64 57.43,26.64 57.1,26.31 55.3,26.31 54.68,25.69 49.69,25.69 49.64,25.64 48.62,25.64 48.07,25.09 47.6,25.09 47.05,24.54 47.05,20.41 43.7,17.05 43.7,16.46 41.08,13.84 40.51,13.84 37.5,10.83 28.43,10.83 27.92,11.34 27.28,11.34 26.3,12.32 26.3,17.66 25.51,18.44 25.51,19.24 24.01,20.74 24.01,22.39 22.67,23.73 22.67,25.17 24.73,27.22 24.73,29.22 25.89,30.39 25.89,32.68 26.91,33.69 26.91,37.11 26.51,37.51 26.03,37.51 25.72,37.2 v1(25.71,37.2)
  BOTTOM w0.079: U24.DJ3 96.55,37.81 96.45,37.91 96.45,38.04 96.52,38.12 96.73,38.12 96.96,38.02 97.2,38.02 97.3,38.07 97.47,38.07 97.59,38.04 97.86,38.04 97.97,38.08 98.5,38.08 v2(98.73,37.86)
USB30_TX2-_C: length 1.4
  TOP w0.102: R284.2 23.46,37.34 23.82,37.34 24.06,37.11 C351.2
USB30_TX2-_C_R: length 11.7
  TOP w0.102: R284.1 21.88,37.34 21.66,37.34 C352.1 20.9,37.32 20.51,37.32 20.41,37.22 20.41,36.61 20.1,36.3 19.8,36.3 U11.5 19.56,36.3 15.38,36.3 14.96,36.73 14.07,36.73 13.47,37.32 13.29,37.32 13.1,37.13 CN7.8
USB30_TX3+: length 180.4
  IN1 w0.089: v2(24.23,10.45) 24.23,10.51 24.04,10.7 22.99,10.7 22.02,11.67 18,11.67 17.67,11.34 16.53,11.34 15.87,10.68 14.73,10.68 14.49,10.44 14.49,10.14 14.58,10.05 14.99,10.05 15.2,9.84 15.2,9.41 14.99,9.2 14.58,9.2 14.49,9.11 14.49,8.84 14.58,8.76 14.99,8.76 15.2,8.55 15.2,8.11 14.99,7.9 14.58,7.9 14.49,7.82 14.49,7.05 13.6,6.16 13.6,3.04 13.76,2.88 14.62,2.88 15.02,2.48 20.5,2.48 20.88,2.85 28.53,2.85 28.74,3.07 28.74,3.82 29.08,4.15 31.2,4.15 31.41,3.94 31.41,2.89 31.54,2.75 31.78,2.75 31.94,2.92 31.94,3.94 32.15,4.15 33.55,4.15 33.76,3.94 33.76,2.84 33.85,2.75 34.11,2.75 34.2,2.84 34.2,3.94 34.41,4.15 34.85,4.15 35.05,3.94 35.05,2.84 35.14,2.75 35.41,2.75 35.5,2.84 35.5,3.94 35.71,4.15 37.4,4.15 37.6,4.35 37.6,5.81 38.26,6.47 38.33,6.47 41.87,10.02 43.93,10.02 47.92,14.01 47.92,15.3 48.29,15.68 48.96,15.68 49.69,14.95 53.27,14.95 53.45,15.12 53.45,16.74 52.73,17.46 52.5,17.46 52.41,17.38 52.41,16.3 52.25,16.14 51.73,16.14 51.42,16.45 51.42,17.75 51.33,17.84 50.57,17.84 50.48,17.75 50.48,15.71 50.23,15.45 49.91,15.45 49.48,15.89 49.48,18.99 49.39,19.08 48.85,19.08 48.73,18.96 48.73,16.32 48.5,16.09 48.04,16.09 46.82,17.31 46.82,18.89 48.1,20.17 49.62,20.17 49.8,20.35 49.8,20.88 v2(49.49,21.19)
  IN3 w0.089: v2(95.57,39.29) 95.62,39.34 95.62,39.48 95.48,39.62 94.08,39.62 93.9,39.79 93.82,39.79 93.22,40.4 91.78,40.4 91.4,40.78 91.4,41.15 90.55,42 87.03,42 85.98,40.95 85.98,40.08 84.94,39.04 84.94,37.83 84.56,37.44 84.56,35.31 84.9,34.97 84.9,34.48 84.57,34.15 84.02,34.15 83.36,33.49 82.08,33.49 78.56,29.97 78.56,28.98 77.89,28.31 76.42,28.31 75.37,27.26 75.37,26.62 73.2,24.45 68.91,24.45 68.74,24.62 66.1,24.62 65.34,23.86 65.06,23.86 64.02,22.82 52.62,22.82 50.22,20.42 49.93,20.42 49.72,20.63 49.72,21.03 49.57,21.19 v2(49.49,21.19) ; v2(24.23,10.45) 24.47,10.68 24.68,10.68 24.9,10.9 24.9,11.25 24.57,11.58 24.57,13.63 23.79,14.41 23.79,17.17 23.89,17.28 23.89,17.85 22.76,18.97 22.76,19.39 21.84,20.32 21.84,22.49 21.91,22.57 22.13,22.57 22.25,22.45 v1(22.25,22.13)
  BOTTOM w0.102: U24.DF5 95.7,39.16 95.57,39.29 v2(95.57,39.29) ; v1(22.25,22.13) 22.25,22.48 22.19,22.53 22.03,22.53 21.85,22.71 21.64,22.71 21.59,22.66 C684.2
USB30_TX3-: length 180.4
  IN1 w0.089: v2(24.23,11.03) 24.11,10.91 23.07,10.91 22.11,11.87 17.92,11.87 17.59,11.54 16.44,11.54 15.78,10.88 14.64,10.88 14.29,10.53 14.29,10.06 14.49,9.85 14.91,9.85 15,9.76 15,9.49 14.91,9.4 14.49,9.4 14.29,9.2 14.29,8.76 14.49,8.55 14.91,8.55 15,8.46 15,8.2 14.91,8.11 14.49,8.11 14.29,7.9 14.29,7.13 13.4,6.24 13.4,2.96 13.68,2.67 14.54,2.67 14.94,2.27 20.59,2.27 20.96,2.65 28.61,2.65 28.95,2.99 28.95,3.73 29.16,3.95 31.12,3.95 31.2,3.86 31.2,2.8 31.46,2.55 31.86,2.55 32.14,2.83 32.14,3.86 32.23,3.95 33.47,3.95 33.55,3.86 33.55,2.76 33.76,2.55 34.2,2.55 34.41,2.76 34.41,3.86 34.49,3.95 34.76,3.95 34.85,3.86 34.85,2.76 35.06,2.55 35.49,2.55 35.7,2.76 35.7,3.86 35.79,3.95 37.48,3.95 37.81,4.27 37.81,5.73 38.35,6.27 38.41,6.27 41.96,9.82 44.01,9.82 48.12,13.92 48.12,15.22 48.37,15.47 48.88,15.47 49.61,14.74 53.36,14.74 53.66,15.04 53.66,16.83 52.82,17.66 52.41,17.66 52.21,17.46 52.21,16.39 52.16,16.34 51.81,16.34 51.62,16.53 51.62,17.84 51.42,18.05 50.49,18.05 50.28,17.84 50.28,15.79 50.14,15.66 50,15.66 49.68,15.98 49.68,19.07 49.47,19.28 48.76,19.28 48.53,19.04 48.53,16.4 48.42,16.29 48.12,16.29 47.03,17.39 47.03,18.81 48.19,19.97 49.7,19.97 50,20.26 50,21.09 v2(50.1,21.19)
  IN3 w0.089: v2(24.23,11.03) 24.38,10.88 24.59,10.88 24.7,10.99 24.7,11.16 24.37,11.49 24.37,13.54 23.58,14.33 23.58,17.26 23.68,17.36 23.68,17.77 22.56,18.89 22.56,19.31 21.63,20.23 21.63,22.57 21.83,22.77 22,22.77 v1(22.2,22.97) ; v2(95.95,39.72) 95.66,39.72 95.56,39.82 94.17,39.82 93.99,40 93.91,40 93.31,40.6 91.87,40.6 91.6,40.86 91.6,41.24 90.64,42.2 86.95,42.2 85.78,41.03 85.78,40.16 84.74,39.12 84.74,37.91 84.35,37.52 84.35,35.23 84.69,34.89 84.69,34.56 84.48,34.35 83.94,34.35 83.28,33.69 81.99,33.69 78.36,30.06 78.36,29.07 77.8,28.51 76.34,28.51 75.17,27.34 75.17,26.7 73.12,24.65 69,24.65 68.82,24.83 66.02,24.83 65.26,24.07 64.98,24.07 63.93,23.02 52.54,23.02 50.14,20.62 50.01,20.62 49.92,20.71 49.92,21.01 v2(50.1,21.19)
  BOTTOM w0.102: C675.2 21.59,23.03 21.7,22.92 22.15,22.92 v1(22.2,22.97) ; v2(95.95,39.72) 96.52,39.16 U24.DF3
USB30_TX+_TYPEC1: length 25.4
  IN1 w0.089: v2(15.35,18.45) 15.14,18.24 15.14,17.67 15.58,17.23 15.58,16.9 15.38,16.7 14.72,16.7 14.59,16.57 14.59,16.35 14.73,16.22 15.8,16.22 15.99,16.4 15.99,18.63 15.61,19.01 15.61,19.32 15.85,19.57 16.19,19.57 16.8,18.96 16.8,16.03 16.17,15.4 13.83,15.4 v1(13.65,15.23)
  BOTTOM w0.102: CN14.A2 8.57,13.65 8.9,13.32 9.38,13.32 9.71,13.65 9.71,15.12 9.86,15.26 10,15.26 10.14,15.12 RV2.6 RV2.5 11.66,15.12 11.8,15.26 12.16,15.26 12.5,15.59 12.85,15.59 13,15.44 13.44,15.44 v1(13.65,15.23) ; v2(15.35,18.45) 15.28,18.53 15.28,19.01 15.42,19.15 C702.1
USB30_TX+_TYPEC1_C: length 3.2
  BOTTOM w0.102: C702.2 15.22,19.93 15.09,20.06 15.09,20.22 16.41,21.54 U34.10
USB30_TX+_TYPEC2: length 25.8
  TOP w0.102: CN14.B2 5.52,18.11 9.2,18.11 9.61,17.7 9.61,17.18 9.82,16.97 10.09,16.97 10.23,17.12 RV1.6 RV1.5 11.76,17.12 11.88,17 12.09,17 12.19,17.1 12.19,17.57 v1(12.63,18.02)
  IN1 w0.089: v1(12.63,18.02) 12.42,17.8 12.25,17.8 12,18.05 12,19.62 11.36,20.26 11.36,23.07 12.01,23.72 13.16,23.72 14.92,25.49 15.48,25.49 15.69,25.7 15.69,26.16 15.78,26.25 16.05,26.25 16.14,26.16 16.14,25.7 16.34,25.49 17.31,25.49 17.79,25.97 17.79,26.28 v1(17.97,26.45)
  BOTTOM w0.102: C669.1 18.34,25.65 17.97,26.02 v1(17.97,26.45)
USB30_TX+_TYPEC2_C: length 1.6
  BOTTOM w0.102: C669.2 18.2,24.47 18.2,24.23 18.3,24.14 U34.17
USB30_TX-_TYPEC1: length 25.5
  IN1 w0.089: v1(13.65,15.86) 13.65,15.76 13.8,15.61 16.09,15.61 16.6,16.12 16.6,18.88 16.11,19.37 15.94,19.37 15.81,19.24 15.81,19.09 16.19,18.71 16.19,16.32 15.89,16.01 14.64,16.01 14.39,16.27 14.39,16.66 14.63,16.9 15.29,16.9 15.38,16.99 15.38,17.15 14.94,17.59 14.94,18.27 v2(14.75,18.45)
  BOTTOM w0.102: v1(13.65,15.86) 13.45,15.66 13.09,15.66 12.94,15.81 12.41,15.81 12.07,15.47 11.78,15.47 11.64,15.61 RV2.4 RV2.7 10.14,15.61 10,15.47 9.77,15.47 9.5,15.2 9.5,13.74 9.29,13.54 8.99,13.54 8.66,13.87 7.82,13.87 7.73,13.96 7.73,14.04 7.62,14.15 CN14.A3 ; v2(14.75,18.45) 15.06,18.76 15.06,19.05 14.96,19.15 C701.1
USB30_TX-_TYPEC1_C: length 3.2
  BOTTOM w0.102: U34.11 16.51,21.94 14.88,20.31 14.88,20.15 C701.2
USB30_TX-_TYPEC2: length 25.7
  TOP w0.102: CN14.B3 5.52,17.89 9.11,17.89 9.4,17.61 9.4,17.09 9.73,16.76 10.06,16.76 10.2,16.62 RV1.7 RV1.4 11.71,16.62 11.88,16.78 12.18,16.78 12.4,17.01 12.4,17.26 12.53,17.39 v1(12.63,17.39)
  IN1 w0.089: v1(12.63,17.39) 12.42,17.6 12.17,17.6 11.8,17.97 11.8,19.54 11.16,20.17 11.16,23.16 11.93,23.93 13.07,23.93 14.84,25.69 15.4,25.69 15.49,25.78 15.49,26.25 15.7,26.45 16.13,26.45 16.34,26.25 16.34,25.78 16.43,25.69 17.22,25.69 17.59,26.05 17.59,26.2 v1(17.33,26.45)
  BOTTOM w0.102: v1(17.33,26.45) 17.75,26.03 17.75,25.81 C668.1
USB30_TX-_TYPEC2_C: length 1.6
  BOTTOM w0.102: U34.16 17.9,24.14 17.99,24.23 17.99,24.47 C668.2
USB30_TX_N4: length 2.3
  TOP w0.102: v2(98.59,39.31) 98.51,39.23 R273.1
  BOTTOM w0.102: U24.DF2 97.73,39.48 98.36,39.48 98.54,39.31 v2(98.59,39.31)
USB30_TX_P4: length 4
  TOP w0.102: v2(99.17,39.31) 98.74,39.74 97.47,39.74 96.96,39.23 R273.2
  BOTTOM w0.089: v2(99.17,39.31) 99.15,39.31 99.12,39.28 99.12,39.23 98.83,38.94 98.44,38.94 98.22,39.16 U24.DF1
USB_BC_ON: length 219.7
  TOP w0.102: U13.97 197.25,29.27 197.6,28.92 197.6,28.51 197.38,28.3 197.21,28.3 197.12,28.21 197.12,26.76 196.95,26.59 196.26,26.59 195.21,25.54 195.21,24.57 196.49,23.29 196.99,23.29 197.32,22.96 197.32,22.69 196.61,21.98 196.61,20.97 196.81,20.76 197.28,20.76 v2(197.47,20.57) ; U7.4 22.31,47.03 v1(22.34,47.05) 22.92,46.47 24.88,46.47 v1(25.01,46.6)
  IN2 w0.089: v2(197.47,20.57) 197.47,20.57 197.47,20.3 197.09,19.93 196.38,19.93 196.37,19.93 193.75,19.93 192.61,18.79 191.94,18.79 190.49,20.24 181.33,20.24 180.88,20.69 179.23,20.69 178.96,20.96 177.54,20.96 177.38,20.81 173.18,20.81 173.07,20.69 170.56,20.69 170.22,20.35 168.25,20.35 168.07,20.17 162.96,20.17 162.62,20.51 155.25,20.51 155.07,20.33 139.4,20.33 138.49,21.25 133.67,21.25 133.66,21.26 126.31,21.26 126.02,21.55 122.49,21.55 121.73,20.79 121.35,20.79 120.78,20.22 119.89,20.22 119.57,19.9 119.57,19.24 119.37,19.04 114.65,19.04 114.36,19.33 112.32,19.33 111.54,18.55 104.96,18.55 104.3,17.89 91.3,17.89 88.25,20.94 84.29,20.94 80.26,16.9 73.89,16.9 73.17,16.18 70.63,16.18 70.53,16.08 64.37,16.08 60.65,19.8 58.26,19.8 57.59,20.47 54.1,20.47 52.9,21.68 51.47,21.68 50.29,20.5 48.92,20.5 47.87,21.54 47.87,22.79 46.07,24.59 46.07,24.78 45.72,25.13 42.05,25.13 39.34,27.84 35.79,27.84 34.34,29.29 31.47,29.29 27.3,33.46 27.15,33.46 24.2,36.4 24.2,45.78 v1(25.01,46.6)
USB_CHARGE_ON: length 215.4
  TOP w0.102: v2(197.01,21.2) 197.01,21.27 196.84,21.45 196.84,21.88 197.55,22.59 197.55,23.06 197.08,23.52 196.64,23.52 195.44,24.73 195.44,25.44 196.37,26.36 197.19,26.36 197.34,26.52 197.34,27.93 197.59,28.18 U13.96 ; v1(25.01,47.23) 24.7,47.23 24.18,47.75 R234.1 23.17,47.75 23.04,47.88 U7.5
  IN2 w0.089: v2(197.01,21.2) 196.94,21.27 196.61,21.27 195.65,20.32 193.59,20.32 193.09,19.81 191.58,19.81 190.73,20.66 183.22,20.66 182.41,21.46 181.06,21.46 180.67,21.07 179.39,21.07 179.06,21.4 177.35,21.4 177.14,21.19 173,21.19 172.89,21.07 170.41,21.07 170.06,20.73 168,20.73 167.82,20.55 163.12,20.55 162.77,20.91 155.1,20.91 154.91,20.71 139.56,20.71 138.65,21.63 133.83,21.63 133.77,21.69 126.51,21.69 126.19,22.01 120.88,22.01 119.84,20.97 116.6,20.97 116.15,20.52 116.15,19.88 115.98,19.71 112.15,19.71 111.48,19.04 104.51,19.04 103.92,18.45 93.01,18.45 92.05,19.4 90.73,19.4 88.67,21.46 84.28,21.46 80.1,17.28 73.62,17.28 73,16.66 70.57,16.66 70.37,16.46 64.66,16.46 60.73,20.38 58.22,20.38 57.75,20.85 54.26,20.85 53.05,22.06 50.2,22.06 49.59,22.67 49,22.67 48.53,23.15 48.53,24.57 47.58,25.51 42.21,25.51 39.47,28.25 35.97,28.25 34.5,29.72 31.63,29.72 27.49,33.86 27.28,33.86 24.61,36.54 24.61,42.84 25.41,43.65 25.41,46.83 v1(25.01,47.23)
USB_CLT1: length 207.6
  TOP w0.102: v2(197.27,21.73) 197.27,21.6 197.49,21.38 U13.79 ; U7.6 24.09,48.38 24.6,47.87 v1(25.01,47.87) 25.01,48.19 v1(25.33,48.51)
  IN2 w0.089: v2(197.27,21.73) 197.17,21.63 196.69,21.63 195.57,20.51 193.11,20.51 192.88,20.73 190.93,20.73 190.81,20.85 183.3,20.85 181.96,22.19 179.56,22.19 179.31,21.93 177.18,21.93 176.82,21.57 172.8,21.57 172.69,21.46 170.25,21.46 169.91,21.11 167.82,21.11 167.65,20.93 163.97,20.93 162.97,21.94 157.01,21.94 156.64,21.58 155.23,21.58 154.77,21.11 139.92,21.11 138.8,22.24 133.4,22.24 133.26,22.1 126.64,22.1 126.35,22.39 121.35,22.39 121.14,22.59 119.9,22.59 118.91,21.6 116.52,21.6 115.86,20.94 113.11,20.94 111.51,19.34 104.41,19.34 103.8,18.73 93,18.73 92.08,19.65 90.76,19.65 88.75,21.65 84.2,21.65 80.02,17.47 73.45,17.47 72.93,16.95 70.6,16.95 70.29,16.65 64.98,16.65 60.95,20.69 58.18,20.69 57.82,21.04 54.34,21.04 53.13,22.25 50.28,22.25 49.67,22.86 49.08,22.86 48.72,23.22 48.72,24.65 47.65,25.72 42.28,25.72 39.54,28.45 36.06,28.45 34.57,29.94 31.71,29.94 27.58,34.07 27.35,34.07 24.81,36.6 24.81,42.75 25.61,43.55 25.61,47.26 v1(25.01,47.87)
USB_ID: length 5.5
  TOP w0.102: R286.2 99.99,36.72 99.94,36.68 v2(99.94,36.65)
  BOTTOM w0.079: U24.DL6 95.6,36.72 95.84,36.96 98.18,36.96 98.54,36.6 98.69,36.6 98.82,36.47 99.29,36.47 99.46,36.65 v2(99.94,36.65)
USB_OC0#: length 160.7
  TOP w0.102: v1(17.71,37.71) 17.18,38.24 v1(17.18,41.67) 15.81,43.04 15.81,45.2 16.27,45.66 16.27,47.79 14.79,49.26 14.79,49.77 15.05,50.02 16.93,50.02 17.57,49.38 U7.13
  IN3 w0.089: v1(17.71,37.71) 15.89,35.88 15.89,27.59 15.13,26.83 14.78,26.83 11.21,23.26 11.21,20.37 12.31,19.27 13.17,19.27 14.16,18.28 14.16,16.77 15.63,15.29 17.01,15.29 17.96,14.35 17.96,12.92 15.42,10.38 15.42,4.05 17.69,1.77 33.69,1.77 35.78,3.86 37.66,3.86 38.15,4.34 38.87,4.34 40.33,5.81 40.33,6.25 41.85,7.77 43.15,7.77 43.57,8.19 46.94,8.19 48.61,9.87 48.61,11.59 48.92,11.9 52.62,11.9 53.71,12.98 54.35,12.98 55.2,13.83 58.35,13.83 58.74,13.45 59.17,13.45 60,14.27 70.09,14.27 70.17,14.35 73.86,14.35 75.67,16.15 80.38,16.15 85.04,20.81 86.39,20.81 89.77,24.2 90.28,24.2 91.37,23.1 v2(91.37,22.72)
  BOTTOM w0.079: 93.03,29.2 93.13,29.29 C654.2 93.31,29.42 92.9,29.83 92.9,30.51 91.96,31.44 91.96,31.98 91.59,32.36 U24.DW14
  BOTTOM w0.102: 93.03,29.2 92.93,29.09 92.93,28.73 92.8,28.6 92.8,27.34 92.85,27.29 R768.2 93.18,26.65 93.36,26.47 93.36,26 93.51,25.84 93.51,25.43 93.21,25.13 92.7,25.13 91.37,23.8 v2(91.37,22.72)
USB_OC1#: length 162
  TOP w0.102: v1(60.64,27.42) 60.51,27.29 v1(60.51,26.77) 60.51,26.4 60.21,26.1 54.84,26.1 54.7,25.96 52.96,25.96 52,25.01 52,23.61 53.15,22.47 53.15,20.74 52.94,20.53 52.94,18.53 52.46,18.05 52.46,15.99 v1(52.21,15.73) ; v2(78.38,45.48) 78.38,45.66 78.17,45.87 77.72,45.87 77.29,45.45 C329.2 76.82,45.45 76.2,44.83 75.59,44.83 73.77,43.01 73.37,43.01 71.62,41.26 v1(70.14,41.26) ; v1(25.01,45.96) 24.57,45.96 23.81,45.2 23.81,42.95 22.22,41.36 20.36,41.36 18.22,39.23 v1(17.71,39.23)
  IN3 w0.089: v1(52.21,15.73) 48.21,11.73 48.21,10.11 47.38,9.28 44.12,9.28 43.01,8.18 41.68,8.18 39.93,6.42 39.93,5.98 38.67,4.72 37.99,4.72 37.51,4.24 35.62,4.24 33.56,2.18 17.83,2.18 15.8,4.21 15.8,10.22 18.38,12.8 18.38,14.5 16.17,16.71 16.17,18.47 14.95,19.69 12.49,19.69 11.62,20.56 11.62,23.06 14.97,26.42 15.3,26.42 16.01,27.14 16.98,27.14 17.26,27.42 17.26,28 17,28.26 16.62,28.26 16.11,28.76 16.11,35.17 16.7,35.75 17.16,35.75 18.15,36.74 18.15,38.8 v1(17.71,39.23)
  BOTTOM w0.102: v2(78.38,45.48) 78.38,45.34 78.65,45.07 U24.CR41 ; U28.3 18.54,45.13 18.86,44.82 19.37,44.82 20.13,45.58 24.63,45.58 v1(25.01,45.96) ; v1(60.64,27.42) 60.56,27.5 60.56,28.31 61.06,28.82 61.06,37.79 62.19,38.93 62.19,39.88 62.91,40.6 R678.2 63.66,40.6 64.35,41.28 65.83,41.28 66.41,40.7 67.8,40.7 68.36,41.26 v1(70.14,41.26)
USB_OC2#: length 184
  TOP w0.102: v2(78.82,44.51) 78.82,44.51 78.8,44.49 78.8,44.25 78.71,44.15 78.71,43.83 78.45,43.58 78.14,43.58 77.91,43.36 77.37,43.36 77.13,43.11 75.01,43.11 73.38,41.49 72.86,41.49 71.36,39.99 68.67,39.99 67.88,39.2 C344.2 66.34,39.2 65.73,38.59 R276.2
  IN1 w0.089: v2(78.82,44.51) 79.01,44.51 79.44,44.94 81.39,44.94 82.54,43.8 82.54,36.82 82.56,36.79 82.56,36.26 82.84,35.98 83.29,35.98 83.82,35.44 84.16,35.44 84.42,35.7 84.42,37.32 84.92,37.83 86.93,37.83 87.18,37.58 87.18,36.1 87.38,35.91 87.87,35.91 88.53,35.25 89.72,35.25 89.98,35.51 89.98,37.96 90.36,38.34 92.39,38.34 92.64,38.09 92.64,36.82 92.9,36.56 92.9,35.55 94.26,34.19 95.22,34.19 95.82,34.78 96.45,34.78 96.67,34.57 99.8,34.57 100.19,34.17 101.53,34.17 102.06,33.65 108.96,33.65 109.24,33.37 109.75,33.37 113.16,29.96 122.03,29.96 124.89,32.81 129.04,32.81 129.74,33.51 132.14,33.51 132.59,33.07 133.22,33.07 133.69,33.54 143.06,33.54 145.36,31.24 155.24,31.24 155.92,30.57 158.91,30.57 159.27,30.21 160.64,30.21 160.74,30.11 161.35,30.11 161.64,30.4 163.07,30.4 163.24,30.22 163.75,30.22 164.3,29.67 170.53,29.67 171.63,28.57 175.26,28.57 176.3,29.62 178.59,29.62 178.77,29.43 181.96,29.43 182.53,30 189.25,30 189.93,29.32 193.81,29.32 194.45,28.69 194.45,28.1 194.64,27.91 194.64,26.97 195.61,26 195.82,26 197.19,24.62 200.54,24.62 200.82,24.34 201.76,24.34 202.15,24.73 203.51,24.73 204.39,23.85 204.97,23.85 205.54,23.28 207.68,23.28 208.05,22.92 208.05,18.97 208.72,18.3 v2(209.15,18.3)
  BOTTOM w0.102: v2(209.15,18.3) 209.54,18.68 209.54,19.59 v1(209.1,20.03) 208.81,20.32 U35.3 ; U24.CT41 78.65,44.21 78.8,44.36 78.8,44.49 78.82,44.51 v2(78.82,44.51)
