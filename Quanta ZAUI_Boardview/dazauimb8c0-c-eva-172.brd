# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_AZ_CODEC_SYNC: length 219.5
  IN1 w0.089: v2(53.66,25.29) 53.66,24.57 53.96,24.27 53.96,23.57 55.46,22.07 55.46,21.52 56.04,20.94 56.73,20.94 58.96,18.71 60.71,18.71 65.7,13.71 70.32,13.71 71.26,12.77 73.91,12.77 74.8,11.89 79.32,11.89 82.41,8.8 83.21,8.8 83.73,8.28 88.51,8.28 88.6,8.37 89.04,8.37 89.35,8.69 89.78,8.69 92.96,11.87 92.96,12.04 93.18,12.26 93.18,12.51 93.37,12.7 93.37,13.33 93.83,13.79 113.23,13.79 113.84,14.4 116.94,14.4 117.56,13.78 181.55,13.78 185.48,9.85 204.9,9.85 205.67,10.63 205.67,11.11 206.13,11.57 206.13,12.06 206.56,12.5 206.56,15.1 206.94,15.48 206.94,16.77 206.7,17.01 206.7,17.76 206.27,18.19 206.27,19.88 206.51,20.13 v2(207.02,20.13)
  BOTTOM w0.102: v2(207.02,20.13) 206.51,20.13 206.21,19.82 204.68,19.82 204.02,19.16 201.99,19.16 v1(201.9,19.26) 201.8,19.35 201.8,20.75 200.82,21.73 200.82,23.76 202.47,25.41 202.47,26.15 201.79,26.83 201.79,27.77 202.45,28.43 202.88,28.43 203.11,28.66 203.11,28.82 203.26,28.96 U30.10 ; v2(53.66,25.29) 53.66,25.39 54.04,25.77 55.06,25.77 55.34,26.05 55.6,26.05 55.93,26.37 57.28,26.37 57.49,26.58 61.14,26.58 63.05,28.49 63.05,29.03 62.83,29.26 62.83,29.87 62,30.7 62,37.39 63.54,38.93 64.52,38.93 64.64,39.05 65.2,39.05 65.76,39.61 R682.1
PCH_BLON_C: length 12.5
  TOP w0.102: Q4.5 56.58,103.62 57,104.04 57.45,104.04 v1(57.59,104.18) 57.59,106.23 57.29,106.53 57.29,107.13 57.6,107.44 R28.2 57.85,107.68 57.64,107.89 R20.2 57.84,108.44 58.35,108.95 R19.1 58.71,108.95 59.24,109.49 59.24,109.97 59.65,110.37 60.87,110.37 61.02,110.22 61.53,110.22 61.78,110.48 61.78,110.63 R12.2
PCH_BLON_EC: length 211.8
  TOP w0.102: U13.88 198.03,24.98 197.8,25.21 v2(197.75,25.21) ; v2(59.12,101.33) 58.79,101.66 58.15,101.66 58.02,101.79 58.02,106.48 R28.1
  IN2 w0.089: v2(197.75,25.21) 197.78,25.21 198.31,25.74 198.31,27.77 197.78,28.31 197.01,28.31 196.76,28.56 196.76,29.43 195.85,30.34 182.84,30.34 182.64,30.14 180.25,30.14 179.06,31.33 176.69,31.33 175.26,32.76 167.49,32.76 167.27,32.53 165.98,32.53 165.78,32.73 164.65,32.73 163.87,33.51 163.73,33.51 163.37,33.88 162.47,33.88 161.64,34.71 159.11,34.71 158.83,34.99 157.01,34.99 156.36,34.34 153.13,34.34 152.77,34.7 148.17,34.7 147.58,35.29 147.09,35.29 146.34,36.04 146.34,36.57 143.38,39.53 141.24,39.53 140.75,39.05 136.99,39.05 136.87,38.92 123.36,38.92 120.99,36.56 118.28,36.56 117.33,35.6 114.7,35.6 113.33,36.97 113.33,39.15 112.24,40.25 111.57,40.25 110.34,41.48 110.34,43.2 110.78,43.65 110.78,45.38 110.93,45.53 110.93,48.68 110.27,49.34 110.27,51.01 106.56,54.72 104.67,54.72 102.41,56.99 102.41,60.66 102.18,60.9 102.18,62.6 103.05,63.47 103.05,72.96 102.36,73.65 99.5,73.65 99.1,74.05 98.54,74.05 96.39,76.2 94.99,76.2 94.32,76.87 94.32,77.69 93.16,78.85 91.45,78.85 88.83,81.47 86.42,81.47 84.9,82.99 84.9,84.31 84.33,84.89 84.33,85.39 83.12,86.6 82.61,86.6 81.82,87.39 81.82,91.78 82.9,92.85 82.9,95.8 82.25,96.44 73.73,96.44 72.78,97.4 72.78,98.59 72.2,99.17 71.57,99.17 71.06,98.67 61.78,98.67 v2(59.12,101.33)
PCH_DISP_ON: length 66.6
  IN1 w0.089: v2(88.61,36.38) 88.1,36.89 88.1,38.24 87.65,38.68 87.65,41.13 87.46,41.32 87.46,50.57 87.64,50.75 87.64,54.28 87.78,54.42 87.78,60.22 87.9,60.34 87.9,60.72 88.11,60.93 88.11,67.2 87.81,67.5 87.81,75.26 87.37,75.69 87.37,77.34 87.18,77.53 87.18,81.27 86.7,81.75 86.7,83.3 86.08,83.92 86.08,84.78 85.13,85.74 85.13,87.21 84.87,87.46 84.87,90.16 86.09,91.38 86.09,93.1 85.33,93.86 83.6,93.86 v1(82.1,95.36)
  BOTTOM w0.079: U24.DN21 88.26,36.07 88.58,36.38 v2(88.61,36.38)
  BOTTOM w0.102: R536.2 83,95.32 v1(82.84,95.16) 82.31,95.16 v1(82.1,95.36)
PCH_DPST_PWM: length 121.1
  TOP w0.102: v2(54.21,100.49) 54.21,101.59 53.71,102.09 52.06,102.09 51.83,102.32 51.83,103.19 51.93,103.29 53.83,103.29 54.55,104 54.55,105.57 54.09,106.03 54.09,106.43 53.61,106.91 R25.1
  IN2 w0.089: v1(64.83,97.27) 67.17,97.27 68.39,96.05 82.09,96.05 82.5,95.63 82.5,93.01 81.42,91.93 81.42,87.24 82.46,86.19 82.92,86.19 83.88,85.23 83.88,83.27 85.39,81.76 85.39,77.49 86.22,76.67 86.22,57.09 85.86,56.73 85.86,54.42 85.25,53.81 85.25,43.7 83.65,42.1 82.84,42.1 82.08,41.34 80.68,41.34 80.48,41.13 80.48,39.38 80.71,39.15 82.84,39.15 83.42,38.57 83.42,34.55 85.44,32.54 86.54,32.54 86.98,32.09 87.6,32.09 87.81,32.31 v2(89.39,32.31)
  BOTTOM w0.079: U24.DU19 88.97,33.76 89.24,33.49 89.24,33.22 89.2,33.05 89.2,32.83 89.27,32.68 89.27,32.51 89.39,32.39 v2(89.39,32.31)
  BOTTOM w0.102: v1(64.83,97.27) 64.83,98.41 64.31,98.93 57.17,98.93 56.52,99.58 55.13,99.58 v2(54.21,100.49)
PCH_DSWROK: length 10.3
  BOTTOM w0.079: U24.DR48 74.62,35.4 73.73,35.4 72.15,33.82 72.15,33.51
  BOTTOM w0.102: 72.15,33.51 72.15,32.63 71.51,31.99 69.28,31.99 69.15,32.12 R708.1 R711.1 68.87,31.2 68.26,30.59 R717.1
PCH_IST_TP_0: length 4.8
  TOP w0.102: TP24.1 84.39,44.49 84.39,43.27 83.65,42.53 83.15,42.53 v2(82.99,42.68)
  BOTTOM w0.102: U24.CW33 82.96,42.7 82.97,42.68 v2(82.99,42.68)
PCH_IST_TP_1: length 6.3
  TOP w0.102: TP22.1 84.47,45.25 84.9,44.82 84.9,43.15 83.44,41.69 v2(83.15,41.69)
  BOTTOM w0.102: U24.CY32 83.15,41.92 v2(83.15,41.69)
PCH_JTAGX: length 4.2
  BOTTOM w0.079: 100.39,75.91 99.39,75.91 98.79,75.31 98.56,75.31 98.2,74.94 97.91,74.94 97.66,75.2 U24.N2
  BOTTOM w0.102: 100.39,75.91 100.95,75.91 R604.1
PCH_LVDS_BLON: length 99.2
  TOP w0.102: v1(58.14,109.73) 58.14,109.71 R20.1
  IN1 w0.089: v2(89.6,36.4) 89.43,36.4 89.19,36.64 89.19,37.71 88.05,38.85 88.05,41.3 87.86,41.49 87.86,50.4 88.03,50.58 88.03,54.11 88.17,54.25 88.17,55.95 88.96,56.74 88.96,57.44 88.17,58.23 88.17,60.03 88.34,60.2 88.54,60.2 88.89,60.54 88.89,66.98 88.23,67.64 88.23,75.4 87.77,75.86 87.77,76.92 88.17,77.33 88.17,81.14 87.59,81.72 87.59,83.25 87.31,83.53 87.03,83.53 86.73,83.83 86.73,84.75 85.99,85.48 85.99,90.72 86.52,91.25 86.52,93.23 85.49,94.26 84.05,94.26 81.43,96.87 v1(81.3,96.87)
  IN2 w0.089: v1(58.14,109.73) 58.14,109.29 58.63,108.8 59.87,108.8 61.21,107.45 62.95,107.45 63.6,108.1 64.22,108.1 64.6,107.72 64.6,106.98 70.18,101.4 72.89,101.4 73.46,100.82 74.94,100.82 75.58,100.19 78.84,100.19 81.34,97.69 81.34,96.91 v1(81.3,96.87)
  BOTTOM w0.102: U24.DL19 89.28,36.72 v2(89.6,36.4)
PCH_OPI_RCOMP: length 1.3
  TOP w0.254: v2(96.2,34.15) 96.1,34.25 R296.2
  BOTTOM w0.254: U24.DU3 96.44,33.91 v2(96.2,34.15)
PCH_PWROK: length 172
  TOP w0.102: v2(191.93,27.21) 193.48,25.67 193.48,24.48 195.17,22.8 196.15,21.82 196.15,20.38 196.66,19.87 197.27,19.87 197.58,20.18 197.75,20.18 197.97,20.4 197.97,20.77 198.18,20.98 U13.78
  IN2 w0.089: v2(65.04,31.61) 65.67,30.97 66.48,30.97 66.86,31.36 66.86,32.02 69.25,34.4 70.55,34.4 71.18,33.77 72.2,33.77 72.83,34.4 73.98,34.4 74.23,34.15 74.23,33.78 75,33.01 77.72,33.01 78.29,32.44 83.65,32.44 84.35,31.74 86.68,31.74 86.93,31.48 87.95,31.48 88.3,31.84 89.7,31.84 89.79,31.93 92.98,31.93 93.31,31.6 94.45,31.6 95.05,31 102.32,31 103.38,32.05 108.46,32.05 108.93,32.52 v1(109.41,32.52) 109.94,31.99 117.97,31.99 119.45,33.47 122.17,33.47 123.59,34.9 133.96,34.9 134.4,34.45 135.65,34.45 135.96,34.15 140.57,34.15 141.01,34.58 144.21,34.58 144.74,34.05 144.74,33.72 145.69,32.77 152.1,32.77 152.5,32.37 156.1,32.37 156.46,32.01 159.66,32.01 159.95,31.71 161.4,31.71 161.8,31.32 162.83,31.32 163.46,30.69 164.28,30.69 164.49,30.47 174.94,30.47 176.03,29.39 178.37,29.39 180.29,27.47 183.31,27.47 184.15,28.31 186.24,28.31 187.03,27.52 188.5,27.52 188.54,27.55 191.6,27.55 v2(191.93,27.21)
  IN3 w0.089: v1(105.42,50.28) 105.22,50.07 105.22,46.94 105.46,46.7 105.46,44.08 107.77,41.77 108.03,41.77 108.44,41.36 108.44,37.81 109.3,36.94 109.3,35.49 109,35.19 109,32.94 v1(109.41,32.52)
  BOTTOM w0.102: R703.2 64.73,32.22 65.04,31.91 v2(65.04,31.61) ; v1(105.42,50.28) 105.4,50.28 104.96,50.72 R641.2
PCH_PWROK_R: length 13.1
  BOTTOM w0.079: 70.65,33.54 71.34,33.54 71.95,34.15 71.98,34.15 73.57,35.74 73.95,35.74 74.17,35.96 75.3,35.96 75.57,35.7 U24.DN47
  BOTTOM w0.102: 70.65,33.54 67.84,33.54 67.59,33.29 67.46,33.29 66.95,32.78 66.08,32.78 66,32.85 R703.1 R702.1
PCH_SLP_SUS#: length 9.4
  BOTTOM w0.079: 70.42,33.77 71.33,33.77 72.09,34.53 72.12,34.53 73.5,35.91 73.87,35.91 74.11,36.15 74.54,36.15 U24.DM49
  BOTTOM w0.102: R701.2 66.84,33.23 67.12,33.51 67.49,33.51 67.75,33.77 70.42,33.77
PCH_SPI0_CLK: length 26.3
  IN1 w0.089: v1(77.3,25.31) 76.78,25.31 75.05,27.05 75.05,29.17 73.04,31.18 72.42,31.18 71.26,32.34 71.26,33.31 72.12,34.18 72.12,36.4 72.68,36.96 72.68,38.52 73.34,39.18 73.85,39.18 75.38,40.7 75.97,40.7 76.62,41.35 77.13,41.35 v2(77.67,41.89)
  BOTTOM w0.102: v1(77.3,25.31) 77.83,25.31 R777.2 78.16,25.56 78.86,24.86 R783.2 ; v2(77.67,41.89) 77.64,41.86 77.64,41.68 U24.DB42
PCH_SPI0_MISO: length 17.5
  IN1 w0.089: v2(77.76,39.91) 77.65,39.91 77.41,40.16 76.59,40.16 76.32,39.89 75.71,39.89 74.97,39.14 74.97,38.06 74.14,37.24 74.14,35.85 73.46,35.17 73.46,34.63 73.9,34.18 73.91,34.18 74.05,34.05 74.05,33.54 74.46,33.13 74.46,32.35 74.22,32.11 74.22,31.64 v1(76.87,28.99)
  BOTTOM w0.079: U24.DF43 77.35,39.59 77.68,39.91 v2(77.76,39.91)
  BOTTOM w0.102: R744.2 77.48,28.38 v1(76.87,28.99)
PCH_SPI0_MOSI: length 20.2
  IN1 w0.089: v1(77.84,27.75) 77.84,27.88 77.28,28.43 76.71,28.43 76.36,28.78 76.36,29.13 73.26,32.23 73.26,33.51 73.07,33.71 73.07,35.56 73.29,35.78 73.29,37.51 73.48,37.71 74.19,37.71 74.76,38.28 74.76,39.23 75.63,40.09 76.23,40.09 76.49,40.35 77.28,40.35 77.64,40.71 v2(77.64,40.89)
  BOTTOM w0.102: U24.DD43 77.64,40.7 v2(77.64,40.89) ; R759.2 78.2,27.75 v1(77.84,27.75)
PCH_SPI1_CLK: length 148.8
  TOP w0.102: R403.1 120.08,23.61 119.31,22.85 119.31,21.55 119.7,21.17 119.7,20 v2(120.03,19.67) ; v2(157.69,18.29) 157.69,18.43 158.02,18.76 162.09,18.76 162.28,18.95 162.28,19.61 162.42,19.75 162.42,20.2 162.72,20.5 v1(162.72,22.07) 162.72,24.38 159.19,27.91 159.19,31.12 C373.1 R312.1 159.92,32.32 v1(160.02,32.43) ; v2(193.19,32.94) 193.19,32.87 192.58,32.25 R319.1
  IN1 w0.089: v2(157.69,18.29) 157.22,18.76 155.38,18.76 154.9,19.24 149.11,19.24 148.93,19.42 137.7,19.42 137,18.71 129.54,18.71 129.29,18.97 123.32,18.97 122.52,19.77 121.04,19.77 120.73,19.47 120.23,19.47 v2(120.03,19.67) 119.71,19.67 119.18,19.14 114.19,19.14 113.34,19.99 104.61,19.99 103.72,19.1 98.4,19.1 94.55,22.95 92.52,22.95 91.83,23.63 90.02,23.63 89.84,23.81 81.21,23.81 80.86,24.16 80.2,24.16 80,23.96 v1(78.75,23.96)
  IN3 w0.089: v2(193.19,32.94) 193.17,32.94 192.72,33.39 190.31,33.39 189.95,33.74 188.99,33.74 188.83,33.59 187.72,33.59 186.61,32.49 184.25,32.49 183.75,31.99 183.32,31.99 182.43,31.1 180.53,31.1 180.28,31.36 176.21,31.36 175.29,32.28 167.92,32.28 167.57,31.92 160.53,31.92 v1(160.02,32.43)
  BOTTOM w0.102: R777.1 79.44,24.99 79.44,23.63 79.21,23.4 R789.2 79.03,23.69 v1(78.75,23.96)
PCH_SPI1_CLK_R: length 6.3
  TOP w0.102: R312.2 158.6,32.34 159.09,32.83 159.52,32.83 v2(160.18,33.49) v1(160.18,34.1)
  BOTTOM w0.102: v2(160.18,33.49) 160.18,34.28 160.56,34.66 161.73,34.66 162.16,34.23 U32.6 U33.6
PCH_SPI1_SI: length 160.1
  TOP w0.102: R321.1 194.55,32.56 194.55,33.31 v2(194.75,33.51) ; R417.1 121.07,21.63 120.94,21.5 v2(120.94,21.25) ; v1(160.67,32.42) 160.84,32.25 R323.1 160.54,31.61 159.76,30.83 159.76,28.02 161.13,26.66 v1(161.3,26.66) 161.3,26.48 163.21,24.58 163.21,20.3 162.9,20 162.9,19.55 162.76,19.41 162.76,18.75 162.29,18.27 v2(160.49,18.27)
  IN1 w0.089: v2(160.49,18.27) 160.72,18.5 162.27,18.5 162.57,18.81 162.57,19.75 161.9,20.42 137.43,20.42 136.63,19.61 129.92,19.61 129.56,19.98 126.81,19.98 126.2,20.59 124.09,20.59 123.76,20.92 121.27,20.92 v2(120.94,21.25) 120.76,21.07 119.72,21.07 119.51,21.28 104.32,21.28 103.92,20.88 98.21,20.88 95,24.09 92.98,24.09 92.31,24.75 90.49,24.75 90.03,25.21 88.48,25.21 88.27,25.42 84.08,25.42 83.29,26.21 80.42,26.21 79.72,26.91 79.72,27.51 78.59,28.64 78.42,28.64 78.27,28.48 78.27,27.32 78.85,26.73 78.85,25.44 78.78,25.36 78.61,25.36 77.83,26.14 v1(77.83,26.58)
  IN3 w0.089: v1(160.67,32.42) 161.35,33.1 165.92,33.1 166.2,32.82 167.2,32.82 167.55,33.18 176.55,33.18 176.77,32.95 176.77,32.57 176.97,32.37 178.47,32.37 179.92,33.82 184.57,33.82 184.85,34.1 186.42,34.1 186.68,34.35 187.13,34.35 187.32,34.54 188.48,34.54 188.62,34.68 189.11,34.68 189.44,35.01 193.25,35.01 v2(194.75,33.51)
  BOTTOM w0.102: R698.1 192.27,34.5 192.7,34.07 194.19,34.07 v2(194.75,33.51) ; R759.1 78.01,27.16 R755.1 77.88,26.63 v1(77.83,26.58)
PCH_SPI1_SI_R: length 3.3
  TOP w0.102: v1(161.34,33.12) v1(161.34,32.45) 161.56,32.45 161.81,32.2 161.81,31.8 R323.2
  BOTTOM w0.102: v1(161.34,32.45) 160.89,32.89 U33.5
PCH_SPI1_SO: length 166.3
  TOP w0.102: v2(159.32,18.27) 159.73,17.87 162.41,17.87 162.99,18.45 162.99,19.31 163.13,19.45 163.13,19.9 163.43,20.21 163.43,24.82 162.23,26.02 R382.1 162.23,27 162.01,27.21 160.89,27.21 159.99,28.12 159.99,30.7 160.46,31.18 161.99,31.18 162.16,31.36 v1(162.16,32.45) 162.16,34.17 v1(162.11,34.23) ; v2(193.99,33.64) 193.69,33.34 193.69,32.66 R320.1 ; v2(120.61,20.66) 121.02,20.26 121.02,18.15 121.2,17.97 R448.1 R458.1
  IN1 w0.089: v2(159.32,18.27) 159.19,18.4 158.71,18.4 158.6,18.51 158.6,18.64 158.71,18.76 162.21,18.76 162.36,18.9 162.36,19.66 161.81,20.2 137.52,20.2 136.72,19.4 129.83,19.4 129.47,19.76 126.72,19.76 126.11,20.37 124,20.37 123.71,20.66 v2(120.61,20.66) 119.82,20.66 119.42,21.07 104.41,21.07 104.01,20.66 98.12,20.66 94.92,23.86 92.9,23.86 92.23,24.54 90.4,24.54 89.95,24.98 87.1,24.98 86.87,25.21 83.99,25.21 83.2,25.99 82.64,25.99 82.55,25.91 82.55,25.27 82.49,25.21 82.26,25.21 82.19,25.27 82.19,25.91 82.1,25.99 81.93,25.99 81.84,25.91 81.84,25.27 81.77,25.21 81.55,25.21 81.48,25.27 81.48,25.91 81.39,25.99 81.22,25.99 81.13,25.91 81.13,25.27 81.06,25.21 80.83,25.21 80.77,25.27 80.77,25.91 80.68,25.99 80.5,25.99 80.42,25.91 80.42,25.27 80.35,25.21 80.12,25.21 80.06,25.27 80.06,25.91 79.82,26.15 79.82,26.5 79.28,27.04 v1(79.28,27.34)
  IN3 w0.089: v2(193.99,33.64) 192.84,34.8 189.53,34.8 189.19,34.45 188.71,34.45 188.58,34.32 187.43,34.32 187.23,34.12 186.78,34.12 186.52,33.87 184.97,33.87 184.69,33.59 181.24,33.59 179.79,32.14 176.44,32.14 175.62,32.96 167.64,32.96 167.28,32.61 166.11,32.61 165.83,32.89 162.37,32.89 162.19,32.7 162.19,32.47 v1(162.16,32.45)
  BOTTOM w0.102: v2(193.99,33.64) 193.94,33.69 192.77,33.69 192.14,33.06 R700.1 ; v1(79.28,27.34) 79.28,27.37 78.56,28.09 R744.1
PCH_SPI1_SO_R: length 3.1
  TOP w0.102: R382.2 162.83,26.59 v2(162.83,27.65)
  BOTTOM w0.102: v2(162.83,27.65) 162.83,27.49 163.43,26.88 U33.2
PCH_SPI_CS0#: length 172.6
  TOP w0.102: v2(158.28,18.27) 157.96,17.96 157.96,17.78 158.1,17.64 162.51,17.64 163.85,18.99 163.85,19.97 v1(164.17,20.28) 164.48,20.6 164.48,24.7 164.74,24.96 164.74,25.94 R384.2 165.01,26.54 165.01,29.42 166.05,30.46 166.05,31.23 165.92,31.36 165.72,31.36 165.37,31.71 v2(165.37,32.35) ; v2(195.01,32.93) 195.21,32.73 R322.1
  IN1 w0.089: v2(77.05,40.78) 77.02,40.78 76.91,40.89 76.73,40.89 76.14,40.3 75.55,40.3 74.56,39.31 74.56,38.34 74.18,37.96 74.18,37.96 74.11,37.9 73.39,37.9 73.09,37.6 73.09,36.23 72.84,35.98 72.84,33.87 72.39,33.42 72.39,32.18 72.54,32.03 73.16,32.03 76.1,29.08 76.1,28.3 76.19,28.21 76.38,28.21 76.47,28.12 76.47,27.94 76.38,27.85 76.19,27.85 76.1,27.76 76.1,27.5 76.18,27.42 77.48,27.42 77.53,27.37 77.53,27.19 77.46,27.12 76.17,27.12 76.1,27.05 76.1,26.96 76.79,26.28 77.39,26.28 78.68,24.99 82.66,24.99 82.82,25.14 82.82,25.69 82.91,25.78 83.08,25.78 83.17,25.69 83.17,25.05 83.24,24.99 86.78,24.99 87.01,24.76 89.86,24.76 90.31,24.32 92.14,24.32 92.82,23.63 94.85,23.63 98.69,19.79 99.83,19.79 99.92,19.87 99.92,20.37 99.98,20.43 100.21,20.43 100.28,20.37 100.28,19.87 100.37,19.79 102.41,19.79 102.5,19.87 102.5,20.37 102.56,20.43 102.79,20.43 102.85,20.37 102.85,19.87 102.94,19.79 103.16,19.79 103.24,19.86 103.24,20.38 103.3,20.45 104.1,20.45 104.5,20.85 119.33,20.85 119.82,20.36 120.38,20.36 120.45,20.29 121,20.29 121.09,20.38 123.02,20.38 123.15,20.26 123.15,19.87 123.23,19.8 123.43,19.8 123.48,19.85 123.48,20.31 123.56,20.38 123.68,20.38 123.85,20.22 123.85,19.53 123.94,19.44 124.1,19.44 124.19,19.52 124.19,20.06 124.28,20.15 124.46,20.15 124.55,20.06 124.55,19.52 124.64,19.44 129.49,19.44 129.74,19.18 136.8,19.18 137.61,19.99 157.17,19.99 157.73,19.43 157.73,19.02 158.28,18.48 v2(158.28,18.27)
  IN3 w0.089: v2(195.01,32.93) 195.01,32.88 194.63,32.5 193.86,32.5 193.64,32.73 193.64,33.36 192.42,34.58 189.62,34.58 189.27,34.23 188.8,34.23 188.68,34.11 187.55,34.11 187.34,33.9 186.88,33.9 186.62,33.64 185.23,33.64 184.59,33.01 184.08,33.01 183.58,32.5 182.81,32.5 181.9,31.58 180.73,31.58 180.48,31.84 176.41,31.84 175.51,32.75 167.73,32.75 167.37,32.39 165.41,32.39 v2(165.37,32.35)
  BOTTOM w0.079: v2(77.05,40.78) 77.04,40.79 77.04,40.9 77.35,41.21 U24.DB43
PCH_SPI_CS0#_R: length 3.3
  TOP w0.102: R384.1 164.49,26.48 v1(164.49,27.21) 164.07,27.63 v2(164.07,27.65)
  BOTTOM w0.102: U33.1 164.7,26.78 164.07,27.42 v2(164.07,27.65)
PCH_SPI_IO2: length 128.1
  TOP w0.102: R363.1 164.45,28.69 163.49,27.72 163.49,27.19 163.89,26.78 163.89,25.49 v1(164.23,25.15) 164.25,25.13 164.25,21.68 v2(164.07,21.5)
  IN1 w0.089: v2(164.07,21.5) 164.07,21.02 163.94,20.89 163.49,20.89 163.38,20.99 156.65,20.99 156.56,21.08 156.56,21.31 156.5,21.37 156.31,21.37 156.21,21.27 156.21,21.08 156.12,20.99 155.94,20.99 155.85,21.08 155.85,21.36 155.76,21.45 155.58,21.45 155.49,21.36 155.49,21.08 155.41,20.99 155.23,20.99 155.14,21.08 155.14,21.36 155.05,21.45 154.87,21.45 154.78,21.36 154.78,21.08 154.65,20.94 154.65,20.94 154.56,20.85 147.74,20.85 147.65,20.94 147.65,21.33 147.56,21.42 147.38,21.42 147.3,21.33 147.3,20.94 147.21,20.85 147.03,20.85 146.94,20.94 146.94,21.33 146.85,21.42 146.67,21.42 146.58,21.33 146.58,20.94 146.5,20.85 146.32,20.85 146.23,20.94 146.23,21.33 146.14,21.42 145.96,21.42 145.87,21.33 145.87,20.94 145.78,20.85 145.61,20.85 145.52,20.94 145.52,21.33 145.43,21.42 145.25,21.42 145.16,21.33 145.16,20.94 145.07,20.85 144.9,20.85 144.81,20.94 144.81,21.33 144.72,21.42 144.54,21.42 144.45,21.33 144.45,20.94 144.36,20.85 144.18,20.85 144.09,20.94 144.09,21.33 144.01,21.42 143.83,21.42 143.74,21.33 143.74,20.94 143.65,20.85 143.47,20.85 143.38,20.94 143.38,21.33 143.29,21.42 143.12,21.42 143.03,21.33 143.03,20.94 142.94,20.85 142.76,20.85 142.67,20.94 142.67,21.33 142.58,21.42 142.41,21.42 142.32,21.33 142.32,20.94 142.23,20.85 142.05,20.85 141.96,20.94 141.96,21.33 141.87,21.42 141.69,21.42 141.61,21.33 141.61,20.94 141.52,20.85 139.61,20.85 139.55,20.92 134.5,20.92 133.63,20.05 130.1,20.05 129.57,20.57 127.13,20.57 125.8,21.89 120.71,21.89 120.45,21.63 119.77,21.63 119.69,21.72 112.8,21.72 112.72,21.79 104.22,21.79 104.02,21.59 98.16,21.59 95.14,24.61 94.05,24.61 93.47,25.2 92.95,25.2 92.86,25.28 92.11,25.28 91.03,26.36 88.33,26.36 87.99,26.02 85.87,26.02 85.25,26.64 80.72,26.64 80.15,27.21 80.15,27.69 78.11,29.72 v1(77.42,29.72) 77.18,29.96 76.56,29.96 75.22,31.3 75.22,33.43 74.61,34.04 74.61,37.17 75.37,37.93 75.37,38.75 76.03,39.41 76.36,39.41 76.64,39.13 77.02,39.13 77.21,39.32 77.97,39.32 78.61,39.97 v2(78.98,39.97)
  BOTTOM w0.102: v2(78.98,39.97) 78.5,39.97 78.27,39.74 78.27,39.72 78.05,39.49 U24.DF42 ; v1(77.42,29.72) 77.3,29.6 R723.1
PCH_SPI_IO3: length 129.5
  TOP w0.102: R335.2 161.24,30.95 160.74,30.95 160.22,30.43 160.22,28.5 v1(160.75,27.97) 161.28,27.44 162.18,27.44 162.42,27.68 162.42,27.82 162.66,28.05 162.99,28.05 163.23,27.82 163.23,27.12 163.66,26.69 163.66,20.11 163.51,19.96 163.51,19.3 163.45,19.24 v2(163.45,19.19)
  IN1 w0.089: v2(79.56,39.95) 79.18,40.34 78.72,40.34 77.92,39.54 77.4,39.54 77.04,39.9 76.6,39.9 76.38,39.69 76.06,39.69 75.17,38.8 75.17,38 74.4,37.22 74.4,33.95 75,33.34 75,31.21 76.51,29.7 76.82,29.7 77.51,29.02 77.73,29.02 v1(77.76,29.05) 78.48,29.05 79.93,27.6 79.93,27.12 80.63,26.43 83.42,26.43 84.21,25.64 87.91,25.64 88.42,26.15 90.94,26.15 92.02,25.07 92.77,25.07 92.86,24.98 93.31,24.98 93.89,24.4 95,24.4 98.02,21.37 104.11,21.37 104.23,21.5 119.6,21.5 119.68,21.42 120.55,21.42 120.81,21.68 125.41,21.68 126.9,20.19 129.65,20.19 130.01,19.83 133.72,19.83 134.58,20.69 139.4,20.69 139.45,20.64 163.18,20.64 163.66,20.15 163.66,19.4 v2(163.45,19.19)
  BOTTOM w0.079: U24.DD41 78.71,40.41 78.99,40.69 79.43,40.69 79.61,40.5 79.61,40.03 79.56,39.98 v2(79.56,39.95)
  BOTTOM w0.102: v1(77.76,29.05) 78.22,29.05 78.39,29.22 R721.1 R722.1
PCH_SUSPWRDNACK: length 104.8
  TOP w0.102: v2(89.46,25.63) 88.96,26.12 R383.2 89.35,26.15 89.37,26.18 R379.1 ; v2(184.97,23.47) 184.95,23.45 184.95,23.4 184.12,22.58 U13.15
  IN2 w0.089: v2(184.97,23.47) 184.4,22.9 183.4,22.9 182.74,23.56 181.19,23.56 180.5,24.25 180.07,24.25 179.34,23.52 179.01,23.52 178.78,23.29 177.26,23.29 176.87,23.67 170.06,23.67 169.68,23.3 168.27,23.3 168.13,23.43 165.82,23.43 165.08,24.17 159.78,24.17 159.75,24.15 157.79,24.15 157.62,24.32 155.2,24.32 154.75,23.87 144.52,23.87 142.74,25.65 138.07,25.65 137.63,26.1 134.58,26.1 134.38,25.89 127.22,25.89 126.85,25.52 121.46,25.52 121.07,25.13 118.71,25.13 118.48,24.9 112.33,24.9 110.35,22.92 95.69,22.92 94.88,23.74 92.16,23.74 91.95,23.95 91.25,23.95 91.01,24.19 90.89,24.19 v2(89.46,25.63)
PCH_TCK: length 7.3
  TOP w0.102: R128.1 99.58,78.22 98.44,77.08 98.44,76.47 98.03,76.06 TP15.1 97.62,76.03 96.43,74.84 96.43,74.54 95.93,74.03 v2(95.63,74.03)
  BOTTOM w0.114: v2(95.63,74.03) 95.67,74 96.03,74 U24.R5
PCH_TDI: length 6.7
  BOTTOM w0.079: 100.39,78.55 100.33,78.55 98.5,76.72 98.23,76.72 98.06,76.55 U24.K1
  BOTTOM w0.102: R592.1 103.03,79.51 102.59,79.07 R594.1 102.39,78.79 101.96,78.36 101.49,78.36 101.31,78.55 100.39,78.55
PCH_TDO: length 6.3
  BOTTOM w0.079: 98.59,76.55 98.46,76.55 98.2,76.29 97.9,76.29 97.64,76.55 U24.K2 ; 100.38,78.32 99.71,77.65
  BOTTOM w0.102: 99.71,77.65 99.68,77.65 98.59,76.55 ; R597.1 102.38,78.07 102.25,77.94 R598.1 101.44,77.94 101.05,78.32 100.38,78.32
PCH_TMS: length 8.5
  BOTTOM w0.079: U24.N3 97.04,74.91 97.29,74.91 97.44,74.76 98.26,74.76 98.63,75.14 98.86,75.14 99.42,75.7 100.24,75.7 100.52,75.42
  BOTTOM w0.102: 100.52,75.42 101.84,75.42 101.94,75.32 102.37,75.32 v1(102.54,75.16) 102.54,75.06 103.21,74.39 R607.1 104.04,74.39 R608.1
PCH_TRST#: length 6.5
  BOTTOM w0.079: U24.N5 96.5,75.59 97.98,75.59 98.03,75.64 98.65,75.64 99.37,76.36 99.6,76.36
  BOTTOM w0.102: 99.6,76.36 100.72,76.36 101.08,76.72 R600.1 101.26,76.85 101.33,76.92 R602.1
PCH_TYPEC_UPFB#: length 140.3
  IN3 w0.089: v1(16.8,27.82) 16.65,27.67 16.26,27.67 15.21,26.62 14.89,26.62 11.41,23.15 11.41,20.45 12.39,19.47 14.88,19.47 15.97,18.38 15.97,16.62 18.16,14.43 18.16,12.85 15.61,10.3 15.61,4.13 17.76,1.97 33.63,1.97 35.7,4.05 37.59,4.05 38.07,4.53 38.77,4.53 40.13,5.89 40.13,6.34 41.77,7.97 43.08,7.97 43.52,8.42 46.9,8.42 48.4,9.92 48.4,11.65 48.84,12.09 52.55,12.09 53.63,13.17 54.27,13.17 55.56,14.46 70.01,14.46 70.09,14.54 73.78,14.54 75.59,16.34 80.3,16.34 84.97,21.02 86.32,21.02 89.47,24.17 89.47,24.5 89.85,24.88 89.85,25.26 v2(90.23,25.64)
  BOTTOM w0.079: U24.DT14 91.59,34.49 91.32,34.23 91.32,33.15 91.35,33.09 91.35,32.82 91.34,32.79 91.26,32.63 91.26,32.45 91.8,31.91 91.8,31.37 92.7,30.47 92.7,29.2
  BOTTOM w0.102: v2(90.23,25.64) 90.23,26.02 v1(90.55,26.34) 90.86,26.65 R766.1 R767.1 92.57,27.08 92.57,28.69 92.7,28.82 92.7,29.2 ; v1(16.8,27.82) 15.73,27.82 14.24,26.33 14.24,25.62 12.99,24.37 v1(11.98,24.37) 10.98,24.37 10.48,23.86 10.48,23.1 9.82,22.45 Q42.1
PCIE_CLKREQ_LAN#: length 170.8
  TOP w0.102: v1(55.76,96.13) 55.36,96.53 55.36,98.36 55.74,98.74 55.92,98.74 55.97,98.79 R52.1 56.57,99.13 R44.1 57.93,99.77 58.15,99.55 Q6.3 ; v2(78.45,37.04) 78.45,36.71 76.9,35.17 76.9,33.77 75.75,32.63 75.75,30.34 75.93,30.16 75.93,29.91 76.24,29.6 76.24,29.15 76.35,29.03 76.35,28.85 76.47,28.74 76.47,26.3 76.08,25.92 76.08,25.46 74.55,23.93 74.42,23.93 74.1,23.61 74.1,23.2 74.36,22.95 R414.1 74.04,22.68 73.87,22.85 71.31,22.85 v2(69.76,21.3)
  IN1 w0.089: v1(55.76,96.13) 55.71,96.13 54.95,95.36 53.83,95.36 52.94,96.25 51.78,96.25 49.39,93.86 44.74,93.86 43.7,94.91 31.98,94.91 28.86,91.78 28.86,81.18 28.33,80.65 28.33,74.64 29.3,73.67 29.3,67.93 29.81,67.42 29.81,64.15 29.34,63.68 29.34,56.7 28.52,55.87 28.52,40.51 28.74,40.29 28.74,39.3 31.77,36.26 36.05,36.26 36.84,35.47 43.78,35.47 45.35,33.9 46.04,33.9 47.6,32.33 47.6,30.86 50.84,27.62 50.84,26.72 51.38,26.17 52.41,26.17 53.15,26.91 53.15,28.21 53.02,28.33 53.02,29.45 53.3,29.73 57.45,29.73 58.11,29.07 60.27,29.07 61.75,27.59 61.75,25.79 64.69,22.85 65.47,22.85 65.87,22.44 65.87,21.22 66.3,20.79 69.25,20.79 v2(69.76,21.3)
  BOTTOM w0.102: U24.DN40 78.45,36.59 v2(78.45,37.04)
PCIE_CLKREQ_SSD#: length 84.3
  TOP w0.102: v1(73.8,11.82) 73.8,11.86 75.27,13.33 75.27,14.28 76.1,15.1 76.96,15.1 78.09,16.24 78.09,18.2 81.6,21.7 v1(81.6,22.63) 81.6,23.56 81.11,24.04 81.11,25.03 81.73,25.65 R390.1 81.98,25.79 82.28,26.1 82.28,27.98 82.66,28.36 82.66,28.89 81.34,30.21 81.34,32.88 81.52,33.06 81.52,35.9 v2(82.18,36.56)
  IN1 w0.089: v1(47.69,7.86) 47.99,8.16 47.99,9.18 48.7,9.89 48.7,11.42 48.86,11.57 70.93,11.57 71.18,11.82 v1(73.8,11.82)
  BOTTOM w0.102: v1(47.69,7.86) 47.56,7.73 42.07,7.73 39.44,5.1 34.48,5.1 33.55,4.16 27.48,4.16 27,3.68 27,3.04 27.1,2.94 CN18.52 ; v2(82.18,36.56) 81.71,36.1 U24.DN34
PCIE_CLKREQ_VGA#: length 70.1
  TOP w0.102: R342.1 84.82,30.62 83.65,31.79 83.65,33.18 83.5,33.33 83.5,34.24 83.27,34.47 83.27,36.08 83.41,36.21 83.41,36.61 v2(82.99,37.03)
  IN1 w0.089: v1(82.97,87.03) 83.78,86.22 83.78,85.81 84.67,84.92 84.67,84.09 85.96,82.79 85.96,81.44 86.24,81.16 86.24,75.8 87.06,74.99 87.06,66.2 87.34,65.92 87.34,61.2 87.06,60.92 87.06,54.72 86.92,54.58 86.92,51.05 86.65,50.78 86.65,49.24 85.25,47.84 85.25,45.5 85.53,45.21 85.53,40.35 83.53,38.34 83.53,37.57 v2(82.99,37.03)
  BOTTOM w0.102: v2(82.99,37.03) 83,37.04 83,37.05 82.67,37.37 U24.DK33 ; v1(82.97,87.03) 83.65,87.72 v1(83.65,88.57) 83.65,89.42 84.9,90.66 Q31.3 85.24,93.03 85.37,93.03 85.66,93.32 85.66,93.95 R542.1
PCIE_CLKREQ_WLAN#: length 115.6
  TOP w0.102: R377.1 79.97,28.66 79.44,29.2 79.44,33.95 80.32,34.82 v2(80.32,35.1) ; v2(173.41,25.87) 173.54,25.74 173.54,25.13 173.59,25.09 v1(173.59,23.05) Q18.3
  IN1 w0.089: v2(80.32,35.1) 80.32,34.59 80.67,34.24 80.67,34.07 82.09,32.64 86.41,32.64 86.84,33.08 87.43,33.08 87.76,32.75 92.52,32.75 93.58,31.69 95.18,31.69 95.31,31.56 97.01,31.56 97.65,30.93 101.33,30.93 101.53,30.72 103.1,30.72 103.82,30 105.42,30 105.89,29.52 107,29.52 107.73,28.79 109.32,28.79 110.3,27.81 123.53,27.81 124.66,28.94 129.47,28.94 130.06,29.53 132.24,29.53 132.4,29.37 137.02,29.37 137.66,30.01 140.13,30.01 140.31,30.19 143.43,30.19 144.49,29.13 146.07,29.13 147.31,27.9 153.43,27.9 153.81,27.52 155.92,27.52 156.38,27.98 160.53,27.98 161.28,27.24 164.83,27.24 164.95,27.36 168.77,27.36 170.16,25.97 170.62,25.97 171.11,25.48 171.73,25.48 172.12,25.87 v2(173.41,25.87)
  BOTTOM w0.102: v2(80.32,35.1) 80.15,34.93 79.93,34.93 79.44,35.42 U24.DP40
PCIE_RCOMPN: length 4
  TOP w0.102: v2(99.76,35.57) 99.98,35.35 100.12,35.35 100.35,35.58 R292.2
  BOTTOM w0.079: v2(99.76,35.57) 99.76,35.49 99.57,35.31 99.42,35.31 99.13,35.6 98.42,35.6 98.22,35.8 97.99,35.8 97.84,35.75 97.59,35.75 97.47,35.87 97.47,35.95 97.53,36.01 U24.DN1
PCIE_RCOMPP: length 4
  TOP w0.102: v2(99.76,34.97) 99.91,35.13 R292.1
  BOTTOM w0.079: v2(99.76,34.97) 99.59,35.14 99.35,35.14 99.06,35.43 98.35,35.43 98.15,35.63 98.01,35.63 97.87,35.58 97.52,35.58 97.3,35.8 97.3,35.94 97.24,36.01 U24.DN3
PCIE_REQ_LAN#_R: length 23.8
  TOP w0.102: U1.12 44.44,101.79 44.28,101.64 44.28,100.62 44.79,100.11 47.18,100.11 v1(47.53,100.47) 48.61,101.55 48.61,101.75 48.96,102.09 49.46,102.09 49.72,101.84 50.48,101.84 51.12,101.21 52.54,101.21 53.4,100.34 53.4,100.06 53.66,99.81 55.48,99.81 56.22,100.55 R44.2 59.12,100.55 59.17,100.5 Q6.1 60.49,99.92 R55.1
PCIE_RXN9_LAN: length 116.2
  TOP w0.102: C88.2 48.97,103.4 49.07,103.29 49.28,103.29 49.48,103.09 v1(49.79,103.09)
  IN3 w0.089: v2(94.41,45.77) 94.57,45.93 94.65,45.93 94.96,46.24 95.94,46.24 96.09,46.39 98.5,46.39 98.78,46.67 99.22,46.67 99.48,46.93 99.48,47.22 99.12,47.58 99.12,48.42 98.41,49.13 98.41,51.1 98.89,51.58 98.89,54.69 98.61,54.98 97.56,54.98 96.91,55.63 96.91,63.11 97.95,64.15 100.49,64.15 101.92,65.58 101.92,74.7 101.43,75.19 101.43,76.07 101.87,76.5 101.87,78.09 101.2,78.75 101.2,79.56 97.75,83.01 97.75,84.34 96.8,85.29 96.8,89.09 92.44,93.45 92.44,93.84 89.42,96.86 85.91,96.86 85.5,97.27 84.52,97.27 81.85,99.94 79.86,99.94 77.94,101.85 76.09,101.85 74.15,103.79 70,103.79 67.79,106.01 64.08,106.01 61.84,103.77 51.78,103.77 51.1,103.09 51.1,102.55 50.31,101.76 49.59,101.76 49.08,102.27 49.08,102.73 49.34,102.98 49.68,102.98 v1(49.79,103.09)
  BOTTOM w0.102: U24.CP7 94.41,45.56 v2(94.41,45.77)
PCIE_RXN10_WLAN: length 123
  TOP w0.102: v2(186.57,33.16) 186.57,33.64 187.01,34.07 v1(187.51,34.07)
  IN1 w0.089: v2(95.05,46.72) 95.24,46.53 95.24,46.26 95.49,46.01 96.03,46.01 96.26,46.24 96.71,46.24 97.09,45.85 97.09,44.55 97.83,43.82 97.83,42.52 100.93,39.42 100.93,37.37 101.32,36.98 101.32,36.67 102.36,35.62 103.15,35.62 103.45,35.32 107.19,35.32 107.24,35.27 110.01,35.27 111.26,34.02 112.91,34.02 113.88,33.06 117.44,33.06 118.76,34.38 125.89,34.38 127.37,35.85 142.86,35.85 143.7,35.01 144.53,35.01 145.78,33.76 145.78,33.43 146.54,32.67 156.44,32.67 156.57,32.55 158.98,32.55 159.72,31.81 163.73,31.81 163.91,31.63 174.18,31.63 174.59,32.04 179.26,32.04 179.56,32.34 180.03,32.34 180.28,32.59 185.14,32.59 185.17,32.57 186.22,32.57 186.37,32.72 186.37,32.96 v2(186.57,33.16)
  BOTTOM w0.102: U24.CM7 94.73,46.4 v2(95.05,46.72) ; CN9.43 184.14,20.63 184.24,20.53 185.76,20.53 186.23,21 186.23,22.21 186.74,22.71 186.74,27.76 186.42,28.08 186.42,29.42 185.76,30.08 185.76,31.96 186.45,32.65 186.45,33.03 v2(186.57,33.16)
PCIE_RXN13_SSD: length 97.9
  IN3 w0.089: v2(34.5,14.06) 34.35,13.91 34.35,13.6 34.14,13.39 33.16,13.39 31.15,15.4 31.15,16.02 31.35,16.22 31.35,23.22 32.81,24.67 37.24,24.67 40.57,28 43.54,28 45.17,29.63 47.46,29.63 50.32,32.49 54.1,32.49 54.63,33.02 59.99,33.02 60.68,33.72 65.78,33.72 65.87,33.81 65.87,34.33 67.24,35.7 69.53,35.7 71.08,37.24 72.59,37.24 73.43,38.09 74.07,38.09 74.28,38.3 74.28,38.93 75.02,39.67 75.02,41.19 75.58,41.75 75.58,42.28 76.51,43.22 77.25,43.22 77.43,43.39 77.95,43.39 78.23,43.12 79.17,43.12 79.64,43.58 79.64,43.75 80.06,44.17 80.75,44.17 80.84,44.08 81.08,44.08 81.65,44.65 81.65,44.77 82.58,45.71 83.7,45.71 84.69,46.7 90.55,46.7 91.9,48.04 93.3,48.04 93.69,48.43 93.69,48.61 94.07,48.99 94.54,48.99 94.6,49.06 94.6,49.25 v2(94.46,49.39)
  BOTTOM w0.102: v2(34.5,14.06) 34.4,13.96 34.4,13.5 34.63,13.27 34.63,13.02 35.58,12.06 35.58,11.68 36.1,11.16 36.97,11.16 37.37,11.57 37.37,11.95 37.98,12.56 38.57,12.56 38.9,12.23 38.9,11.92 R852.1 ; U24.CG7 94.73,49.12 v2(94.46,49.39)
PCIE_RXN13_SSD_C: length 1.9
  BOTTOM w0.102: R852.2 38.78,11.04 38.78,10.68 38.71,10.61 38.71,10.46 38.85,10.32 CN18.5
PCIE_RXN14_SSD: length 93.4
  IN3 w0.089: v2(33.5,12.66) 33.3,12.46 33.17,12.46 33.06,12.57 33.06,12.91 30.72,15.25 30.72,16.15 30.96,16.39 30.96,23.38 33.75,26.17 34.82,26.17 36.32,27.67 39.38,27.67 40.12,28.41 43,28.41 45.43,30.85 47.69,30.85 49.21,32.37 49.64,32.37 50.68,33.41 59.68,33.41 63.75,37.48 66.27,37.48 67.31,36.44 69.71,36.44 71.36,38.09 72.71,38.09 74.61,39.99 74.61,41.35 75.04,41.79 75.04,42.45 76.57,43.98 77.34,43.98 77.42,43.9 77.63,43.9 77.65,43.88 79.04,43.88 79.4,44.24 79.4,44.78 79.56,44.94 80.6,44.94 80.96,45.3 80.96,45.58 81.14,45.76 81.85,45.76 82.82,46.72 84.03,46.72 84.42,47.1 89.98,47.1 91.85,48.98 93.45,48.98 94.25,49.77 95.18,49.77 95.38,49.97 95.38,50.19 95.52,50.32 v2(95.64,50.32)
  BOTTOM w0.102: v2(33.5,12.66) 33.66,12.51 34.25,12.51 34.57,12.19 34.57,12.01 34.71,11.87 R846.1 ; U24.CE6 95.38,50.05 v2(95.64,50.32)
PCIE_RXN14_SSD_C: length 3
  BOTTOM w0.102: R846.2 34.66,11.42 34.56,11.32 34.56,11.12 34.68,11 35.38,11 35.71,10.67 35.71,10.54 35.85,10.4 CN18.17
PCIE_RXN15_SSD: length 94.6
  IN3 w0.089: v2(95.7,51.28) 95.53,51.45 95.53,51.71 95.24,52.01 94.25,52.01 93.08,50.84 92.42,50.84 89.88,48.3 84.19,48.3 83.86,47.97 82.88,47.97 81.87,46.95 81.03,46.95 80.17,46.09 77.5,46.09 74.13,42.72 74.13,42.21 73.82,41.9 73.05,41.9 69.45,38.29 63.13,38.29 59.07,34.23 50.37,34.23 49.34,33.21 38.56,33.21 35.44,30.09 35.44,29.12 29.58,23.26 29.58,14.92 30.92,13.58 30.92,12.02 31.4,11.54 31.99,11.54 32.27,11.82 32.27,12.18 v2(32.45,12.36)
  BOTTOM w0.102: v2(32.45,12.36) 32.6,12.2 R844.1 ; U24.CC5 96.09,50.89 v2(95.7,51.28)
PCIE_RXN15_SSD_C: length 2.1
  BOTTOM w0.102: CN18.29 32.85,10.33 32.71,10.47 32.71,10.67 32.35,11.03 32.35,11.17 32.6,11.42 R844.2
PCIE_RXN16_SSD: length 97.4
  IN3 w0.089: v1(29.01,12.25) 29.32,11.94 29.32,11.71 29.53,11.51 30.18,11.51 30.52,11.85 30.52,13.22 28.63,15.11 28.63,19.77 28.89,20.03 28.89,23.13 34.85,29.08 34.85,30.07 38.72,33.95 49.52,33.95 50.74,35.17 59.24,35.17 62.77,38.7 68.98,38.7 70.07,39.79 70.07,40.28 72.88,43.09 73.93,43.09 76.64,45.81 76.64,46.47 76.49,46.62 76.49,47 76.74,47.26 77.15,47.26 77.61,47.71 80.83,47.71 80.86,47.74 82.08,47.74 82.48,48.14 82.48,48.55 82.69,48.75 83.77,48.75 83.82,48.7 89.57,48.7 92.11,51.24 92.92,51.24 94.12,52.44 94.96,52.44 95.24,52.72 95.85,52.72 95.92,52.64 95.92,52.42 v2(95.67,52.17)
  BOTTOM w0.102: v1(29.01,12.25) 29.14,12.11 R849.1 ; U24.CA6 95.67,51.93 v2(95.67,52.17)
PCIE_RXN16_SSD_C: length 1.9
  BOTTOM w0.102: CN18.43 29.35,10.37 29.49,10.51 29.49,10.74 29.4,10.83 29.4,11.06 R849.2
PCIE_RXN_LAN_L: length 2.5
  TOP w0.102: C88.1 48.19,103.36 48.08,103.26 47.79,103.26 47.69,103.36 47.69,103.92 47.21,104.4 U1.18
PCIE_RXP9_LAN: length 116.2
  TOP w0.102: v1(49.79,102.46) 49.79,102.48 49.19,103.08 49.07,103.08 48.97,102.98 C94.2
  IN3 w0.089: v2(95.05,45.77) 95.05,45.95 95.14,46.04 96.02,46.04 96.18,46.19 98.59,46.19 98.87,46.47 99.3,46.47 99.68,46.85 99.68,47.31 99.33,47.66 99.33,48.5 98.61,49.21 98.61,51.01 99.1,51.5 99.1,54.77 98.69,55.18 97.65,55.18 97.12,55.71 97.12,63.03 98.03,63.94 100.57,63.94 102.12,65.49 102.12,74.79 101.64,75.27 101.64,75.98 102.07,76.41 102.07,78.18 101.41,78.84 101.41,79.65 97.96,83.1 97.96,84.42 97,85.38 97,89.18 92.64,93.53 92.64,93.92 89.5,97.06 85.99,97.06 85.58,97.47 84.6,97.47 81.93,100.14 79.94,100.14 78.03,102.06 76.17,102.06 74.24,103.99 70.09,103.99 67.87,106.21 63.99,106.21 61.76,103.97 51.69,103.97 50.9,103.18 50.9,102.64 50.23,101.97 49.68,101.97 49.29,102.36 49.29,102.64 49.42,102.78 49.54,102.78 49.79,102.53 v1(49.79,102.46)
  BOTTOM w0.102: U24.CP6 95.15,45.23 95.05,45.33 v2(95.05,45.77)
PCIE_RXP10_WLAN: length 122.3
  TOP w0.102: v2(185.99,33.16) 185.99,33.77 v1(186.19,33.97)
  IN1 w0.089: v2(185.99,33.16) 186.17,32.98 186.17,32.81 186.13,32.77 185.25,32.77 185.23,32.8 180.19,32.8 179.94,32.55 179.48,32.55 179.17,32.24 174.5,32.24 174.09,31.84 163.99,31.84 163.82,32.02 159.8,32.02 159.07,32.75 156.65,32.75 156.53,32.88 146.62,32.88 145.98,33.51 145.98,33.84 144.61,35.22 143.78,35.22 142.94,36.05 127.28,36.05 125.81,34.58 118.68,34.58 117.36,33.26 113.96,33.26 113,34.23 111.34,34.23 110.09,35.47 107.33,35.47 107.28,35.52 103.53,35.52 103.23,35.83 102.44,35.83 101.52,36.75 101.52,37.06 101.13,37.45 101.13,39.51 98.03,42.61 98.03,43.9 97.29,44.64 97.29,45.94 96.79,46.44 96.18,46.44 95.95,46.21 95.57,46.21 95.45,46.34 95.45,46.47 v2(95.64,46.67)
  BOTTOM w0.102: v2(185.99,33.16) 186.23,32.92 186.23,32.74 185.55,32.05 185.55,30 186.21,29.33 186.21,27.99 186.52,27.67 186.52,22.8 186.02,22.3 186.02,21.09 185.67,20.75 184.33,20.75 183.95,21.13 CN9.41 ; v2(95.64,46.67) 95.79,46.52 95.79,45.83 95.72,45.76 95.56,45.76 95.43,45.88 95.43,46.1 U24.CM6
PCIE_RXP13_SSD: length 97.9
  IN3 w0.089: v2(33.89,14.06) 34.01,14.06 34.15,13.92 34.15,13.68 34.06,13.59 33.25,13.59 31.35,15.48 31.35,15.94 31.56,16.14 31.56,23.13 32.9,24.47 37.32,24.47 40.65,27.8 43.62,27.8 45.25,29.43 47.55,29.43 50.41,32.29 54.18,32.29 54.71,32.82 60.07,32.82 60.77,33.51 65.87,33.51 66.08,33.72 66.08,34.25 67.32,35.5 69.62,35.5 71.16,37.04 72.67,37.04 73.52,37.88 74.15,37.88 74.48,38.21 74.48,38.85 75.22,39.58 75.22,41.11 75.78,41.67 75.78,42.2 76.59,43.01 77.34,43.01 77.51,43.19 77.86,43.19 78.14,42.91 79.26,42.91 79.84,43.5 79.84,43.67 80.14,43.97 80.67,43.97 80.76,43.88 81.16,43.88 81.85,44.56 81.85,44.69 82.67,45.51 83.79,45.51 84.77,46.49 90.64,46.49 91.98,47.84 93.38,47.84 93.89,48.35 93.89,48.53 94.15,48.79 94.62,48.79 94.8,48.97 94.8,49.24 94.96,49.39 v2(95.09,49.39)
  BOTTOM w0.102: R851.1 38.56,11.77 38.68,11.9 38.68,12.14 38.48,12.34 38.07,12.34 37.59,11.86 37.59,11.48 37.06,10.95 36.01,10.95 35.37,11.59 35.37,11.97 34.42,12.93 34.42,13.18 34.19,13.41 34.19,13.79 33.92,14.06 v2(33.89,14.06) ; v2(95.09,49.39) 95.09,49.07 95.26,48.89 U24.CG6
PCIE_RXP13_SSD_C: length 1.9
  BOTTOM w0.102: R851.2 38.56,11.04 38.56,10.77 38.49,10.7 38.49,10.48 38.35,10.33 CN18.7
PCIE_RXP14_SSD: length 93.4
  IN3 w0.089: v2(33.53,12.08) 33.35,12.25 33.08,12.25 32.85,12.48 32.85,12.83 30.52,15.17 30.52,16.24 30.76,16.48 30.76,23.46 33.67,26.38 34.73,26.38 36.23,27.88 39.3,27.88 40.03,28.61 42.91,28.61 45.35,31.05 47.6,31.05 49.13,32.57 49.55,32.57 50.6,33.62 59.6,33.62 63.66,37.68 66.36,37.68 67.4,36.64 69.63,36.64 71.28,38.29 72.62,38.29 74.41,40.08 74.41,41.44 74.84,41.87 74.84,42.54 76.49,44.19 77.42,44.19 77.51,44.11 77.71,44.11 77.74,44.08 78.95,44.08 79.2,44.32 79.2,44.86 79.47,45.14 80.51,45.14 80.76,45.38 80.76,45.66 81.05,45.96 81.77,45.96 82.73,46.93 83.95,46.93 84.33,47.31 89.89,47.31 91.77,49.18 93.37,49.18 94.16,49.97 95.1,49.97 95.18,50.05 95.18,50.22 v2(95.04,50.36)
  BOTTOM w0.102: R845.1 34.22,11.87 34.35,12 34.35,12.1 34.16,12.29 33.74,12.29 v2(33.53,12.08) ; v2(95.04,50.36) 94.73,50.04 U24.CE7
PCIE_RXP14_SSD_C: length 3
  BOTTOM w0.102: R845.2 34.26,11.42 34.34,11.34 34.34,11.03 34.59,10.78 35.29,10.78 35.49,10.58 35.49,10.5 35.35,10.35 CN18.19
PCIE_RXP15_SSD: length 94.5
  IN3 w0.089: v2(95.04,51.28) 95.25,51.28 95.33,51.36 95.33,51.62 95.15,51.8 94.33,51.8 93.17,50.64 92.51,50.64 89.96,48.09 84.27,48.09 83.94,47.76 82.97,47.76 81.95,46.75 81.11,46.75 80.26,45.89 77.59,45.89 74.33,42.63 74.33,42.12 73.9,41.69 73.14,41.69 69.53,38.09 63.21,38.09 59.16,34.03 50.45,34.03 49.43,33.01 38.64,33.01 35.65,30.01 35.65,29.04 29.78,23.17 29.78,15.01 31.13,13.66 31.13,12.1 31.48,11.75 31.91,11.75 32.07,11.91 32.07,12.36 31.96,12.46 31.79,12.46 v2(31.66,12.33)
  BOTTOM w0.102: v2(31.66,12.33) 31.94,12.33 32.06,12.21 32.06,11.97 31.96,11.87 R843.1 ; U24.CC6 95.46,50.81 95.46,50.99 95.17,51.28 v2(95.04,51.28)
PCIE_RXP15_SSD_C: length 2.1
  BOTTOM w0.102: R843.2 32.14,11.12 32.14,10.94 32.49,10.58 32.49,10.5 32.35,10.35 CN18.31
PCIE_RXP16_SSD: length 97.4
  IN3 w0.089: v1(29.84,12.25) 29.53,11.94 29.53,11.8 29.61,11.71 30.09,11.71 30.31,11.93 30.31,13.14 28.43,15.02 28.43,19.85 28.69,20.11 28.69,23.21 34.64,29.17 34.64,30.16 38.64,34.15 49.44,34.15 50.66,35.37 59.16,35.37 62.69,38.9 68.9,38.9 69.87,39.87 69.87,40.36 72.8,43.29 73.84,43.29 76.44,45.89 76.44,46.38 76.29,46.54 76.29,47.09 76.66,47.46 77.07,47.46 77.52,47.92 80.75,47.92 80.78,47.94 81.99,47.94 82.28,48.23 82.28,48.64 82.6,48.96 83.86,48.96 83.91,48.91 89.49,48.91 92.02,51.44 92.83,51.44 94.03,52.64 94.88,52.64 95.16,52.92 95.93,52.92 96.12,52.72 96.12,52.38 v2(96.33,52.17)
  BOTTOM w0.102: R850.1 29.91,12.19 v1(29.84,12.25) ; v2(96.33,52.17) 96.03,51.87 U24.CA5
PCIE_RXP16_SSD_C: length 1.9
  BOTTOM w0.102: R850.2 29.61,11.03 29.61,10.92 29.71,10.83 29.71,10.51 29.85,10.37 CN18.41
PCIE_RXP_LAN_L: length 2.6
  TOP w0.102: U1.17 47.31,104 47.47,103.83 47.47,103.27 47.7,103.05 48.08,103.05 48.19,102.94 C94.1
PCIE_TXN9_LAN: length 131
  TOP w0.102: U1.14 45.24,102.82 45.05,102.64 45.05,101.69 45.31,101.43 45.4,101.43 45.53,101.31 v1(45.53,101.21)
  IN3 w0.089: v1(103.87,41.9) 103.93,41.9 104.24,42.2 104.24,42.33 103.97,42.61 103.1,42.61 101.89,43.82 101.89,45.53 101.22,46.2 101.22,49 100.77,49.44 100.77,56.04 99.17,57.64 99.17,61.71 99.66,62.19 101.18,62.19 103.8,64.81 103.8,73.21 104.25,73.67 104.25,77.67 104.51,77.92 104.51,79.36 104.84,79.69 104.84,80.81 104.46,81.19 104.46,86.8 102.57,88.68 100.1,88.68 96.39,92.4 96.39,93.26 94.78,94.87 94.78,95.86 93.68,96.96 93.04,96.96 89.77,100.24 87.77,100.24 86.93,101.08 84.64,101.08 82.18,103.54 78.98,103.54 76.82,105.7 74.78,105.7 74.7,105.78 70.64,105.78 68.43,107.99 62.76,107.99 62.38,107.61 53.2,107.61 51.24,105.65 50.54,105.65 49.7,106.49 46.65,106.49 45.02,104.85 45.02,101.71 v1(45.53,101.21)
  BOTTOM w0.102: C611.2 102.65,41.5 102.75,41.4 103.99,41.4 104.13,41.54 104.13,41.66 103.9,41.9 v1(103.87,41.9)
PCIE_TXN9_LAN_C: length 5.3
  BOTTOM w0.079: U24.DA2 97.66,41.63 97.91,41.88 98.85,41.88 99.33,41.41 100.93,41.41 101.28,41.76 101.48,41.76 101.53,41.81 101.53,41.81
  BOTTOM w0.102: 101.53,41.81 101.88,41.81 101.92,41.77 C611.1
PCIE_TXN10_WLAN: length 121
  IN3 w0.089: v1(104.33,35.93) 104.54,36.14 104.54,36.35 104.78,36.59 105.88,36.59 106.23,36.23 106.23,33.66 106.08,33.51 106.08,32.24 105.55,31.71 105.55,29.89 106.79,28.65 106.79,27.66 107.43,27.03 107.43,24.83 110.32,21.93 113.95,21.93 115.07,23.05 119.94,23.05 121.76,24.87 123.03,24.87 123.19,24.7 125.96,24.7 126.5,25.23 135.21,25.23 135.26,25.28 136.96,25.28 139.13,27.46 139.55,27.46 139.66,27.57 142.35,27.57 142.76,27.16 143.22,27.16 143.53,26.86 144.51,26.86 145.09,27.44 153.02,27.44 154.29,26.17 156.13,26.17 156.49,25.81 159.93,25.81 160.45,25.29 165.76,25.29 165.97,25.09 169.1,25.09 169.22,25.21 171.64,25.21 172.93,26.5 176.24,26.5 176.64,26.1 178.64,26.1 178.92,26.38 182.01,26.38 182.62,25.77 184.44,25.77 184.56,25.88 184.56,26.06 v2(184.39,26.22)
  BOTTOM w0.079: 101.92,42.4 101.9,42.4 101.87,42.43 101.16,42.43 100.92,42.19 98.95,42.19 98.83,42.07 97.45,42.07 97.21,41.83 96.97,41.83 96.79,42.02 96.79,42.13 96.88,42.22 97.06,42.22 U24.CY3
  BOTTOM w0.102: v1(104.33,35.93) 104.99,36.59 105.22,36.59 105.56,36.93 105.56,42.01 105.17,42.4 101.92,42.4 ; C677.2 180.98,23.17 181.11,23.3 181.11,23.53 181.35,23.77 183.03,23.77 184.58,25.32 184.58,26.03 v2(184.39,26.22)
PCIE_TXN10_WLAN_C: length 2.9
  BOTTOM w0.102: C677.1 180.95,22.56 180.95,22.35 181.25,22.05 182.09,22.05 182.18,22.13 CN9.37
PCIE_TXN13_SSD: length 90.6
  TOP w0.102: v1(36.69,12.08) 36.52,12.24 35.91,12.24 35.62,11.95 35.62,10.41 C486.1
  IN3 w0.089: v1(36.69,12.08) 36.76,12.15 37.87,12.15 40.23,14.51 40.79,14.51 42.99,16.72 42.99,17.38 46.32,20.7 46.32,24.78 47.46,25.92 47.86,25.92 49.24,27.29 53.17,27.29 53.48,26.99 55.79,26.99 57.11,28.31 58.33,28.31 59.75,29.73 62.83,29.73 63.43,29.12 65.97,29.12 66.18,29.32 67.25,29.32 71.31,33.39 73.85,33.39 74.03,33.56 78,33.56 79.64,35.21 79.86,35.21 80.25,35.6 80.66,35.6 81.04,35.97 81.04,38.69 82.15,39.81 82.15,40.37 82.71,40.93 83.2,40.93 83.72,41.45 83.72,41.58 86.19,44.06 91.39,44.06 92.11,43.34 92.8,43.34 92.88,43.42 93.12,43.42 93.64,42.9 93.64,42.76 94.07,42.33 95.42,42.33 95.48,42.39 98.91,42.39 99.55,43.03 99.55,43.24 v2(99.74,43.43)
  BOTTOM w0.079: U24.CT3 96.75,44.3 96.85,44.39 97.02,44.39 97.11,44.3 97.11,43.99 97.19,43.91 97.35,43.82 97.5,43.82 97.63,43.9 97.84,43.9 98,43.83 98.14,43.83 98.47,43.99 99.27,43.99 99.47,43.79 99.47,43.61 99.65,43.43 v2(99.74,43.43)
PCIE_TXN13_SSD_C: length 7.2
  TOP w0.102: C486.2 35.6,8.85 35.6,8.03 36.27,7.37 36.27,6.81 v1(36.55,6.53)
  BOTTOM w0.102: v1(36.55,6.53) 36.26,6.82 36.26,7.42 36.42,7.58 36.75,7.58 37.21,8.04 37.21,8.33 37.35,8.47 CN18.11
PCIE_TXN14_SSD: length 94.9
  TOP w0.102: v1(35.98,13.6) 35.92,13.6 35.74,13.42 35.74,12.96 34.28,11.49 34.28,11.34 33.56,10.63 33.56,10.43 C484.1
  IN3 w0.089: v1(35.98,13.6) 35.85,13.6 35.73,13.48 35.73,13.32 35.88,13.17 36.22,13.17 36.63,13.58 38.16,13.58 39.94,15.35 40.41,15.35 42.15,17.09 42.15,19.67 41.79,20.03 41.79,21.99 43.79,23.99 44.36,23.99 47.23,26.86 47.58,26.86 48.92,28.21 49.91,28.21 51.79,30.09 53.01,30.09 53.06,30.03 54.59,30.03 55.17,30.62 57.38,30.62 57.86,31.1 62.08,31.1 62.28,31.3 64.32,31.3 64.53,31.1 66.02,31.1 68.63,33.72 70.28,33.72 70.92,34.35 71.51,34.35 71.77,34.61 74.53,34.61 75.47,35.55 76.3,35.55 76.45,35.39 76.97,35.39 77.45,35.88 77.83,35.88 78.34,36.38 78.44,36.38 78.9,36.85 78.9,38.61 78.8,38.71 78.8,39.21 79.15,39.56 79.74,39.56 80.73,40.55 81.14,40.55 82.87,42.28 83.27,42.28 85.86,44.87 91.96,44.87 92.24,44.59 92.69,44.59 92.89,44.39 93.31,44.39 94.22,43.48 95.3,43.48 95.36,43.55 95.82,43.55 96.38,44.11 100.61,44.11 101.07,44.56 101.07,44.85 v2(100.9,45.02)
  BOTTOM w0.079: v2(100.9,45.02) 100.95,45.02 101.11,44.86 101.11,44.71 100.76,44.36 97.66,44.36 U24.CT2
PCIE_TXN14_SSD_C: length 4.3
  TOP w0.102: C484.2 33.69,9.25 33.57,9.13 33.57,8.95 34.21,8.31 34.21,7.99 v1(34.49,7.71)
  BOTTOM w0.102: CN18.23 34.35,8.59 34.21,8.45 34.21,7.99 v1(34.49,7.71)
PCIE_TXN15_SSD: length 107.2
  TOP w0.102: v2(37.98,14.39) 37.82,14.22 37.82,13.84 37.6,13.63 36.64,13.63 36.12,14.15 36.12,14.3 35.86,14.55 33.22,14.55 32.83,14.16 32.83,13.52 33.08,13.27 33.08,11.8 32.42,11.14 31.41,11.14 31.16,10.88 31.16,10.43 C482.1
  IN3 w0.089: v2(99.73,45.09) 99.53,44.89 99.53,44.72 99.31,44.5 96.3,44.5 96.1,44.3 95.44,44.3 95.37,44.23 94.22,44.23 93.06,45.39 93.06,45.77 92.81,46.01 92.31,46.01 91.58,45.27 85.54,45.27 83.66,43.39 82.71,43.39 82.21,42.89 82.21,42.4 81.93,42.12 80.68,42.12 80.43,41.87 80.43,40.83 79.93,40.33 79.15,40.33 79.14,40.34 78.77,40.34 78.55,40.12 78.14,40.12 77.94,40.31 77.58,40.31 77.33,40.07 77.33,39.8 77.37,39.77 77.37,39.29 77.33,39.25 77.33,39.23 77.08,38.98 77.08,38.47 76.85,38.24 76.44,38.24 76.26,38.06 76.26,37.96 73.85,35.55 71.37,35.55 69.95,34.12 68.46,34.12 66.64,32.29 61.71,32.29 61,31.58 55.37,31.58 54.3,30.52 51.63,30.52 49.9,28.79 48.65,28.79 47.23,27.37 46.78,27.37 46.35,26.94 45.93,26.94 45.48,26.48 45.48,26.19 44.22,24.93 40.76,24.93 38.63,22.8 33.5,22.8 32.78,22.08 32.78,17.28 34.3,15.76 37.35,15.76 37.58,15.53 37.58,14.79 v2(37.98,14.39)
  BOTTOM w0.079: U24.CR3 97.2,44.79 97.5,44.79 97.72,44.57 99.13,44.57 99.65,45.09 v2(99.73,45.09)
PCIE_TXN15_SSD_C: length 4.2
  TOP w0.102: v1(31.49,7.58) 31.21,7.86 31.21,8.26 31.16,8.31 31.16,8.85 C482.2
  BOTTOM w0.102: v1(31.49,7.58) 31.21,7.86 31.21,8.45 31.35,8.59 CN18.35
PCIE_TXN16_SSD: length 100.5
  TOP w0.102: v1(32.73,16.18) 32.7,16.18 32.51,15.99 32.51,14.91 31.25,13.65 31.25,12.61 29.64,11 29.03,11 28.18,10.15 28.18,9.84 28.25,9.77 C488.1
  IN3 w0.089: v1(32.73,16.18) 32.66,16.18 32.27,16.57 32.27,16.93 32.17,17.03 32.17,22.33 33.24,23.4 37.2,23.4 40.98,27.19 43.94,27.19 45.58,28.83 47.83,28.83 48.58,29.58 49.79,29.58 51.9,31.69 54.54,31.69 55.08,32.22 60.47,32.22 61.16,32.9 66.38,32.9 67.24,33.77 67.24,34.39 67.74,34.89 69.85,34.89 71.41,36.44 73.09,36.44 73.33,36.68 73.99,36.68 75.32,38.01 75.32,38.72 75.86,39.25 75.86,40.16 76.88,41.18 77.23,41.18 77.33,41.29 77.98,41.29 78.08,41.19 78.5,41.19 78.51,41.18 79.41,41.18 79.75,41.52 79.75,42.13 80.86,43.24 81.55,43.24 82.74,44.44 82.74,44.69 82.96,44.91 84.05,44.91 85.02,45.88 90.99,45.88 92.31,47.2 93.05,47.2 93.71,46.54 93.71,45.62 94.15,45.19 95.33,45.19 95.4,45.25 96.11,45.25 96.24,45.12 97.52,45.12 97.88,45.48 99.81,45.48 100,45.67 100,45.88 v2(100.19,46.07)
  BOTTOM w0.079: U24.CP1 98.06,45.23 98.06,45.47 98.1,45.51 99.85,45.51 100,45.66 100,45.88 v2(100.19,46.07)
PCIE_TXN16_SSD_C: length 3.7
  TOP w0.102: v1(28.49,7.71) 28.21,7.99 28.21,8.27 28.24,8.3 28.24,8.59 C488.2
  BOTTOM w0.102: CN18.47 28.35,8.84 28.21,8.7 28.21,7.99 v1(28.49,7.71)
PCIE_TXP9_LAN: length 131
  TOP w0.102: v1(44.89,101.23) 44.84,101.28 U1.13
  IN3 w0.089: v1(44.89,101.23) 44.89,101.55 44.82,101.63 44.82,104.94 46.57,106.69 49.79,106.69 50.62,105.85 51.16,105.85 53.11,107.81 62.29,107.81 62.67,108.19 68.51,108.19 70.72,105.98 74.79,105.98 74.86,105.9 76.91,105.9 79.06,103.75 82.26,103.75 84.73,101.28 87.01,101.28 87.85,100.44 89.85,100.44 93.13,97.17 93.76,97.17 94.98,95.95 94.98,94.96 96.59,93.34 96.59,92.48 100.19,88.89 102.65,88.89 104.66,86.88 104.66,81.27 105.04,80.89 105.04,79.61 104.71,79.28 104.71,77.84 104.46,77.58 104.46,73.59 104,73.13 104,64.72 101.26,61.99 99.74,61.99 99.38,61.62 99.38,57.73 100.98,56.13 100.98,49.52 101.42,49.08 101.42,46.29 102.09,45.61 102.09,43.9 103.19,42.81 104.05,42.81 104.45,42.41 104.45,41.96 v1(104.51,41.9)
  BOTTOM w0.102: C613.2 102.8,41.01 102.98,41.18 104.08,41.18 104.35,41.45 104.35,41.74 104.36,41.75 v1(104.51,41.9)
PCIE_TXP9_LAN_C: length 5.2
  BOTTOM w0.079: U24.DA1 98.14,41.72 98.78,41.72 99.26,41.24 101,41.24 101.35,41.59 101.53,41.59
  BOTTOM w0.102: 101.53,41.59 101.79,41.59 101.9,41.49 101.9,41.34 101.8,41.24 101.8,41.03 101.9,40.93 102.06,40.93 102.14,41.01 C613.1
PCIE_TXP10_WLAN: length 121.1
  IN3 w0.089: v1(104.96,35.93) 104.75,36.14 104.75,36.27 104.86,36.38 105.79,36.38 106.03,36.15 106.03,33.74 105.88,33.59 105.88,32.33 105.34,31.79 105.34,29.81 106.59,28.56 106.59,27.58 107.22,26.94 107.22,24.74 110.24,21.73 114.03,21.73 115.15,22.85 120.03,22.85 121.84,24.66 122.94,24.66 123.11,24.5 126.05,24.5 126.58,25.03 135.29,25.03 135.34,25.08 137.04,25.08 139.22,27.25 139.63,27.25 139.75,27.37 142.27,27.37 142.67,26.96 143.14,26.96 143.44,26.66 144.6,26.66 145.17,27.23 152.94,27.23 154.21,25.96 156.05,25.96 156.4,25.61 159.84,25.61 160.37,25.09 165.68,25.09 165.88,24.88 169.18,24.88 169.3,25.01 171.72,25.01 173.02,26.3 176.15,26.3 176.56,25.89 178.73,25.89 179,26.17 181.93,26.17 182.54,25.56 184.53,25.56 184.76,25.8 184.76,26.04 v2(184.97,26.25)
  BOTTOM w0.079: U24.CY4 96.62,42.19 96.9,42.47 97.25,42.47 97.49,42.23 98.76,42.23 98.88,42.35 100.85,42.35 101.09,42.59 101.87,42.59 101.9,42.62 101.92,42.62
  BOTTOM w0.102: 101.92,42.62 105.26,42.62 105.78,42.1 105.78,36.84 105.31,36.37 105.08,36.37 104.96,36.26 v1(104.96,35.93) ; v2(184.97,26.25) 184.8,26.07 184.8,25.23 183.12,23.56 181.44,23.56 181.33,23.44 181.33,23.34 C678.2
PCIE_TXP10_WLAN_C: length 2.9
  BOTTOM w0.102: C678.1 181.24,22.72 181.16,22.64 181.16,22.44 181.34,22.26 182,22.26 182.37,22.63 CN9.35
PCIE_TXP13_SSD: length 90.7
  TOP w0.102: C485.1 35.12,10.03 35.41,10.31 35.41,12.04 35.83,12.46 36.42,12.46 v1(36.68,12.72)
  IN3 w0.089: v2(99.15,43.43) 99.34,43.24 99.34,43.12 98.82,42.59 95.4,42.59 95.34,42.53 94.15,42.53 93.84,42.84 93.84,42.98 93.2,43.62 92.8,43.62 92.71,43.54 92.19,43.54 91.48,44.26 86.11,44.26 83.52,41.67 83.52,41.54 83.12,41.13 82.63,41.13 81.95,40.46 81.95,39.89 80.83,38.77 80.83,36.05 80.58,35.8 80.17,35.8 79.78,35.41 79.56,35.41 77.91,33.77 73.94,33.77 73.76,33.59 71.23,33.59 67.16,29.53 66.09,29.53 65.89,29.32 63.52,29.32 62.91,29.93 59.67,29.93 58.25,28.51 57.03,28.51 55.71,27.19 53.56,27.19 53.26,27.49 49.15,27.49 47.78,26.12 47.37,26.12 46.11,24.86 46.11,20.79 42.78,17.46 42.78,16.8 40.7,14.72 40.15,14.72 37.79,12.36 37.04,12.36 v1(36.68,12.72)
  BOTTOM w0.079: U24.CT5 96.39,43.82 97.01,43.82 97.31,43.65 97.55,43.65 97.68,43.73 97.81,43.73 97.96,43.66 98.18,43.66 98.51,43.82 99.2,43.82 99.3,43.72 99.3,43.58 v2(99.15,43.43)
