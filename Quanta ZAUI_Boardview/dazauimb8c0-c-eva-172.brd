# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAINON_ON_G: length 39.8
  TOP w0.254: PQ7.3 24.57,41.77 25.33,42.53 v2(25.97,42.53) 28.59,42.53 28.71,42.4 28.71,41.41 28.05,40.75 PR64.2 28.44,40.27 PQ8.2 28.44,36.76 29.37,35.83 PR73.1
  BOTTOM w0.254: PQ28.2 16.84,29.56 16.22,30.19 16.22,32.47 16.61,32.86 v1(16.98,32.86) 18.14,32.86 18.22,32.95 18.22,33.64 17.84,34.02 16.75,34.02 16.57,34.2 16.57,35.87 16.91,36.22 PQ25.2 PQ23.2 18.84,39.59 19.46,40.22 21.12,40.22 22.08,41.18 23.99,41.18 25.33,42.53 v2(25.97,42.53)
MBCLK: length 135.2
  TOP w0.102: v1(102.7,16.98) 102.7,16.06 101.64,15.01 PR120.2 PC123.1 PD6.1 ; v2(139,29.48) 139.3,29.17 139.3,27.77 138.65,27.11 138.25,27.11 136.12,24.98 135.67,24.98 135.11,24.42 135.11,24.07 134.96,23.92 134.96,22.94 135.32,22.58 135.32,21.12 134.81,20.61 134.81,20.23 v2(134.71,20.13) ; v2(194.96,19.54) 194.96,20.37 194.52,20.8 194.52,21.33 194.07,21.79 194.07,22.93 192.96,24.04 190.77,24.04 189.87,24.94 189.52,24.94 189.36,25.11 188.72,25.11 188.63,25.19 188.63,25.84 189.14,26.35 189.88,26.35 190.43,26.91 190.43,27.47 192.05,29.08 U13.110
  IN2 w0.089: v2(194.96,19.54) 194.96,19.47 194.63,19.14 193.5,19.14 192.75,18.4 191.79,18.4 190.61,19.58 187.94,19.58 187.36,19 186.85,19 186.19,19.66 181.07,19.66 180.62,20.12 179.09,20.12 178.62,19.65 176.34,19.65 175.76,20.24 173.42,20.24 173.26,20.08 170.76,20.08 170.46,19.78 168.49,19.78 168.31,19.6 162.22,19.6 161.96,19.86 155.41,19.86 155.25,19.71 137.66,19.71 136.77,20.6 135.85,20.6 135.7,20.45 135.7,19.95 135.52,19.77 135.06,19.77 v2(134.71,20.13) 134.53,19.95 130.74,19.95 130.4,20.3 122.19,20.3 120.27,18.38 114.13,18.38 113.76,18.74 112.74,18.74 112.37,18.38 112.37,17.97 112.14,17.73 111.86,17.73 111.57,18.02 109.12,18.02 107.65,16.55 103.14,16.55 v1(102.7,16.98)
  BOTTOM w0.102: PR255.1 138.72,29.3 138.9,29.48 v2(139,29.48) ; v2(194.96,19.54) 193.86,20.64 193.69,20.64 193.56,20.76 R805.1
MBDATA: length 131.4
  TOP w0.102: v1(106.11,14.59) PR119.2 107.61,15.46 PC122.1 PD5.1 109.03,14.72 110.06,13.69 112.39,13.69 113.32,14.62 113.32,16.34 112.1,17.56 112.1,17.99 112,18.1 v2(112,18.12) ; U13.111 191.65,29 190.21,27.56 190.21,27.06 189.72,26.58 189.04,26.58 188.4,25.94 188.4,25.1 188.62,24.88 189.26,24.88 189.43,24.71 189.77,24.71 190.67,23.81 192.86,23.81 193.84,22.83 193.84,21.69 194.28,21.25 194.28,19.59 v2(194.3,19.56) ; v2(135.29,20.24) 135.29,20.69 135.55,20.94 135.55,22.68 135.19,23.03 135.19,23.82 135.34,23.97 135.34,24.33 135.77,24.75 136.21,24.75 138.34,26.88 138.75,26.88 139.53,27.67 139.53,29.52 v2(139.58,29.58)
  IN2 w0.089: v2(194.3,19.56) 193.64,19.56 192.69,18.6 191.86,18.6 190.69,19.77 187.86,19.77 187.33,19.24 186.88,19.24 186.27,19.86 181.15,19.86 180.7,20.31 179.01,20.31 178.54,19.84 176.42,19.84 175.84,20.43 173.34,20.43 173.18,20.27 170.68,20.27 170.38,19.97 168.41,19.97 168.23,19.79 162.45,19.79 162.16,20.08 155.35,20.08 155.17,19.9 139.29,19.9 138.38,20.81 135.72,20.81 135.44,20.53 135.44,20.39 v2(135.29,20.24) 134.72,20.81 126.02,20.81 125.69,20.49 122.11,20.49 120.19,18.57 114.29,18.57 113.92,18.93 112.66,18.93 112,18.27 v2(112,18.12)
  BOTTOM w0.102: R811.1 193.81,20.05 v2(194.3,19.56) ; v2(139.58,29.58) 139.15,30.01 PR253.1
MBP0#: length 4.8
  TOP w0.102: R134.2 95.9,77.36 94.4,75.86 94.4,75.53 94.55,75.37 94.55,74.43 v2(94.18,74.07)
  BOTTOM w0.114: v2(94.18,74.07) 94.16,74.04 94.16,73.68 U24.T9
MBP1#: length 4.8
  TOP w0.102: R135.2 96.84,77.23 95.9,76.29 95.9,75.73 95.49,75.32 95.49,75.07 95.02,74.6 v2(95.02,74.6)
  BOTTOM w0.114: U24.T7 94.64,73.69 94.64,74.34 94.87,74.57 94.99,74.57 v2(95.02,74.6)
MBP2#: length 5.6
  TOP w0.102: v2(94.1,74.65) 93.71,75.05 93.71,75.74 94.64,76.67 94.64,77.29 94.96,77.61 95.09,77.61 95.31,77.84 R127.2
  BOTTOM w0.114: v2(94.1,74.65) 93.43,73.97 U24.T10
MBP3#: length 5
  TOP w0.102: R136.2 97.6,77.28 96.15,75.83 96.15,75.7 95.7,75.24 95.7,74.96 95.44,74.71 95.44,74.43 95.02,74.01 v2(95.02,73.99)
  BOTTOM w0.114: v2(95.02,73.99) 95.02,73.96 U24.T6
MDI0+: length 18.8
  TOP w0.102: U1.1 42.1,106.8 41.82,107.07 41.82,107.09 41.6,107.32 v1(41.57,107.32)
  IN1 w0.089: v1(30.18,104.35) 30.18,104.71 29.69,105.2 29.69,105.75 30.1,106.16 31.05,106.16 31.86,105.35 32.19,105.35 33.01,106.16 40.03,106.16 40.13,106.26 40.13,106.44 39.75,106.82 39.75,107.23 40.18,107.66 40.89,107.66 41.25,107.29 41.55,107.29 v1(41.57,107.32)
  BOTTOM w0.102: U21.9 29.9,104.07 v1(30.18,104.35)
MDI0+_1: length 24.8
  IN2 w0.089: v1(29.96,109.72) 30.23,109.45 30.23,109.38 29.84,108.99 23.84,108.99 14.92,100.07 13.52,100.07 13.22,99.77 CN3.1
  BOTTOM w0.102: U21.16 29.9,110.96 30.2,110.66 30.2,109.96 v1(29.96,109.72)
MDI0-: length 18.8
  TOP w0.102: U1.2 41.63,106.4 41.56,106.47 v1(41.56,106.68)
  IN1 w0.089: v1(41.56,106.68) 41.56,106.83 41.46,106.93 41.1,106.93 40.74,107.29 40.33,107.29 40.12,107.07 40.12,106.97 40.5,106.59 40.5,106.11 40.18,105.79 33.16,105.79 32.35,104.98 31.71,104.98 30.9,105.79 30.25,105.79 30.06,105.6 30.06,105.35 30.55,104.86 30.55,104.53 30.69,104.38 v1(30.9,104.38)
  BOTTOM w0.102: U21.8 30.9,103.98 31.08,104.15 31.08,104.28 30.97,104.38 v1(30.9,104.38)
MDI0-_1: length 24.8
  IN2 w0.089: v1(30.6,109.72) 30.6,109.23 29.99,108.62 23.99,108.62 15.07,99.71 13.68,99.71 13.45,99.48 CN3.2
  BOTTOM w0.102: v1(30.6,109.72) 30.6,110.66 30.9,110.96 U21.17
MDI1+: length 19.1
  TOP w0.102: U1.4 42.53,105.59 41.93,105.59 41.93,105.59 40.8,105.59 v1(40.57,105.37)
  IN3 w0.089: v1(26.99,104.38) 26.99,103.64 27.39,103.24 28.48,103.24 28.71,103.47 37.17,103.47 37.57,103.87 38.57,103.87 39.17,104.48 40.19,104.48 40.57,104.86 v1(40.57,105.37)
  BOTTOM w0.102: U21.12 26.9,104.01 26.99,104.1 v1(26.99,104.38)
MDI1+_1: length 24.7
  TOP w0.102: v1(26.98,109.71) 27.1,109.59 27.1,109.27 26.94,109.1 24.85,109.1 15.31,99.56 15.31,97.09 14.98,96.76 14.67,96.76 13.7,97.73 CN3.3
  BOTTOM w0.102: v1(26.98,109.71) 26.98,109.74 27.12,109.88 27.12,110.74 26.9,110.96 U21.13
MDI1-: length 19.1
  TOP w0.102: U1.5 41.77,105.2 41.76,105.2 41.14,105.2 40.88,104.94 40.17,104.94 39.94,105.17 v1(39.94,105.37)
  IN3 w0.089: v1(39.94,105.37) 40.09,105.22 40.09,105.06 39.99,104.96 38.97,104.96 38.37,104.35 37.37,104.35 36.97,103.95 28.51,103.95 28.28,103.72 27.59,103.72 27.47,103.84 27.47,104.23 27.62,104.38 v1(27.9,104.38)
  BOTTOM w0.102: U21.11 27.9,103.8 27.62,104.07 27.62,104.23 27.77,104.38 v1(27.9,104.38)
MDI1-_1: length 24.6
  TOP w0.102: CN3.6 15.71,96.93 15.71,99.4 25.02,108.71 27.1,108.71 27.49,109.1 27.49,109.59 v1(27.61,109.71)
  BOTTOM w0.102: v1(27.61,109.71) 27.61,109.74 27.51,109.84 27.51,110.58 27.9,110.96 U21.14
MDI2+: length 10
  TOP w0.102: v1(39.82,103.99) 39.85,103.99 40.45,104.58 41.29,104.58 41.5,104.8 U1.6
  IN1 w0.089: v1(39.82,103.99) 39.82,104 39.99,104.18 39.99,104.44 39.88,104.56 38.95,104.56 38.62,104.89 38.42,104.89 37.88,104.35 37.35,104.35 36.82,104.89 36.43,104.89 36.33,104.79 36.33,104.48 36.46,104.36 v1(36.62,104.36)
  BOTTOM w0.102: U21.2 36.9,104.08 v1(36.62,104.36)
MDI2+_1: length 40.5
  IN1 w0.089: v1(36.64,109.36) 36.64,110.04 36.3,110.37 35.43,110.37 33.93,108.88 23.39,108.88 22.83,109.44 22.4,109.44 21.93,108.97 21.93,108.54 22.71,107.76 22.71,107.64 22.46,107.38 22.31,107.38 21.47,108.22 21.04,108.22 20.58,107.75 20.58,107.32 21.43,106.46 21.43,106.36 15.19,100.11 15.19,96.73 14.4,95.95 13.7,95.95 13.45,96.2 CN3.4
  BOTTOM w0.102: U21.23 36.9,110.96 36.57,110.64 36.57,109.42 v1(36.64,109.36)
MDI2-: length 10
  TOP w0.102: v1(40.52,104) 40.71,104.19 41.45,104.19 41.66,104.4 42.53,104.4 U1.7
  IN1 w0.089: v1(35.9,104.38) 35.96,104.44 35.96,104.94 36.28,105.26 36.97,105.26 37.5,104.72 37.73,104.72 38.26,105.26 38.77,105.26 39.1,104.93 40.03,104.93 40.36,104.6 40.36,104.16 v1(40.52,104)
  BOTTOM w0.102: U21.3 v1(35.9,104.38)
MDI2-_1: length 40.5
  IN1 w0.089: CN3.5 13.44,95.69 13.55,95.58 14.55,95.58 15.56,96.58 15.56,99.96 21.8,106.21 21.8,106.61 20.94,107.47 20.94,107.6 21.2,107.85 21.32,107.85 22.15,107.01 22.61,107.01 23.08,107.48 23.08,107.91 22.3,108.7 22.3,108.82 22.55,109.07 22.67,109.07 23.24,108.51 34.09,108.51 35.58,110.01 36.15,110.01 36.27,109.89 36.27,109.62 v1(36,109.36)
  BOTTOM w0.102: v1(36,109.36) 36,109.38 36.18,109.56 36.18,110.68 35.9,110.96 U21.22
MDI3+: length 17.5
  TOP w0.102: U1.9 43.24,102.73 42.76,102.25 42.76,102.02 41.18,100.44 39.81,100.44 39.7,100.55 39.7,101.42 v1(39.75,101.47)
  IN1 w0.089: v1(33.18,104.4) 33.35,104.58 33.35,104.86 33.77,105.27 34.38,105.27 34.81,104.84 34.81,104 35.2,103.61 38.84,103.61 39.56,102.88 39.56,101.66 v1(39.75,101.47)
  BOTTOM w0.102: U21.6 32.9,104.12 v1(33.18,104.4)
MDI3+_1: length 32.8
  IN3 w0.089: v1(32.96,110) 32.96,109.44 32.73,109.21 24.42,109.21 15.58,100.37 15.58,95.44 13.79,93.65 CN3.7
  BOTTOM w0.102: v1(32.96,110) 33.15,110.19 33.15,110.84 32.9,111.09 U21.19
MDI3-: length 17.5
  TOP w0.102: v1(39.11,101.47) 39.31,101.28 39.31,100.39 39.65,100.05 41.35,100.05 43.15,101.85 43.15,102.08 43.63,102.56 43.63,102.64 43.64,102.65 U1.10
  IN1 w0.089: v1(33.9,104.38) 33.9,104.4 33.72,104.58 33.72,104.7 33.92,104.9 34.22,104.9 34.44,104.68 34.44,103.85 35.05,103.24 38.68,103.24 39.19,102.73 39.19,101.55 v1(39.11,101.47)
  BOTTOM w0.102: v1(33.9,104.38) U21.5
MDI3-_1: length 32.8
  IN3 w0.089: CN3.8 16.06,95.24 16.06,100.17 24.62,108.72 32.93,108.72 33.44,109.24 33.44,109.85 v1(33.6,110)
  BOTTOM w0.102: U21.20 33.9,111.12 33.54,110.76 33.54,110.06 v1(33.6,110)
ME_WR#: length 161.6
  TOP w0.102: U13.109 192.45,29.05 191.93,28.54 v2(191.93,28.38)
  IN2 w0.089: v2(191.93,28.38) 192.26,28.38 192.75,27.9 192.75,26.61 192.19,26.05 191.7,26.05 190.39,27.36 188.62,27.36 188.58,27.33 185.57,27.33 184.85,28.05 184.19,28.05 183.41,27.28 180.21,27.28 178.29,29.2 175.95,29.2 174.86,30.28 164.41,30.28 164.19,30.5 163.38,30.5 162.75,31.13 161.72,31.13 161.32,31.52 159.67,31.52 159.37,31.82 156.38,31.82 156.03,32.17 152.43,32.17 152.02,32.58 145.52,32.58 144.54,33.57 144.54,33.96 144.11,34.39 141.09,34.39 140.65,33.96 135.88,33.96 135.57,34.26 134.32,34.26 133.9,34.68 126.5,34.68 123.01,31.19 109.81,31.19 109.7,31.08 108.85,31.08 108.27,31.66 103.52,31.66 102.48,30.62 97.88,30.62 97.6,30.34 95.17,30.34 94.3,31.22 91.11,31.22 89.6,29.7 88.7,29.7 87.91,30.49 84.75,30.49 83.18,32.06 78.12,32.06 77.56,32.62 74.74,32.62 73.99,33.37 71.04,33.37 70.39,34.02 69.4,34.02 68.39,33.01 68.39,32.68 68.62,32.45 68.62,31.48 67.68,30.55 65.7,30.55 64.48,29.32 63.18,29.32 62.78,29.72 61.93,29.72 v1(61.53,29.32)
  BOTTOM w0.102: v1(61.53,29.32) 61.29,29.56 61.29,37.69 63.32,39.72 64.03,39.72 64.56,40.25 R679.1
MEM_VREF_CTL_QA: length 3.4
  TOP w0.381: Q5.3 R43.1 134.31,101.7 v1(134.76,102.14) 134.82,102.2 R40.1
MIC2-VREFO: length 15
  TOP w0.381: v1(212.13,43.93) 212.38,43.67 212.76,43.67
  IN2 w0.381: v2(203.95,36.61) 203.74,36.61 203.36,36.99 203.36,38.7 207.71,43.04 209.92,43.04 210.81,43.93 v1(212.13,43.93)
  BOTTOM w0.203: v2(203.95,36.61) 204.06,36.5 U30.29
  vias: v1(212.66,43.12)
MINICAR_PME#: length 4.7
  BOTTOM w0.102: CN9.55 181.71,17.63 Q46.1 181.14,17.06 v1(181.14,16.12) 181.14,15.73 180.55,15.15 R833.1
MIPI60_CFG0#: length 10.9
  TOP w0.102: v2(95.63,68.51) 95.64,68.52 95.64,68.53 95.64,68.53 95.85,68.53 96.44,67.94 96.85,67.94 97.22,68.31 97.85,68.31 98.77,69.23 101.84,69.23 103.49,70.88 103.49,71.41 103.8,71.72 R170.1
  BOTTOM w0.114: U24.AG6 95.62,68.35 95.62,68.48 95.63,68.49 v2(95.63,68.51)
MIPI60_CFG0#_R: length 3.7
  TOP w0.102: TP17.1 103.69,72.5 103.8,72.4 R170.2 103.97,72.22 104.17,72.41 104.17,72.63 104.27,72.73 R168.1 104.46,72.63 104.71,72.38 105.09,72.38 105.15,72.44 105.79,72.44 105.88,72.53 R169.2
MIPI60_CFG1#: length 14.7
  TOP w0.102: v2(95.03,68.49) 95.41,68.11 95.99,68.11 96.36,67.74 97.79,67.74 98.49,68.44 101.64,68.44 103.95,70.75 103.95,71.23 104.23,71.51 104.23,71.89 104.33,72 R171.1 104.46,71.86 104.71,71.61 105.27,71.61 105.32,71.56 105.73,71.56 105.88,71.72 R172.2
  BOTTOM w0.114: U24.AE7 94.73,68.79 v2(95.03,68.49)
MIPI60_CFG2#: length 13.5
  TOP w0.102: v2(94.39,67.73) 94.97,67.15 96.09,67.15 96.11,67.13 99.08,67.13 99.57,66.65 101.77,66.65 103.73,68.61 103.73,68.73 104.02,69.02 R181.1 104.1,69.1 104.38,69.38 105.29,69.38 105.47,69.2 R180.2
  BOTTOM w0.114: v2(94.39,67.73) 94.73,68.07 U24.AG7
MIPI60_CFG3#: length 17.5
  TOP w0.102: v2(93.76,69.56) 93.76,69.58 93.79,69.61 93.79,69.71 94.04,69.96 94.5,69.96 94.83,69.63 94.83,69.18 94.91,69.09 97.36,69.09 98.36,70.09 99.25,70.09 99.5,70.34 101.79,70.34 102.68,71.23 102.68,72.33 102.73,72.38 102.73,73.57 103.14,73.98 104.02,73.98 104.28,74.23 R161.1 104.46,74.41 104.63,74.59 105.68,74.59 105.88,74.38 R162.2
  BOTTOM w0.114: v2(93.76,69.56) 93.76,69.58 93.79,69.61 93.79,69.65 U24.AD9
MIPI60_CFG4#: length 16
  TOP w0.102: R167.2 105.73,73.52 105.68,73.47 105.4,73.47 105.09,73.16 104.56,73.16 104.46,73.27 R166.1 103.31,73.52 103.14,73.34 103.14,72.12 103.08,72.07 103.08,71.06 101.92,69.89 101.92,69.76 101.61,69.46 98.11,69.46 97.54,68.89 94.8,68.89 v2(94.42,68.52)
  BOTTOM w0.114: v2(94.42,68.52) 94.42,68.68 U24.AE9
MIPI60_CFG5#: length 15.7
  TOP w0.102: R152.2 105.88,75.14 105.73,74.99 104.63,74.99 104.48,75.14 R151.1 104.3,75.35 103.99,75.04 103.2,75.04 v1(102.69,74.54) 102.32,74.17 102.32,72.78 101.87,72.33 98.92,72.33 96.62,70.03 94.92,70.03 94.54,70.41 v2(94.49,70.41)
  BOTTOM w0.114: v2(94.49,70.41) 94.08,70.81 U24.AB9
MIPI60_CFG6#: length 12.7
  TOP w0.102: R176.2 105.81,70.88 105.44,70.88 105.11,71.21 104.68,71.21 104.48,71.01 R174.1 104.48,70.7 102.02,68.24 98.67,68.24 97.97,67.54 96.28,67.54 96.08,67.73 v2(95.83,67.73)
  BOTTOM w0.114: v2(95.83,67.73) 95.38,67.28 U24.AJ6
MIPI60_CFG7#: length 15.4
  TOP w0.102: v2(95.09,70.41) 96.42,70.41 98.86,72.85 v1(99.17,72.85) 99.29,72.73 101.66,72.73 101.9,72.97 101.9,74.36 102.99,75.45 103.82,75.45 104.07,75.7 104.07,75.93 104.25,76.11 R146.1 104.48,76.34 104.61,76.47 105.75,76.47 105.88,76.34 R147.2
  BOTTOM w0.114: U24.AB7 94.73,70.8 95.09,70.43 v2(95.09,70.41)
MIPI60_CFG8#: length 8.3
  TOP w0.102: R126.2 R125.1 93.79,77.84 93.58,77.63 93.58,76.79 92.29,75.5 92.29,73.74 v2(93.79,72.25)
  BOTTOM w0.114: v2(93.79,72.25) 93.79,72.27 93.43,72.63 U24.V10
MIPI60_CFG9#: length 11.9
  TOP w0.102: R185.2 105.6,68.44 105.12,67.96 104.56,67.96 104.36,68.16 R186.1 104.01,68.31 101.9,66.2 99.31,66.2 99.2,66.32 96.25,66.32 v2(95.85,66.73)
  BOTTOM w0.114: U24.AJ5 96.03,66.92 95.85,66.73 v2(95.85,66.73)
MIPI60_CFG10#: length 17.7
  TOP w0.102: v2(93.77,71.4) 94.17,71.8 95.41,71.8 95.51,71.89 96.15,71.89 97.55,73.29 97.55,73.67 98.18,74.31 98.18,74.96 99.33,76.1 99.33,76.85 99.71,77.23 100.87,77.23 101.28,76.82 v1(103.72,76.82) 103.69,76.85 103.69,77.04 104.2,77.54 104.2,77.76 104.41,77.96 R132.1 104.48,78.24 104.59,78.35 105.78,78.35 105.88,78.24 R133.2
  BOTTOM w0.114: U24.Y10 93.43,71.74 v2(93.77,71.4)
MIPI60_CFG11#: length 13.2
  TOP w0.102: R179.2 105.88,69.91 105.75,69.79 104.76,69.79 104.63,69.92 104.63,69.99 R177.1 104.48,70.12 101.79,67.42 98.66,67.42 98.58,67.33 96.19,67.33 96.18,67.35 95.48,67.35 v2(95.11,67.71)
  BOTTOM w0.114: U24.AJ7 94.73,67.33 v2(95.11,67.71)
MIPI60_CFG12#: length 17.3
  TOP w0.102: v2(93.88,70.41) 94.26,70.8 95.64,70.8 95.9,71.06 96.48,71.06 98.51,73.09 98.51,73.87 98.69,74.05 98.69,74.89 99.5,75.7 101.28,75.7 101.81,76.24 102.49,76.24 v1(102.73,76) 103.12,76.39 103.9,76.39 104.33,76.82 104.33,77.1 R140.1 104.48,77.05 104.66,76.87 105.65,76.87 105.88,77.1 R141.2
  BOTTOM w0.114: v2(93.88,70.41) U24.AB10
MIPI60_CFG13#: length 14.7
  TOP w0.102: R182.2 106.74,68.54 106.08,67.88 R193.1 106.08,67.5 105.62,67.04 103.31,67.04 101.66,65.39 99.53,65.39 99.02,65.9 97.6,65.9 97.12,65.42 96.55,65.42 95.24,66.72 v2(95.19,66.72)
  BOTTOM w0.114: U24.AL7 94.75,66.28 v2(95.19,66.72)
MIPI60_CFG14#: length 18.1
  TOP w0.102: v2(94.55,65.83) 94.73,65.83 95.68,64.88 97.79,64.88 97.99,65.09 98.65,65.09 99.16,64.58 102.02,64.58 103.67,66.23 106.56,66.23 106.87,66.53 107.88,66.53 v1(108.27,66.92) 108.65,67.3 108.65,67.8 108.42,68.03 R192.1 R184.2
  BOTTOM w0.114: U24.AL9 94.1,66.28 v2(94.55,65.83)
MIPI60_CFG15#: length 17.2
  TOP w0.102: v2(94.51,66.72) 94.99,66.24 94.99,65.88 95.72,65.15 97.43,65.15 97.78,65.49 98.82,65.49 99.33,64.98 101.84,64.98 103.49,66.64 106.34,66.64 v1(106.54,66.84) 106.61,66.92 106.61,67.8 106.84,68.03 R191.1 R183.2
  BOTTOM w0.102: U24.AJ9 94.12,67.2 94.51,66.8 v2(94.51,66.72)
MIPI60_CFG16_STB_DN: length 3.7
  TOP w0.102: R156.2 97.04,74.56 96.1,73.62 95.29,73.62 95.03,73.37 v2(95.03,73.2)
  BOTTOM w0.114: U24.V6 95.04,73.02 95.04,73.18 v2(95.03,73.2)
MIPI60_CFG17_STB_DP: length 6.6
  TOP w0.102: TP13.1 94.12,76.75 92.7,75.33 92.7,74.05 93.53,73.21 v2(94.42,73.21)
  BOTTOM w0.114: U24.V7 94.72,72.69 94.42,72.98 v2(94.42,73.21)
MIPI60_CFG18_STB_DN: length 7.1
  TOP w0.102: R143.2 98.92,76.27 97.78,75.13 97.78,74.48 97.09,73.8 97.09,73.42 96.02,72.35 95.13,72.35 v2(94.98,72.2)
  BOTTOM w0.114: v2(94.98,72.2) 94.98,72.17 U24.Y6
MIPI60_CFG19_STB_DP: length 5.6
  TOP w0.102: v2(94.41,71.4) 94.8,71.01 95.22,71.01 95.67,71.46 96.3,71.46 97.98,73.14 97.98,73.47 TP16.1
  BOTTOM w0.114: U24.Y7 94.73,71.72 v2(94.41,71.4)
MODEM_CLKREQ: length 109.9
  TOP w0.102: v2(142.76,32.75) 142.43,32.42 142.43,31.3 142.12,31 141.92,31 141.79,30.87 141.79,29.87 142.17,29.49 142.17,27.79 142.97,27 143.09,27 143.39,26.69 143.39,26.14 144.67,24.87 145.21,24.87 145.65,24.42 145.65,24.01 145.4,23.76 145.4,19.75 145.61,19.54 U14.1 145.82,18.42 R439.2 ; R439.2 146.1,17.29 R455.1 ; R439.2 146.47,18.52 U14.2 ; R256.2 77.4,43.93 v2(77.07,43.6)
  IN1 w0.089: v2(77.07,43.6) 77.71,43.6 78.04,43.93 79.56,43.93 79.69,44.06 81.15,44.06 82.14,43.07 82.14,38.83 81.63,38.32 81.63,35.92 82.02,35.53 82.83,35.53 84.01,34.36 84.73,34.36 85.41,35.04 85.41,37.32 85.52,37.44 86.55,37.44 86.79,37.2 86.79,35.94 87.22,35.51 87.71,35.51 88.36,34.86 89.89,34.86 90.74,35.71 90.74,35.95 91.22,36.44 91.63,36.44 91.91,36.16 91.91,34.89 92.11,34.68 93.15,34.68 94.06,33.77 97.15,33.77 97.55,34.17 99.57,34.17 101.03,32.71 101.52,32.71 102.07,33.26 108.8,33.26 109.08,32.98 109.58,32.98 113,29.57 122.83,29.57 125.68,32.42 129.21,32.42 129.91,33.12 131.98,33.12 132.92,32.18 135.38,32.18 136.08,32.88 137.35,32.88 137.96,32.27 141.57,32.27 142.05,32.75 v2(142.76,32.75)
  BOTTOM w0.102: U24.CT47 75.62,44.18 76.41,43.39 76.87,43.39 v2(77.07,43.6)
MODEM_CLKREQ_L: length 61.9
  TOP w0.102: v2(147.74,26.62) 147.74,26.1 148.25,25.59 148.25,25.03 148.08,24.87 148.08,24.04 147.86,23.82 R404.1 147.86,23.17 v1(147.48,22.8) 147.12,22.43 U14.4 147.12,21.03 147.2,20.94 147.57,20.94 147.73,20.78 148.17,20.78 148.88,20.07 148.88,17.99 148.17,17.28 R455.2
  IN3 w0.089: v2(147.74,26.62) 147.74,26.1 147.99,25.85 153.49,25.85 153.96,25.38 155.8,25.38 156.16,25.02 159.6,25.02 160.12,24.5 165.44,24.5 165.64,24.3 169.44,24.3 169.54,24.4 172.49,24.4 173.29,25.2 179,25.2 179.37,25.57 181.7,25.57 182.29,24.98 185.08,24.98 185.43,25.33 185.43,25.59 185.95,26.11 189.56,26.11 189.85,25.82 v2(189.85,25.35)
  BOTTOM w0.102: v2(189.85,25.35) 189.85,25.36 189.82,25.39 189.82,27.69 190.01,27.88 CN9.14
MX0: length 65.4
  TOP w0.102: v2(195.08,16.58) 195.08,16.53 195.13,16.48 195.13,15.2 194.85,14.91 U13.58 ; C412.1 166.43,21.25 v2(166.18,21.5)
  IN3 w0.089: v2(195.08,16.58) 195.26,16.76 195.26,17.49 194.98,17.77 193,17.77 192.73,18.05 191.58,18.05 191.5,18.13 191.5,18.91 189.69,20.72 188.82,20.72 188.23,21.31 186.1,21.31 185.76,21.66 185.4,21.66 185.23,21.83 183.61,21.83 182.09,20.31 181.25,20.31 180.91,20.64 179.08,20.64 178.7,21.02 173.2,21.02 172.6,20.42 167.97,20.42 167.7,20.69 166.99,20.69 v2(166.18,21.5) 165.75,21.07 165.29,21.07 163.85,22.51 157.59,22.51 157.47,22.63 155.73,22.63 155.07,23.29 146.16,23.29 145.68,23.76 145.68,24.45 145.48,24.65 144.69,24.65 144.59,24.75 144.59,26.15 v2(144.54,26.2)
  BOTTOM w0.102: CN8.10 144.4,26.06 v2(144.54,26.2) 144.54,26.45 v1(144.21,26.78) ; CN10.10 166,20.79 166.18,20.97 v2(166.18,21.5)
MX1: length 62.8
  TOP w0.102: v2(168.72,19.38) 168.69,19.4 C424.1 ; U13.59 195.25,14.98 195.36,15.1 195.36,16.27 195.49,16.39 195.49,16.9 195.36,17.03 195.11,17.03 194.77,17.37 v2(194.75,17.37)
  IN3 w0.089: v2(145.25,24.24) 145.25,24.22 145.22,24.19 145.22,23.95 146.08,23.1 154.99,23.1 155.65,22.44 157.39,22.44 157.51,22.32 162.37,22.32 164.83,19.86 168.24,19.86 v2(168.72,19.38) 169.57,20.23 172.68,20.23 173.28,20.83 178.62,20.83 179,20.45 180.83,20.45 181.17,20.12 182.17,20.12 182.94,20.88 186.31,20.88 186.55,21.12 188.15,21.12 188.74,20.53 189.61,20.53 191.3,18.83 191.3,18.05 191.5,17.85 192.65,17.85 192.96,17.54 194.6,17.54 194.75,17.39 v2(194.75,17.37)
  BOTTOM w0.102: v2(168.72,19.38) 168.64,19.46 168.64,19.48 168.3,19.83 167.42,19.83 167,20.25 CN10.9 ; CN8.9 145.4,24.42 145.25,24.27 v2(145.25,24.24)
MX2: length 62.9
  TOP w0.102: C406.1 167.96,21.45 v2(167.92,21.49) ; v2(195.9,16.59) 195.9,16.47 195.59,16.17 195.59,14.98 195.65,14.93 U13.60
  IN3 w0.089: v2(195.9,16.59) 195.85,16.65 195.85,17.27 195.46,17.66 195.46,18.4 195.29,18.57 193.18,18.57 193.06,18.45 192.05,18.45 191.69,18.82 191.69,18.99 189.76,20.91 188.9,20.91 188.2,21.61 187.61,21.61 187.11,22.11 186.72,22.11 186.46,21.85 185.48,21.85 185.31,22.02 183.53,22.02 182.78,21.26 181.1,21.26 180.87,21.02 179.24,21.02 178.69,21.58 176.03,21.58 175.1,22.51 174.17,22.51 173.92,22.26 173.92,22.03 172.5,20.61 168.82,20.61 167.94,21.49 v2(167.92,21.49) 167.92,21.74 167.75,21.91 164.75,21.91 163.96,22.7 157.67,22.7 157.55,22.82 155.81,22.82 155.15,23.48 147.84,23.48 v2(147.08,24.24)
  BOTTOM w0.102: v2(167.92,21.49) 168,21.41 CN10.8 ; v2(147.08,24.24) 146.4,24.92 CN8.8 146.4,26.16 v1(145.96,26.61)
MX3: length 65
  TOP w0.102: v2(168.53,21.49) 168.7,21.32 169.25,21.32 C404.1 ; U13.61 196.05,14.85 195.82,15.08 195.82,15.81 v2(196.02,16.01)
  IN3 w0.089: v2(196.02,16.01) 196.27,16.26 196.27,16.75 196.13,16.89 196.04,16.99 196.04,17.35 195.65,17.74 195.65,18.48 195.37,18.76 193.1,18.76 192.98,18.64 192.13,18.64 191.88,18.9 191.88,19.24 190.12,20.99 190.12,21.46 189.79,21.8 187.69,21.8 187.19,22.3 186.64,22.3 186.38,22.04 185.56,22.04 185.39,22.21 183.46,22.21 182.7,21.45 181.02,21.45 180.79,21.21 179.32,21.21 178.76,21.77 176.11,21.77 175.18,22.7 174.08,22.7 173.71,22.33 173.71,22.1 172.41,20.8 169.22,20.8 v2(168.53,21.49) 168.5,21.49 168.44,21.55 168.41,21.55 167.86,22.1 164.89,22.1 164.1,22.89 157.75,22.89 157.63,23.01 155.89,23.01 155.23,23.67 149.05,23.67 148.49,24.23 v2(148.49,24.24)
  BOTTOM w0.102: v2(148.49,24.24) 148.27,24.24 147.86,24.65 147.63,24.65 147.4,24.88 CN8.7 147.4,25.91 147.61,26.12 148.43,26.12 148.81,26.5 148.81,26.96 v1(148.5,27.27) ; v2(168.53,21.49) 168.55,21.47 168.57,21.47 169,21.04 CN10.7
MX4: length 62.8
  TOP w0.102: U13.62 196.45,14.9 196.23,15.12 v2(196.23,15.45) ; v2(169.68,21.55) 170.01,21.55 170.22,21.35 C405.1
  IN3 w0.089: v2(149.3,24.24) 149.3,24.23 149.67,23.86 155.31,23.86 155.97,23.2 157.71,23.2 157.83,23.08 164.22,23.08 165.01,22.29 167.97,22.29 168.31,21.95 168.6,21.95 168.8,21.75 169.53,21.75 169.68,21.6 v2(169.68,21.55) 169.68,21.25 169.94,20.99 172.33,20.99 173.52,22.19 173.52,22.44 174.02,22.94 176.62,22.94 177.42,22.15 179,22.15 179.04,22.18 182.53,22.18 182.75,22.4 185.47,22.4 185.64,22.23 186.3,22.23 186.56,22.49 187.27,22.49 187.77,21.99 189.87,21.99 190.31,21.54 190.31,21.07 192.07,19.32 192.07,18.98 192.21,18.83 192.9,18.83 193.02,18.95 195.44,18.95 195.84,18.56 195.84,17.82 196.23,17.43 196.23,17.06 196.46,16.83 196.46,15.69 v2(196.23,15.45)
  BOTTOM w0.102: v2(169.68,21.55) 169.71,21.53 169.71,21.22 170,20.93 CN10.6 ; v1(149.79,27.29) 149.44,26.94 149.44,26.81 148.4,25.77 CN8.6 148.4,25 149.16,24.24 v2(149.3,24.24)
MX5: length 63.4
  TOP w0.102: C401.1 171.26,21.37 v2(171.26,21.83) ; v2(196.99,17.15) 196.84,16.99 196.67,16.99 196.43,16.75 196.43,16.37 196.63,16.17 196.63,15.06 196.85,14.85 U13.63
  IN3 w0.089: v2(150.52,24.24) 150.52,24.26 151.26,25 153.14,25 153.69,24.45 155.53,24.45 156.21,23.77 157.95,23.77 158.07,23.65 164.61,23.65 165.4,22.86 168.2,22.86 168.54,22.52 168.84,22.52 169.03,22.33 171.02,22.33 171.26,22.08 v2(171.26,21.83) 171.82,22.4 172.55,22.4 173.68,23.52 176.85,23.52 177.65,22.72 178.77,22.72 178.8,22.75 182.29,22.75 182.51,22.97 185.43,22.97 185.82,23.36 187.21,23.36 188.01,22.56 190.1,22.56 190.89,21.78 190.89,21.31 192.39,19.81 193.13,19.81 193.47,20.15 195.27,20.15 196.99,18.42 v2(196.99,17.15)
  BOTTOM w0.102: v2(171.26,21.83) 171,21.57 CN10.5 ; v1(150.94,26.61) 150.13,26.61 149.4,25.88 CN8.5 149.4,24.82 149.97,24.24 v2(150.52,24.24)
MX6: length 61.1
  TOP w0.102: v2(196.84,16.59) 196.86,16.56 196.86,15.23 197.25,14.85 U13.64 197.25,13.15 TP47.1 ; C402.1 171.72,21.37 171.84,21.5 v2(171.84,21.83)
  IN3 w0.089: v2(151.1,24.24) 151.1,24.27 151.64,24.81 153.06,24.81 153.61,24.26 155.45,24.26 156.13,23.58 157.87,23.58 157.99,23.46 164.52,23.46 165.31,22.67 168.12,22.67 168.46,22.33 168.76,22.33 168.95,22.14 170.78,22.14 170.86,22.05 170.86,21.69 171.18,21.37 171.75,21.37 171.84,21.46 v2(171.84,21.83) 172.22,22.2 172.63,22.2 173.75,23.33 176.78,23.33 177.58,22.53 178.85,22.53 178.88,22.56 182.37,22.56 182.59,22.78 185.63,22.78 185.8,22.61 186.15,22.61 186.41,22.87 187.43,22.87 187.93,22.37 190.02,22.37 190.7,21.7 190.7,21.23 192.31,19.62 193.21,19.62 193.55,19.96 195.19,19.96 196.03,19.12 196.03,17.9 196.45,17.47 196.45,17.11 196.65,16.91 196.65,16.77 v2(196.84,16.59)
  BOTTOM w0.102: CN8.4 150.4,24.95 v2(151.1,24.24) ; CN10.4 172,21.11 171.84,21.27 v2(171.84,21.83)
MX7: length 58.8
  TOP w0.102: U13.65 198.18,15.78 197.69,16.26 197.69,17.45 197.36,17.78 196.18,17.78 195.16,18.81 193.57,18.81 193.21,19.16 192.52,19.16 v2(192.47,19.21) ; v2(151.69,24.24) 151.05,23.61 TP44.1 ; v2(172.43,21.83) C403.1
  IN3 w0.089: v2(151.69,24.24) 152.06,24.62 152.98,24.62 153.53,24.07 155.37,24.07 156.05,23.39 157.79,23.39 157.91,23.27 164.36,23.27 165.15,22.48 168.04,22.48 168.38,22.14 168.68,22.14 168.87,21.95 170.57,21.95 170.66,21.86 170.66,21.61 171.09,21.18 172.14,21.18 172.4,21.45 172.4,21.8 v2(172.43,21.83) 172.53,21.83 173.83,23.14 176.7,23.14 177.5,22.34 178.93,22.34 178.96,22.37 182.45,22.37 182.67,22.59 185.55,22.59 185.72,22.42 186.22,22.42 186.48,22.68 187.35,22.68 187.85,22.18 189.94,22.18 190.5,21.62 190.5,21.15 192.44,19.21 v2(192.47,19.21)
  BOTTOM w0.102: v2(151.69,24.24) 151.69,24.51 151.4,24.8 CN8.3 ; CN10.3 173,21.23 172.43,21.8 v2(172.43,21.83)
MY0: length 69.4
  TOP w0.102: U13.36 186.05,15.23 186.04,15.24 186.04,16.06 v2(185.99,16.12) ; v2(151.57,18.76) 150.81,19.52 v1(150.81,19.57) C407.1
  IN3 w0.089: v2(185.99,16.12) 185.64,16.12 185.59,16.06 183.08,16.06 182.78,15.77 157.7,15.77 155.68,17.79 152.54,17.79 v2(151.57,18.76) 151.19,18.37 150.46,18.37 150.23,18.15 146.18,18.15 142.89,21.43 131.51,21.43 130.26,22.69 130.26,23.08 129.73,23.61 129.6,23.61 v2(129.22,23.99)
  BOTTOM w0.102: CN8.26 128.4,24.61 129.02,23.99 v2(129.22,23.99) ; v2(151.57,18.76) 151.09,18.76 150,19.85 CN10.26
MY1: length 70
  TOP w0.102: C408.1 151.57,19.34 v2(152.16,18.76) 152.16,18.63 151.67,18.15 v1(151.62,18.15) ; v2(186.55,16.62) 186.45,16.52 186.45,14.87 186.45,14.87 U13.37
  IN3 w0.089: v2(129.86,23.99) 130.45,23.4 130.45,22.77 131.59,21.62 142.97,21.62 145.41,19.18 151.73,19.18 v2(152.16,18.76) 152.94,17.98 155.75,17.98 157.77,15.96 180.27,15.96 180.93,16.61 182.14,16.61 182.5,16.25 185.5,16.25 185.97,16.72 186.45,16.72 v2(186.55,16.62)
  BOTTOM w0.102: v2(129.86,23.99) 129.4,24.45 CN8.25 ; CN10.25 151,19.91 v2(152.16,18.76)
MY2: length 69.2
  TOP w0.102: U13.38 186.85,15 186.7,15.15 186.7,15.43 187.13,15.86 v2(187.13,16.67) ; v2(152.74,18.76) 152.33,19.16 v1(152.33,19.62) C409.1
  IN3 w0.089: v2(130.49,23.99) 130.64,23.84 130.64,22.84 131.67,21.81 143.05,21.81 145.47,19.39 152.11,19.39 v2(152.74,18.76) 153.33,18.17 155.83,18.17 157.85,16.15 177.51,16.15 178.17,16.81 183.09,16.81 183.45,16.45 185.42,16.45 186.05,17.08 186.73,17.08 v2(187.13,16.67)
  BOTTOM w0.102: v2(130.49,23.99) 130.4,24.08 CN8.24 ; v2(152.74,18.76) 152,19.5 CN10.24
MY3: length 70.6
  TOP w0.102: C410.1 153.1,18.99 v2(153.33,18.76) 153.33,18.58 152.97,18.22 v1(152.97,17.84) ; v2(186.47,17.49) 186.88,17.08 187.39,17.08 187.54,16.93 187.54,15.2 187.25,14.91 U13.39
  IN3 w0.089: v2(131.13,23.99) 130.83,23.69 130.83,22.92 131.75,22 143.13,22 145.55,19.58 152.5,19.58 v2(153.33,18.76) 153.71,18.38 155.89,18.38 157.93,16.34 177.43,16.34 178.09,17 183.17,17 183.53,16.64 185.34,16.64 186.19,17.49 v2(186.47,17.49)
  BOTTOM w0.102: CN8.23 131.4,24.26 v2(131.13,23.99) ; CN10.23 153,19.08 v2(153.33,18.76)
MY4: length 69.2
  TOP w0.102: C411.1 153.83,20.28 v1(153.83,19.54) 153.83,18.88 153.91,18.81 v2(153.91,18.76) ; v2(187.06,17.49) 187.51,17.49 187.77,17.23 187.77,15.11 187.65,14.99 U13.40
  IN3 w0.089: v2(187.06,17.49) 186.68,17.86 186.2,17.86 185.85,18.22 184.04,18.22 183.01,17.19 177.91,17.19 177.25,16.53 174.36,16.53 173.68,17.2 173.43,17.2 172.76,16.53 158.01,16.53 155.73,18.81 153.94,18.81 153.91,18.78 ; 153.91,18.78 153.91,18.88 153.3,19.49 152.91,19.49 152.63,19.77 145.63,19.77 143.21,22.19 132.88,22.19 132.32,22.75 132.32,23.43 v1(132.01,23.74) ; 153.91,18.78 v2(153.91,18.76)
  BOTTOM w0.102: CN10.22 154,18.97 153.91,18.88 v2(153.91,18.76) ; v1(132.01,23.74) 132.4,24.12 CN8.22
MY5: length 69.6
  TOP w0.102: C414.1 155.48,19.34 v2(155.59,19.24) ; v2(188.81,17.46) 189.19,17.08 189.19,16.04 188.05,14.89 U13.41
  IN3 w0.089: v2(132.9,23.74) 132.52,23.35 132.52,22.81 132.95,22.38 143.29,22.38 145.71,19.96 154.71,19.96 155.43,19.24 v2(155.59,19.24) 155.66,19.16 155.66,19.15 158.09,16.72 172.68,16.72 173.35,17.39 173.76,17.39 174.44,16.72 177.18,16.72 177.84,17.38 182.94,17.38 183.96,18.41 185.93,18.41 186.28,18.05 187.04,18.05 187.47,17.63 188.67,17.63 188.81,17.49 v2(188.81,17.46)
  BOTTOM w0.102: v2(132.9,23.74) 133.08,23.91 133.08,24.42 133.4,24.74 CN8.21 ; v2(155.59,19.24) 155,19.83 CN10.21
MY6: length 70.3
  TOP w0.102: U13.42 188.45,14.86 189.6,16.01 v2(189.6,16.7) ; C415.1 156.2,19.26 v2(156.17,19.24)
  IN3 w0.089: v2(189.6,16.7) 189.36,16.7 189.19,16.86 189.19,17.7 189.03,17.86 187.5,17.86 187.12,18.24 186.36,18.24 186,18.6 183.89,18.6 182.86,17.57 177.76,17.57 177.1,16.91 174.52,16.91 173.84,17.58 173.27,17.58 172.6,16.91 158.17,16.91 156.17,18.91 v2(156.17,19.24) 156.17,19.34 155.36,20.15 145.79,20.15 143.37,22.57 133.33,22.57 132.93,22.97 v2(132.93,23.15)
  BOTTOM w0.102: CN8.20 134.4,24.85 134.08,24.53 133.57,24.53 133.31,24.27 133.31,23.56 132.93,23.18 v2(132.93,23.15) ; v2(156.17,19.24) 156.17,19.67 156,19.84 CN10.20
MY7: length 71.2
  TOP w0.102: v1(155.87,17.87) 156.75,18.76 v2(156.75,19.25) 156.75,19.65 156.93,19.82 C416.1 ; U13.43 188.85,14.91 190.08,16.14 190.08,17.15 189.93,17.3 v2(189.58,17.3)
  IN3 w0.089: v2(134.53,23.33) 135.02,22.84 143.37,22.84 145.87,20.34 155.66,20.34 v2(156.75,19.25) 156.75,18.59 158.25,17.1 172.52,17.1 173.19,17.77 173.92,17.77 174.59,17.1 177.02,17.1 177.68,17.76 182.78,17.76 183.81,18.79 186.08,18.79 186.44,18.43 187.2,18.43 187.58,18.05 189.11,18.05 189.58,17.58 v2(189.58,17.3)
  BOTTOM w0.102: CN8.19 135.4,24.96 134.94,24.5 134.5,24.5 134.05,24.04 134.05,23.51 134.22,23.33 v2(134.53,23.33) ; CN10.19 157,19.56 156.75,19.32 v2(156.75,19.25)
MY8: length 71.4
  TOP w0.102: C417.1 157.64,19.54 v2(157.34,19.24) 157.21,19.11 157.21,17.91 v1(157.31,17.82) ; U13.44 189.25,14.88 190.46,16.1 190.46,17.74 190.08,18.12 v2(189.6,18.12)
  IN3 w0.089: v2(189.6,18.12) 189.55,18.12 189.43,18.24 187.66,18.24 187.28,18.62 186.52,18.62 186.16,18.98 183.73,18.98 182.7,17.95 176.41,17.95 176.06,18.3 174.31,18.3 173.97,17.96 173.12,17.96 172.44,17.29 159.29,17.29 158.65,17.92 158.65,18.43 158.43,18.66 157.92,18.66 v2(157.34,19.24) 156.94,19.64 156.68,19.64 155.79,20.53 145.95,20.53 143.45,23.03 135.64,23.03 134.76,23.91 v2(134.54,23.91)
  BOTTOM w0.102: CN8.18 136.4,24.69 136.24,24.53 135.55,24.53 135.44,24.42 135.44,24.18 135.17,23.91 v2(134.54,23.91) ; CN10.18 158,19.9 v2(157.34,19.24)
MY9: length 68.1
  TOP w0.102: v2(158.92,19.27) 159.07,19.42 C419.1 ; v2(188.63,18.81) 188.66,18.78 188.81,18.78 189.16,19.14 189.88,19.14 190.69,18.32 190.69,15.95 189.65,14.91 U13.45
  IN3 w0.089: v2(136.03,24.12) 136.67,23.48 143.54,23.48 146.1,20.91 155.95,20.91 156.84,20.02 157.41,20.02 157.76,19.67 158.48,19.67 158.88,19.27 v2(158.92,19.27) 158.92,19.22 159.83,18.31 159.83,17.91 160.07,17.67 172.28,17.67 172.96,18.34 173.81,18.34 174.15,18.68 176.22,18.68 176.56,18.33 182.54,18.33 183.57,19.36 186.32,19.36 186.68,19 188.38,19 188.58,18.81 v2(188.63,18.81)
  BOTTOM w0.102: CN8.17 137.4,24.67 137.06,24.33 136.47,24.33 136.26,24.12 v2(136.03,24.12) ; v2(158.92,19.27) 158.92,19.78 159,19.86 CN10.17
MY10: length 72.5
  TOP w0.102: v2(188.05,18.62) 188.05,18.8 188.62,19.37 190.03,19.37 190.92,18.48 190.92,15.8 190.05,14.93 U13.46 ; C418.1 158.35,19.31 v2(158.33,19.29)
  IN3 w0.089: v2(135.82,23.56) 136.16,23.23 143.52,23.23 146.03,20.72 155.87,20.72 156.76,19.83 157.28,19.83 157.82,19.29 v2(158.33,19.29) 158.89,18.73 158.89,18.07 159.48,17.48 172.36,17.48 173.04,18.15 173.89,18.15 174.23,18.49 176.14,18.49 176.49,18.14 182.62,18.14 183.65,19.17 186.24,19.17 186.6,18.81 187.85,18.81 v2(188.05,18.62)
  BOTTOM w0.102: v2(135.82,23.56) 136.08,23.56 136.63,24.1 138.07,24.1 138.4,24.43 CN8.16 ; v2(158.33,19.29) 158.33,19.01 158.56,18.78 159.35,18.78 159.45,18.88 159.45,19.54 160,20.1 CN10.16
MY11: length 66.4
  TOP w0.102: U13.51 192.05,15.96 192.01,15.99 v2(192.01,16) ; C420.1 159.78,19.43 v2(159.93,19.28)
  IN3 w0.089: v2(192.01,16) 192,16 191.99,16.01 191.78,16.01 190.35,17.44 190.35,18.43 189.21,19.58 188.34,19.58 187.75,20.17 186.95,20.17 186.71,19.93 183.33,19.93 182.56,19.16 180.77,19.16 180.44,19.5 179.27,19.5 178.68,18.92 176.79,18.92 175.83,19.88 173.68,19.88 172.05,18.24 161.4,18.24 160.8,18.85 160.36,18.85 v2(159.93,19.28) 159.93,19.35 159.25,20.03 158.93,20.03 158.68,20.28 158.03,20.28 157.72,20.59 157.08,20.59 156.18,21.49 155.26,21.49 154.6,22.15 145.68,22.15 142.95,24.88 142.1,24.88 v2(139.99,26.99)
  BOTTOM w0.102: CN8.15 139.4,25.79 139.99,26.38 v2(139.99,26.99) ; CN10.15 161,19.95 160.84,19.8 160.44,19.8 v2(159.93,19.28)
MY12: length 66.8
  TOP w0.102: U13.52 192.45,14.9 192.27,15.07 192.27,15.66 192.45,15.83 192.45,16.16 191.99,16.61 191.99,16.76 191.99,16.77 v2(191.99,16.81) ; v2(160.54,19.29) 160.49,19.34 C421.1
  IN3 w0.089: v2(140.58,26.99) 140.58,26.73 142.24,25.07 143.03,25.07 145.76,22.34 154.68,22.34 155.34,21.68 156.26,21.68 157.16,20.78 157.82,20.78 158.12,20.48 158.75,20.48 159.01,20.22 159.33,20.22 159.86,19.69 160.14,19.69 v2(160.54,19.29) 160.62,19.29 161.48,18.43 171.97,18.43 173.6,20.07 175.91,20.07 176.87,19.11 178.6,19.11 179.19,19.69 180.51,19.69 180.85,19.35 182.48,19.35 183.25,20.12 186.63,20.12 186.87,20.36 187.83,20.36 188.42,19.77 189.29,19.77 190.54,18.51 190.54,17.53 191.22,16.85 191.9,16.85 191.94,16.81 v2(191.99,16.81)
  BOTTOM w0.102: CN10.14 162,19.96 161.86,19.83 161.2,19.83 160.66,19.29 v2(160.54,19.29) ; v2(140.58,26.99) 140.4,26.81 CN8.14
MY13: length 67.6
  TOP w0.102: v2(192.57,16.79) 192.56,16.78 192.56,16.36 192.67,16.25 192.67,15.73 192.55,15.6 192.55,15.22 192.85,14.92 U13.53 ; v2(161.19,19.25) 161.2,19.25 C422.1
  IN3 w0.089: v2(141.16,26.99) 141.54,26.61 141.54,26.14 142.43,25.26 143.11,25.26 145.84,22.53 154.76,22.53 155.42,21.87 156.34,21.87 157.24,20.97 157.92,20.97 158.21,20.69 158.81,20.69 159.09,20.41 159.4,20.41 159.93,19.88 160.24,19.88 160.37,19.75 160.69,19.75 v2(161.19,19.25) 161.29,19.16 161.29,18.89 161.56,18.62 170.07,18.62 170.16,18.71 170.16,19.08 170.74,19.66 172.92,19.66 173.52,20.26 175.98,20.26 176.95,19.3 178.52,19.3 179.11,19.88 180.59,19.88 180.93,19.54 182.41,19.54 183.17,20.31 186.55,20.31 186.79,20.55 187.91,20.55 188.5,19.96 189.37,19.96 190.73,18.59 190.73,17.62 191.1,17.26 192.11,17.26 192.35,17.02 192.35,16.98 192.54,16.79 v2(192.57,16.79)
  BOTTOM w0.102: CN8.13 141.4,26.75 v2(141.16,26.99) ; CN10.13 163,20.05 162.85,19.9 162.58,19.9 162.28,19.6 161.54,19.6 v2(161.19,19.25)
MY14: length 69
  TOP w0.102: v2(193.08,15.66) 193.1,15.63 193.1,15.23 193.25,15.08 U13.54 193.25,13.39 v1(192.49,12.64) ; C423.1 161.8,19.81 v2(161.8,19.18)
  IN3 w0.089: v2(193.08,15.66) 193.08,15.68 192.99,15.77 192.99,16.98 192.51,17.45 191.26,17.45 190.92,17.79 190.92,18.67 189.45,20.15 188.58,20.15 187.99,20.74 186.71,20.74 186.47,20.5 183.1,20.5 182.33,19.73 181.01,19.73 180.67,20.07 179.03,20.07 178.44,19.49 177.03,19.49 176.06,20.45 173.44,20.45 172.84,19.85 170.66,19.85 169.97,19.16 169.97,18.9 169.88,18.81 162.16,18.81 v2(161.8,19.18) 161.8,19.2 161.06,19.94 160.45,19.94 160.32,20.07 160.01,20.07 159.48,20.6 159.17,20.6 158.88,20.89 158.3,20.89 158.02,21.16 157.32,21.16 156.42,22.06 155.5,22.06 154.84,22.72 145.92,22.72 143.19,25.45 143,25.45 141.95,26.5 v2(141.95,26.76)
  BOTTOM w0.102: CN10.12 164,19.92 163.76,19.67 162.67,19.67 162.29,19.29 161.91,19.29 v2(161.8,19.18) ; CN8.12 142.4,25.95 141.95,26.4 v2(141.95,26.76)
MY15: length 69.7
  TOP w0.102: v2(165.28,19.23) 165.75,19.7 C427.1 ; v1(193.76,12.64) 193.65,12.75 U13.55 193.65,14.88 193.94,15.17 193.94,15.51 194.07,15.63 194.07,16.12 194.27,16.32 v2(194.27,16.62)
  IN3 w0.089: v2(142.51,26.55) 142.51,26.4 146,22.91 154.91,22.91 155.58,22.25 157.31,22.25 157.43,22.13 162.29,22.13 164.75,19.67 164.83,19.67 v2(165.28,19.23) 165.72,19.67 167.96,19.67 168.29,19.34 168.29,19.09 168.38,19 169.07,19 169.2,19.14 169.2,19.52 169.72,20.04 172.76,20.04 173.36,20.64 176.14,20.64 177.11,19.68 178.37,19.68 178.95,20.26 180.75,20.26 181.09,19.93 182.25,19.93 183.02,20.69 186.39,20.69 186.63,20.93 188.07,20.93 188.66,20.34 189.53,20.34 191.11,18.75 191.11,17.98 191.44,17.65 192.58,17.65 193.43,16.8 193.81,16.8 193.89,16.72 194.17,16.72 v2(194.27,16.62)
  BOTTOM w0.102: v2(142.51,26.55) 143.17,26.55 143.4,26.32 CN8.11 ; CN10.11 165,19.53 165.28,19.25 v2(165.28,19.23)
MY16: length 82.4
  TOP w0.102: v2(194.35,15.33) 194.35,15.32 194.22,15.2 194.22,15.1 194.05,14.93 U13.56 194.05,13.27 194.68,12.64 v1(195.06,12.64) ; C400.1 149.34,20.94 148.98,21.3 v2(148.98,21.53)
  IN3 w0.089: v2(194.35,15.33) 194.12,15.1 192.38,15.1 190.16,17.32 190.16,18.36 189.13,19.39 186.83,19.39 186.48,19.74 183.41,19.74 182.64,18.97 180.69,18.97 180.36,19.31 179.34,19.31 178.76,18.72 176.71,18.72 176.37,19.06 173.99,19.06 173.65,18.72 172.8,18.72 172.13,18.05 161.32,18.05 160.72,18.66 160.02,18.66 159.51,19.17 159.51,19.5 159.17,19.84 158.85,19.84 158.61,20.08 157.94,20.08 157.62,20.4 157,20.4 156.11,21.3 155.18,21.3 154.52,21.96 149.42,21.96 148.99,21.53 v2(148.98,21.53) 148.58,21.93 145.63,21.93 143.68,23.87 137.08,23.87 136.27,24.68 135.51,24.68 135.46,24.64 128.7,24.64 v2(127.95,23.89)
  BOTTOM w0.102: v2(148.98,21.53) 148.8,21.53 148,20.72 CN10.28 ; v2(127.95,23.89) 127.95,23.91 127.34,24.53 126.52,24.53 126.4,24.65 CN8.28
MY17: length 80.9
  TOP w0.102: U13.57 194.45,14.85 194.83,15.23 194.83,15.67 194.57,15.94 v2(194.47,15.94) ; C394.1 149.67,21.63 v2(149.57,21.53)
  IN3 w0.089: v2(194.47,15.94) 194.57,15.94 194.85,15.65 194.85,15.2 194.56,14.91 192.28,14.91 189.97,17.21 189.97,18.28 189.05,19.19 186.76,19.19 186.4,19.55 183.49,19.55 182.46,18.52 176.64,18.52 176.29,18.87 174.07,18.87 173.73,18.53 172.88,18.53 172.2,17.86 160.17,17.86 160.08,17.95 160.08,18.33 159.32,19.09 159.32,19.42 159.09,19.65 158.77,19.65 158.55,19.87 157.85,19.87 157.52,20.21 156.92,20.21 156.03,21.11 149.99,21.11 v2(149.57,21.53) 149.53,21.53 149.13,21.13 146.16,21.13 143.6,23.68 137,23.68 136.19,24.49 135.58,24.49 135.54,24.45 129.09,24.45 v2(128.54,23.89)
  BOTTOM w0.102: v2(149.57,21.53) 149,20.96 CN10.27 ; CN8.27 127.4,24.79 127.7,24.5 128.19,24.5 128.54,24.15 v2(128.54,23.89)
N12E_SCL: length 10.1
  BOTTOM w0.102: U22.C9 100.91,94.35 100.51,93.95 100.51,93.7 100.31,93.51 100.31,92.78 100.47,92.63 100.47,91.96 100.11,91.61 99.68,91.61 98.62,90.55 97.03,90.55 96.53,90.05 95.31,90.05 R559.1
N12E_SDA: length 11.1
  BOTTOM w0.102: U22.C8 100.07,94.35 99.63,93.91 99.63,91.88 98.52,90.78 96.94,90.78 96.44,90.28 93.46,90.28 93.2,90.01 93.2,89.68 93.53,89.34 R558.1
NBSWON#: length 77.4
  TOP w0.102: D17.2 150.56,19.11 150.33,19.34 150.33,19.8 149.98,20.15 R430.2 149.44,20.15 148.58,21.02 148.58,21.69 149.85,22.97 151.06,22.97 v2(152.33,24.24) ; SW1.1 169.89,23.02 169.7,23.21 v2(169.7,24.03) 169.86,24.19 169.86,25.33 170.31,25.78 SW1.2 ; R362.1 170.55,28.89 170.39,29.04 170.39,30.02 169.39,31.02 v2(169.02,31.02) 168.67,30.67 v1(168.67,30.52) ; U13.107 193.25,28.8 193.48,28.56 v2(193.99,28.56)
  IN2 w0.089: v2(152.33,24.24) 154.22,24.24 155.02,25.04 159.79,25.04 160.46,24.38 165.38,24.38 165.46,24.3 166.45,24.3 166.61,24.14 169.25,24.14 169.37,24.03 v2(169.7,24.03)
  IN3 w0.089: v2(169.02,31.02) 169.22,31.22 174.83,31.22 175.74,30.31 179.7,30.31 180.18,29.83 182.84,29.83 183.41,30.39 187.59,30.39 187.64,30.34 192.43,30.34 193.99,28.78 v2(193.99,28.56)
  BOTTOM w0.102: v2(169.02,31.02) 166.76,28.76 166.76,26.93 167.6,26.09 167.6,25.05 168.16,24.5 169.23,24.5 v2(169.7,24.03) 170.23,24.03 170.32,24.12 171.13,24.12 171.77,23.48 C676.2 ; v2(152.33,24.24) 153,24.24 153.4,24.65 CN8.1
NGFF_SATA_DET: length 94.7
  TOP w0.102: v1(31.3,4.69) 29.4,6.59 R495.1 ; v1(47.79,10.93) 47.79,11.34 48.27,11.82 51.13,11.82 51.61,12.3 51.61,14.45 52.69,15.53 52.69,17.94 53.17,18.43 53.17,20.44 53.38,20.64 53.38,22.97 v1(52.54,23.81) 52.26,24.09 52.26,24.94 53.05,25.73 54.8,25.73 54.94,25.87 60.3,25.87 61.23,26.79 61.23,28.05 60.29,28.99 60.29,44.84 60.54,45.09 R253.2 60.95,45.09 61.48,44.56 62.08,44.56 62.18,44.46 62.34,44.46 62.65,44.16 64.04,44.16 64.2,44.31 69.35,44.31 70.08,43.59 70.08,43.27 70.43,42.91 71.05,42.91 72.58,44.44 72.58,44.94 73.47,45.83 74.99,45.83 76.52,47.36 76.93,47.36 77.28,47.01 77.28,46.62 77.07,46.42 v2(77.07,46.32)
  IN3 w0.089: v1(47.79,10.93) 47.28,10.43 47.28,10.03 46.91,9.67 43.95,9.67 42.87,8.58 41.51,8.58 39.52,6.59 39.52,6.14 38.48,5.1 37.83,5.1 37.36,4.63 33.01,4.63 32.45,5.19 31.81,5.19 v1(31.3,4.69)
  BOTTOM w0.102: U24.CR43 77.35,45.14 76.97,45.52 76.97,46.21 v2(77.07,46.32)
NTC1N_R: length 33.9
  TOP w0.203: PR58.1 143.68,51.67 v1(144.21,51.67)
  IN1 w0.102: v1(144.21,51.67) 144.18,51.67 143.58,52.27 143.58,52.37 142.21,53.75 142.21,54.67 140.71,56.18 140.71,57.28 140.71,57.29 140.71,57.95 137.64,61.01 134.61,61.01 131.68,63.94 131.68,66.58 128.84,69.43 124.6,69.43 v1(124.55,69.48)
  BOTTOM w0.178: v1(124.55,69.48) 124.55,69.28 123.82,68.55 PR161.1
  BOTTOM w0.254: v1(144.21,51.67) 144.08,51.79 PR190.2
NV_PLLVDD: length 13.2
  TOP w0.254: C105.2 98.09,101.67 v2(97.95,101.67) 97.4,102.22 v1(97.29,102.22) 96.81,102.22 94.7,104.33 93.71,104.33 91.5,106.54 89.72,106.54 89.46,106.28 C68.2 88.72,106.03 L2.2
  BOTTOM w0.254: U22.L6 v2(97.95,101.67)
ODD_PRSNT#: length 82
  TOP w0.079: v2(87.64,37.55) 88.71,37.55 89.13,37.13 89.13,36.14 89.24,36.03 89.64,36.03 89.88,35.8 89.88,35.38 90.53,34.73 90.53,33.93 90.87,33.59 91.73,33.59
  TOP w0.102: 91.73,33.59 92.44,33.59 92.76,33.26 R306.2 93.28,32.49 93.28,30.85 94.25,29.88 94.25,29.12 94.58,28.79 95.59,28.79 96.35,28.03 96.35,27.55 v1(95.51,26.7) 95.44,26.63 95.44,24.45 95.34,24.34 94.33,24.34 92.9,22.92 92.9,22.19 v1(92.92,22.16)
  BOTTOM w0.079: v2(87.64,37.55) 87.93,37.55 U24.DK21
  BOTTOM w0.102: v1(92.92,22.16) 92.9,22.13 92.9,21.35 94.5,19.75 94.5,16.45 96.61,14.34 113.5,14.34 114.14,14.97 118.4,14.97 119.04,14.34 125.05,14.34 125.32,14.6 125.32,15.74 125.87,16.29 127.43,16.29 127.74,15.99 137.17,15.99 137.59,16.41 138.61,16.41 138.85,16.65 138.85,17.67 139.52,18.34 C703.1 140.05,19.7 R812.2
ODD_PRSNT#_C: length 10.8
  BOTTOM w0.102: R812.1 140.15,20.15 140,20.3 R806.1 C699.1 138.49,19.7 138.28,19.48 138.28,19.02 137.18,17.93 137.18,16.96 136.71,16.5 133.79,16.5 133.35,16.94 CN15.8
PBA_FP_PWREN#: length 164.9
  TOP w0.102: R418.1 51.9,20.82 50.99,19.9 50.99,17.39 v2(50.94,17.33) ; U13.76 198.18,20.18 197.76,19.77 v2(197.75,19.77)
  IN2 w0.089: v2(50.94,17.33) 53.9,17.33 56.3,14.94 57.35,14.94 58.38,15.97 60.57,15.97 62.03,14.51 73.2,14.51 75.03,12.69 81.16,12.69 84.09,9.75 87.92,9.75 88.01,9.84 88.43,9.84 93.38,14.79 109.76,14.79 110.42,15.45 112.42,15.45 114.3,17.33 121.4,17.33 122.37,18.3 128.1,18.3 128.59,17.82 137.21,17.82 137.68,18.29 142.98,18.29 143.47,17.79 150.57,17.79 151.08,18.3 154.88,18.3 155.06,18.48 156.97,18.48 157.58,17.87 160.7,17.87 161.05,18.22 171.69,18.22 172.4,18.93 173.92,18.93 174.07,19.08 178.86,19.08 179.3,19.52 180.41,19.52 180.83,19.09 185.95,19.09 186.61,18.43 187.47,18.43 187.71,18.2 188.21,18.2 188.42,18.41 188.81,18.41 189.42,19.01 190.37,19.01 191.55,17.83 192.99,17.83 193.73,18.57 195.57,18.57 196.04,18.1 196.66,18.1 197.29,18.73 197.29,19.31 v2(197.75,19.77)
PBA_PWR:
  vias: v1(48.8,21.58)
PBA_PWR_C:
  vias: v1(55.45,20.83)
PBA_PWR_R: length 4.5
  TOP w0.508: v1(52.26,19.95) 52.16,19.95 51.65,19.44 51.65,17.16 51.14,16.65 50.48,16.65 50.46,16.67
  vias: v1(49.34,16.24)
PCBEEP_EC: length 70.5
  TOP w0.102: v1(186.35,9.74) 187.03,10.43 v2(187.03,10.96) 187.03,10.98 186.98,11.04 186.98,12.71 186.73,12.97 185.66,12.97 185.25,13.38 U13.34
  IN1 w0.089: v2(197.19,28.7) 197.34,28.7 198.49,27.55 200.64,27.55 201.03,27.15 202.59,27.15 202.81,27.37 203.97,27.37 204.05,27.29 204.74,27.29 205.37,26.66 205.37,25.82 205.6,25.59 205.93,25.59 206.03,25.49 206.72,25.49 207.52,24.68 208.47,24.68 209.27,23.88 211.75,23.88 212.66,22.97 212.66,19.16 213.17,18.66 213.17,15.2 213.65,14.72 213.65,10.83 213.19,10.37 213.19,9.97 212.94,9.71 211.33,9.71 211.24,9.8 v1(211.24,9.94)
  BOTTOM w0.102: v1(211.24,9.94) 210.94,9.64 188.35,9.64 v2(187.03,10.96) ; D35.2 195.24,32.26 195.51,31.99 195.51,29.91 195.62,29.81 195.95,29.81 197.05,28.7 v2(197.19,28.7)
PCBEEP_EC_C: length 15
  TOP w0.102: v2(199.53,28.71) 199.53,28.97 v1(199.08,29.41)
  IN3 w0.089: v2(199.53,28.71) 199.53,28.61 199.23,28.31 198.63,28.31 198.38,28.56 198.38,28.74 197.14,29.98 197.14,33.82 v2(197.01,33.95)
  BOTTOM w0.102: C660.2 200.16,27.93 199.53,28.56 v2(199.53,28.71) ; C648.2 196.6,30.22 196.26,30.56 R718.2 196,31.83 R707.1 196.69,31.85 C638.2 197.16,33.8 v2(197.01,33.95)
PCH_AZ_CODEC_BITCLK: length 205.9
  IN1 w0.089: v2(204.1,22.8) 204.15,22.74 204.15,19.44 203.87,19.16 203.87,17.38 204.71,16.55 204.71,11.31 204.15,10.76 192.49,10.76 191.73,11.52 190.41,11.52 190,11.92 190,12.74 189.59,13.15 187.47,13.15 187.13,12.81 187.13,11.92 186.62,11.42 185.2,11.42 181.93,14.69 117.93,14.69 117.32,15.3 110.45,15.3 109.85,14.69 93.45,14.69 92.47,13.71 92.47,13.07 92.28,12.89 92.28,12.63 89.23,9.59 88.98,9.59 88.67,9.27 88.23,9.27 88.13,9.18 84.11,9.18 83.59,9.7 82.79,9.7 79.7,12.79 75.17,12.79 73.53,14.43 70.88,14.43 70.6,14.72 65.97,14.72 61.09,19.61 59.87,19.61 58.58,20.9 58.58,21.9 57.07,23.4 56.08,23.4 v2(55.37,24.12)
  BOTTOM w0.102: U30.6 204.86,27.04 204.27,26.45 204.27,26.15 C667.2 204.17,25.78 203.9,25.51 203.9,23.38 204.1,23.18 v2(204.1,22.8) ; R687.1 65.11,38.11 64.98,37.98 63.92,37.98 62.94,37 62.94,31.09 63.78,30.25 64,30.25 64.2,30.05 64.2,28.31 v1(62.86,26.97) 61.53,25.64 57.88,25.64 57.67,25.43 56.32,25.43 55.99,25.11 55.79,25.11 55.37,24.68 v2(55.37,24.12)
PCH_AZ_CODEC_RST#: length 215.8
  IN1 w0.089: v2(53.08,25.18) 53.08,24.79 53.74,24.13 53.74,23.48 55.18,22.04 55.18,21.5 56.12,20.56 56.81,20.56 58.88,18.49 60.62,18.49 65.61,13.5 70.23,13.5 71.17,12.56 73.82,12.56 74.71,11.67 79.23,11.67 82.32,8.58 83.13,8.58 83.64,8.06 88.6,8.06 88.69,8.15 89.13,8.15 89.44,8.47 89.87,8.47 93.18,11.78 93.18,11.95 93.4,12.17 93.4,12.42 93.58,12.61 93.58,13.24 93.91,13.58 113.35,13.58 113.96,14.18 116.85,14.18 117.47,13.57 181.46,13.57 185.39,9.64 205.07,9.64 206.21,10.78 207.33,10.78 208.21,11.67 208.21,13.58 207.45,14.34 207.45,16.75 207.33,16.88 207.33,18.4 206.64,19.09 v2(206.64,19.67)
  BOTTOM w0.102: v2(53.08,25.18) 53.08,24.92 53.38,24.62 54.61,24.62 55.58,25.59 55.79,25.59 56.12,25.91 57.47,25.91 57.68,26.12 61.33,26.12 63.51,28.3 63.51,29.22 63.28,29.45 63.28,30.06 62.46,30.89 62.46,37.2 63.73,38.48 64.71,38.48 64.83,38.59 65.47,38.59 65.72,38.85 R684.1 ; R782.2 198.94,24.28 198.94,22.8 199.21,22.53 Q45.1 199.21,20.9 201.38,18.73 204.23,18.73 204.89,19.39 v1(205.01,19.39) 206.28,19.39 206.56,19.67 v2(206.64,19.67)
PCH_AZ_CODEC_SDIN0: length 217.8
  IN1 w0.089: v2(204.71,22.9) 204.71,21.75 204.84,21.63 204.84,17.16 205.2,16.79 205.2,10.99 204.49,10.29 185.66,10.29 181.73,14.22 117.74,14.22 117.12,14.83 113.66,14.83 113.05,14.22 93.65,14.22 92.94,13.51 92.94,12.88 92.75,12.69 92.75,12.44 89.43,9.12 89.18,9.12 88.86,8.8 88.42,8.8 88.33,8.71 83.91,8.71 83.39,9.23 82.59,9.23 79.5,12.32 74.97,12.32 73.33,13.96 70.69,13.96 70.4,14.25 65.78,14.25 60.89,19.14 59.67,19.14 58.11,20.7 58.11,21.7 57.4,22.41 55.73,22.41 54.41,23.73 v2(54.41,25.31)
  IN3 w0.089: v2(204.71,22.9) 204.71,23.1 204.43,23.38 204.43,24.6 204.02,25 204.02,26.2 v2(203.24,26.99)
  BOTTOM w0.079: U24.CV45 76.07,43.1 75.63,42.66 75.63,42.4 75.46,42.24 74.06,42.24 73.75,41.93 73.3,41.93 73.21,42.02 72.98,42.02 72.89,41.93
  BOTTOM w0.102: 72.89,41.93 71.27,40.32 68.77,40.32 68.06,39.61 66.89,39.61 66.51,39.23 65.7,39.23 65.3,38.82 64.74,38.82 64.62,38.7 63.64,38.7 62.23,37.3 62.23,30.79 63.05,29.97 63.05,29.36 63.28,29.13 63.28,28.4 61.23,26.35 57.58,26.35 57.37,26.14 56.02,26.14 55.7,25.82 55.43,25.82 54.93,25.31 v2(54.41,25.31) ; v2(203.24,26.99) 203.26,27.01 R751.2
PCH_AZ_CODEC_SDIN0_R: length 2.1
  BOTTOM w0.102: R751.1 203.46,27.87 204.06,28.47 U30.8
PCH_AZ_CODEC_SDOUT: length 209.2
  TOP w0.102: v1(206.46,22.24) 206.08,21.86 v2(206.08,21.75)
  IN1 w0.089: v2(54.53,26.36) 54.53,26.01 54.03,25.51 54.03,24.55 54.18,24.41 54.18,23.65 55.68,22.16 55.68,21.61 56.12,21.17 57.01,21.17 59.26,18.92 60.8,18.92 65.69,14.03 70.31,14.03 70.6,13.75 73.24,13.75 74.89,12.1 79.41,12.1 82.5,9.01 83.3,9.01 83.82,8.5 88.42,8.5 88.51,8.59 88.95,8.59 89.27,8.9 89.69,8.9 92.75,11.96 92.75,12.13 92.97,12.35 92.97,12.6 93.15,12.79 93.15,13.42 93.74,14.01 113.14,14.01 113.75,14.62 117.03,14.62 117.65,14 181.64,14 185.57,10.07 204.79,10.07 205.45,10.73 205.45,11.21 205.9,11.67 205.9,12.15 206.31,12.56 206.31,15.35 206.73,15.77 206.73,16.68 206.42,16.99 206.42,17.65 205.94,18.13 205.94,20.65 206.08,20.79 v2(206.08,21.75)
  BOTTOM w0.102: v2(206.08,21.75) 206.08,22.97 205.5,23.56 205.5,25.21 205.34,25.36 205.34,28.33 205.26,28.42 U30.5 ; R683.1 64.61,39.34 64.43,39.16 63.45,39.16 61.77,37.49 61.77,30.6 62.6,29.78 62.6,29.17 62.83,28.94 62.83,28.59 61.04,26.81 57.39,26.81 57.18,26.6 55.83,26.6 55.52,26.29 54.61,26.29 v2(54.53,26.36)
