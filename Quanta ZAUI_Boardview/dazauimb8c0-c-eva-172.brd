# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXP13_SSD_C: length 7.1
  TOP w0.102: C485.2 35.39,8.85 35.39,7.94 36.05,7.28 36.05,6.81 v1(35.77,6.53)
  BOTTOM w0.102: v1(35.77,6.53) 36.04,6.79 36.04,7.51 36.33,7.8 36.66,7.8 36.99,8.13 36.99,8.33 36.85,8.47 CN18.13
PCIE_TXP14_SSD: length 95
  TOP w0.102: v1(35.35,13.6) 35.52,13.42 35.52,13.05 34.06,11.58 34.06,11.43 33.35,10.72 33.35,10.42 C483.1
  IN3 w0.089: v1(35.35,13.6) 35.53,13.42 35.53,13.24 35.8,12.97 36.31,12.97 36.71,13.37 38.25,13.37 40.02,15.15 40.5,15.15 42.35,17 42.35,19.76 42,20.11 42,21.91 43.88,23.79 44.44,23.79 47.31,26.66 47.66,26.66 49.01,28 50,28 51.88,29.88 52.93,29.88 52.98,29.83 54.67,29.83 55.26,30.42 57.47,30.42 57.95,30.9 62.16,30.9 62.37,31.1 64.24,31.1 64.44,30.9 66.1,30.9 68.72,33.51 70.37,33.51 71,34.15 71.6,34.15 71.85,34.4 74.61,34.4 75.55,35.34 76.21,35.34 76.36,35.19 77.05,35.19 77.53,35.67 77.91,35.67 78.42,36.18 78.52,36.18 79.11,36.77 79.11,38.7 79.01,38.8 79.01,39.13 79.23,39.36 79.83,39.36 80.81,40.34 81.22,40.34 82.95,42.07 83.36,42.07 85.95,44.66 91.87,44.66 92.15,44.39 92.6,44.39 92.8,44.18 93.23,44.18 94.13,43.28 95.38,43.28 95.45,43.34 95.9,43.34 96.46,43.9 100.7,43.9 101.27,44.47 101.27,44.8 v2(101.48,45.02)
  BOTTOM w0.079: v2(101.48,45.02) 101.28,44.81 101.28,44.64 100.83,44.19 98.14,44.19 U24.CT1
PCIE_TXP14_SSD_C: length 4.3
  TOP w0.102: v1(33.71,7.71) 33.99,7.99 33.99,8.22 33.36,8.86 33.36,9.13 33.24,9.25 C483.2
  BOTTOM w0.102: v1(33.71,7.71) 33.99,7.99 33.99,8.38 33.85,8.52 CN18.25
PCIE_TXP15_SSD: length 107.2
  TOP w0.102: C481.1 30.94,10.43 30.94,10.97 31.32,11.35 32.33,11.35 32.87,11.89 32.87,13.18 32.61,13.43 32.61,14.25 33.13,14.77 35.95,14.77 36.33,14.39 36.33,14.24 36.73,13.84 37.51,13.84 37.6,13.93 37.6,14.18 v2(37.37,14.4)
  IN3 w0.089: v2(37.37,14.4) 37.37,15.45 37.26,15.56 34.22,15.56 32.57,17.2 32.57,22.16 33.41,23 38.54,23 40.68,25.13 44.13,25.13 45.27,26.28 45.27,26.56 45.85,27.14 46.26,27.14 46.7,27.57 47.15,27.57 48.56,28.99 49.82,28.99 51.55,30.72 54.21,30.72 55.28,31.79 60.91,31.79 61.62,32.5 66.55,32.5 68.38,34.33 69.86,34.33 71.28,35.75 73.76,35.75 76.06,38.04 76.06,38.14 76.36,38.44 76.76,38.44 76.88,38.56 76.88,39.06 77.13,39.31 77.13,39.33 77.16,39.37 77.16,39.68 77.13,39.72 77.13,40.15 77.49,40.52 78.03,40.52 78.23,40.32 78.46,40.32 78.69,40.54 79.22,40.54 79.23,40.53 79.84,40.53 80.22,40.91 80.22,41.95 80.6,42.33 81.84,42.33 82,42.49 82,42.97 82.62,43.59 83.57,43.59 85.46,45.48 91.49,45.48 92.23,46.21 92.9,46.21 93.26,45.85 93.26,45.48 94.3,44.44 95.29,44.44 95.35,44.51 96.02,44.51 96.21,44.7 99.23,44.7 99.33,44.8 99.33,44.91 v2(99.15,45.09)
  BOTTOM w0.079: v2(99.15,45.09) 99.15,44.82 99.06,44.73 97.79,44.73 97.57,44.96 96.94,44.96 96.65,44.67 U24.CR4
PCIE_TXP15_SSD_C: length 4.2
  TOP w0.102: v1(30.71,7.58) 30.99,7.86 30.99,8.17 30.94,8.22 30.94,8.85 C481.2
  BOTTOM w0.102: v1(30.71,7.58) 30.99,7.86 30.99,8.38 30.85,8.52 CN18.37
PCIE_TXP16_SSD: length 100.4
  TOP w0.102: C487.1 27.88,9.77 27.96,9.85 27.96,10.24 28.94,11.21 29.55,11.21 31.04,12.7 31.04,13.74 32.29,15 32.29,15.98 v1(32.07,16.21)
  IN3 w0.089: v1(32.07,16.21) 32.07,16.21 32.07,16.84 31.96,16.95 31.96,22.41 33.16,23.61 37.11,23.61 40.9,27.39 43.85,27.39 45.5,29.04 47.75,29.04 48.49,29.78 49.71,29.78 51.82,31.89 54.46,31.89 54.99,32.42 60.39,32.42 61.07,33.11 66.3,33.11 67.04,33.85 67.04,34.47 67.66,35.09 69.77,35.09 71.32,36.64 73.01,36.64 73.24,36.88 73.9,36.88 75.12,38.09 75.12,38.81 75.65,39.34 75.65,40.25 76.8,41.39 77.14,41.39 77.24,41.49 78.07,41.49 78.16,41.39 78.59,41.39 78.59,41.39 79.33,41.39 79.49,41.55 79.49,41.56 79.55,41.62 79.55,42.22 80.77,43.45 81.46,43.45 82.54,44.52 82.54,44.77 82.88,45.12 83.97,45.12 84.94,46.09 90.91,46.09 92.23,47.41 93.14,47.41 93.91,46.63 93.91,45.71 94.23,45.39 95.25,45.39 95.32,45.46 96.19,45.46 96.33,45.33 97.44,45.33 97.79,45.68 99.72,45.68 99.8,45.76 99.8,45.88 v2(99.61,46.07)
  BOTTOM w0.079: v2(99.61,46.07) 99.83,45.85 99.83,45.73 99.78,45.68 98.03,45.68 97.58,45.23 U24.CP2
PCIE_TXP16_SSD_C: length 3.7
  TOP w0.102: C487.2 28.02,8.59 28.02,8.39 27.99,8.36 27.99,7.99 v1(27.71,7.71)
  BOTTOM w0.102: CN18.49 27.85,8.77 27.99,8.63 27.99,7.99 v1(27.71,7.71)
PCIE_WAKE#: length 299.5
  TOP w0.102: v2(75.78,36.36) 75.78,36.21 74.1,34.53 74.1,33.77 73.72,33.39 71.58,33.39 70.18,31.99 69.67,31.99 67.66,29.98 67.66,29.59 67.27,29.2 67.27,25.6 68.01,24.86 R406.1 68.01,23.3 68.39,22.92 68.39,21.7 v1(67.88,21.2) 67.75,21.07 67.47,21.07 66.48,22.06 66.48,22.45 v1(66.03,22.91) 65.99,22.95 64.35,22.95 63.91,22.52 56.98,22.52 56.48,23.02 v2(56.48,24.01) ; U1.21 47.29,105.6 47.33,105.55 49.43,105.55 49.73,105.85 50.15,105.85 50.61,106.31 v2(50.94,106.31)
  IN2 w0.089: v1(25.6,61.72) 25.85,61.48 25.85,50.51 25.28,49.95 24.8,49.95 24.4,49.54 24.4,48.93 24.58,48.75 25.05,48.75 26,47.8 26,43.36 25.23,42.6 25.23,36.45 25.63,36.05 27.08,36.05 30.64,32.49 37.03,32.49 38.52,31 39.49,31 39.92,30.57 43.71,30.57 44.7,29.57 44.7,28.06 45.93,26.83 48.88,26.83 49.08,27.04 49.72,27.04 53.4,23.35 55.81,23.35 v2(56.48,24.01) ; v1(67.88,21.2) 68.58,20.49 73.78,20.49 74.34,19.93 76.26,19.93 77.07,19.12 79.37,19.12 83.5,23.25 89.33,23.25 91.21,21.37 92.53,21.37 93.37,20.53 96.35,20.53 97.29,21.47 104.07,21.47 104.15,21.4 111.66,21.4 112.84,22.57 115.58,22.57 116.08,23.07 118.01,23.07 119.11,24.18 121.46,24.18 121.82,23.82 122.24,23.82 122.5,24.08 126.49,24.08 127.51,25.11 134.67,25.11 134.79,25.23 137.41,25.23 137.79,24.85 141.92,24.85 143.67,23.11 155.9,23.11 156.17,23.38 164.73,23.38 165.57,22.53 170,22.53 170.37,22.91 175.26,22.91 175.6,22.57 v2(175.86,22.57)
  IN3 w0.089: v2(50.94,106.31) 50.16,107.09 44.67,107.09 42.23,104.64 42.23,103.75 40.6,102.12 38.19,102.12 36.13,100.06 31.23,100.06 28.26,97.09 28.26,93.92 26.35,92.01 26.35,90.92 25.46,90.02 25.46,89.39 22.28,86.22 22.28,77.59 23.66,76.21 23.66,74.56 26.44,71.78 26.44,68.91 27.36,67.99 27.36,63.91 27.18,63.73 27.18,63.31 25.82,61.96 25.82,61.94 v1(25.6,61.72)
  BOTTOM w0.102: U24.DL45 76.27,36.81 75.87,36.4 75.82,36.4 75.79,36.38 75.78,36.38 75.78,36.38 v2(75.78,36.36) ; Q46.3 179.81,17.92 179.11,18.63 179.11,19.26 180.33,20.49 EC9.1 180.18,20.79 176.34,20.79 176.01,21.12 176.01,22.41 v2(175.86,22.57)
PD#: length 33
  TOP w0.102: C377.1 210.34,30.53 210.63,30.82 213.37,30.82 v1(213.63,30.57) 213.88,30.31 215.5,30.31 216.01,29.81 216.01,27.72 214.49,26.2 214.49,25.72 212.43,23.66 208.65,23.66 206.77,25.54 205.52,25.54 205.14,25.92 v2(203.55,25.92) ; C377.1 210.17,30.39 v1(209.61,29.83) ; C377.1 210.26,30.31 R355.1 210.26,28.82 210.43,28.66 R364.1
  BOTTOM w0.102: U30.47 208.24,30.82 208.41,30.66 208.41,30.49 209.06,29.83 v1(209.61,29.83) ; v2(203.55,25.92) 203.24,25.92 203.02,25.7 D36.2 202.91,25.16 202.13,24.38 D37.2
PEDET: length 5.7
  TOP w0.102: v1(22.67,10.15) 22.51,9.99 R491.2
  TOP w0.381: 23.3,8.27 23.33,8.24 23.46,8.24 23.95,8.74 Q27.2 ; 23.3,8.27 v1(23.3,8.32) ; 23.3,8.27 23.28,8.24 R492.2 22.68,8.84 22.51,9.01 R491.2
  BOTTOM w0.254: CN18.69 22.85,8.44 23.05,8.24 23.28,8.24 23.3,8.26 23.3,8.29 23.3,8.29 v1(23.3,8.32)
PEG_RXN5: length 100.8
  TOP w0.102: v1(90.87,108.19) 91.08,108.41 92.28,108.41 93.88,110.01 96.59,110.01 96.79,110.21 97.35,110.21 C40.1
  IN1 w0.089: v2(95.65,42.02) 95.39,41.76 95.39,41.58 95.18,41.38 93.22,41.38 93.08,41.52 92.1,41.52 90.03,43.59 90.03,49.45 90.66,50.08 90.66,50.87 91.27,51.48 91.27,54.05 91.81,54.58 91.81,56.6 92.01,56.81 92.01,59.75 91.93,59.83 91.93,60.37 92.01,60.45 92.01,67.39 91.27,68.13 91.27,70.82 90.51,71.58 90.51,73 90.36,73.16 90.36,74.97 90.51,75.13 90.51,77.21 90.79,77.49 90.79,80.34 90.41,80.72 90.41,81.56 90.23,81.74 90.23,82.29 89.36,83.16 89.36,84.6 89.27,84.69 89.16,84.69 88.95,84.9 88.95,85.28 89.16,85.49 89.27,85.49 89.36,85.58 89.36,85.8 89.27,85.89 88.75,85.89 88.54,86.09 88.54,86.48 88.75,86.69 89.27,86.69 89.36,86.77 89.36,87.28 89.27,87.37 89.07,87.37 88.86,87.58 88.86,87.96 89.07,88.17 89.27,88.17 89.36,88.26 89.36,88.54 90.33,89.51 90.33,95.36 90.22,95.46 89.11,95.46 88.76,95.82 88.76,96.68 89.17,97.09 89.89,97.09 90.33,97.52 90.33,97.99 90.24,98.08 88.79,98.08 88.58,98.29 88.58,98.67 88.79,98.88 90.2,98.88 90.33,99.01 90.33,99.55 90.15,99.73 89.06,99.73 88.85,99.94 88.85,100.36 89.06,100.57 90.07,100.57 90.17,100.67 90.17,101.42 90.08,101.51 88.55,101.51 88.34,101.72 88.34,102.27 88.55,102.48 90.08,102.48 90.17,102.56 90.17,102.67 90.74,103.24 90.74,104.34 90.65,104.43 89.77,104.43 89.52,104.68 89.52,105.1 89.73,105.31 90.19,105.31 90.28,105.4 90.28,105.69 90.19,105.78 89.77,105.78 89.52,106.03 89.52,106.41 89.73,106.62 90.49,106.62 90.67,106.79 91.12,106.79 91.35,107.02 91.35,108.26 91.25,108.37 91.04,108.37 v1(90.87,108.19)
  BOTTOM w0.102: U24.DA6 95.38,41.75 v2(95.65,42.02)
PEG_RXN5_C: length 3.8
  TOP w0.102: v2(100.49,110.81) 100.19,111.11 99.95,111.11 99.82,111.24 99.48,111.24 99.22,110.98 99.22,110.44 99,110.22 98.61,110.22 98.5,110.1 C40.2
  BOTTOM w0.102: U22.AB9 v2(100.49,110.81)
PEG_RXN6: length 96.9
  TOP w0.102: C9.1 101.43,120.03 101.43,120.95 101.08,121.3 100.6,121.3 100.06,120.76 99.5,120.76 98.62,119.88 97.42,119.88 97.27,119.73 97.27,119.19 97.39,119.06 97.56,119.06 v1(97.72,119.23)
  IN1 w0.089: v1(97.72,119.23) 97.53,119.42 97.37,119.42 97.24,119.29 97.24,118.6 96.23,117.59 94.46,117.59 93.51,116.64 93.51,115.04 92.9,114.43 92.9,112.18 92.16,111.44 92.16,106.4 91.55,105.79 91.55,102.89 90.97,102.31 90.97,100.21 91.25,99.94 91.25,93.12 91.13,93 91.13,89.16 90.17,88.21 90.17,83.48 90.43,83.22 91.07,83.22 91.41,82.88 91.41,80.85 92.09,80.18 92.09,68.85 93.25,67.69 93.25,63.41 93.74,62.93 93.74,60.21 93.38,59.85 93.38,54.7 92.82,54.14 92.54,54.14 92.09,53.68 92.09,51.14 91.46,50.52 91.46,49.75 90.84,49.13 90.84,44.61 91.9,43.55 93.26,43.55 93.65,43.16 93.65,43.07 94.19,42.53 95.16,42.53 95.29,42.66 95.29,42.81 95.19,42.91 v2(95.04,42.91)
  BOTTOM w0.102: v2(95.04,42.91) 95.13,42.81 95.13,42.66 94.94,42.46 94.76,42.46 U24.CY7
PEG_RXN6_C: length 9.3
  TOP w0.102: v2(102.12,111.62) 102.27,111.62 102.33,111.68 102.33,112.04 101.66,112.71 101.66,116.67 101.46,116.88 101.46,117.61 101.83,117.98 101.83,118.36 101.34,118.85 C9.2
  BOTTOM w0.102: U22.AC10 101.77,111.17 101.99,111.17 102.14,111.33 102.14,111.59 v2(102.12,111.62)
PEG_RXN7: length 97
  TOP w0.102: C4.1 103.02,121.53 102.77,121.79 102.77,122.5 102.88,122.62 v1(103.07,122.62)
  IN1 w0.089: v1(103.07,122.62) 102.83,122.62 102.72,122.51 102.72,122.16 102.46,121.91 102.01,121.91 101.12,122.8 100.04,122.8 98.44,121.19 98.44,118.39 98.01,117.97 97.45,117.97 96.18,116.7 94.55,116.7 94.17,116.32 94.17,112.38 92.77,110.98 92.77,106.1 92.15,105.47 92.15,102.63 91.58,102.06 91.58,100.67 91.86,100.39 91.86,92.74 91.72,92.61 91.72,88.9 90.79,87.96 90.79,84.42 92.28,82.93 92.28,82.6 92.7,82.19 92.7,69.11 93.99,67.81 93.99,63.61 94.4,63.21 94.4,60.01 93.99,59.6 93.99,52.67 93.33,52.01 93.33,51.5 92.06,50.23 92.06,49.5 91.49,48.93 91.49,45.16 92.03,44.61 92.63,44.61 92.86,44.39 93.31,44.39 94.21,43.48 95.19,43.48 95.29,43.58 95.29,43.72 95.15,43.86 v2(95.04,43.86)
  BOTTOM w0.079: U24.CV7 94.97,43.4 95.13,43.57 95.13,43.76 v2(95.04,43.86)
PEG_RXN7_C: length 10.5
  TOP w0.102: C4.2 103.11,120.68 103.11,120.13 102.79,119.81 102.79,115.95 103.59,115.15 103.59,112.91 103.39,112.71 103.39,112.3 102.97,111.88 v2(102.97,111.64)
  BOTTOM w0.102: U22.AC11 102.96,111.64 v2(102.97,111.64)
PEG_RXN8: length 99.8
  TOP w0.102: C12.1 104.09,119.87 104.09,120.6 104.48,120.99 104.48,121.8 v1(104.72,122.03)
  IN1 w0.089: v1(104.72,122.03) 104.53,122.22 104.53,122.43 104.22,122.74 103.76,122.74 103.19,122.16 103.19,121.72 102.97,121.5 99.6,121.5 98.87,120.76 98.87,118.22 98.21,117.56 97.62,117.56 95.59,115.54 95.59,114.5 94.58,113.48 94.58,110.69 93.18,109.29 93.18,105.75 92.54,105.11 92.54,102.45 91.97,101.88 91.97,100.96 92.26,100.66 92.26,92.58 92.12,92.43 92.12,88.61 91.2,87.69 91.2,84.59 92.81,82.97 92.81,82.65 93.69,81.77 93.69,76.5 93.51,76.32 93.51,73.05 93.96,72.6 95.18,72.6 95.52,72.27 95.52,70.46 96.25,69.73 96.25,69.18 96.02,68.96 96.02,68.08 96.25,67.85 96.25,63.57 95.59,62.91 95.59,53.36 93.79,51.56 93.79,49.8 93.14,49.16 92.28,49.16 91.88,48.77 91.88,46.18 92.05,46.01 92.69,46.01 92.95,45.75 92.95,45.49 94.21,44.23 95.32,44.23 95.55,44.47 95.55,44.73 v2(95.7,44.88)
  BOTTOM w0.102: U24.CT6 95.7,44.64 v2(95.7,44.88)
PEG_RXN8_C: length 9.3
  TOP w0.102: v2(103.8,110.82) 104.2,111.23 104.2,111.92 104.42,112.14 104.42,115.62 103.93,116.11 103.93,117.9 104.25,118.22 104.25,118.53 104.33,118.6 C12.2
  BOTTOM w0.102: v2(103.8,110.82) 103.39,110.42 U22.AB12
PEG_RXP5: length 100.8
  TOP w0.102: C36.1 97.72,110.52 97.62,110.43 96.7,110.43 96.5,110.22 93.79,110.22 92.19,108.62 90.94,108.62 90.87,108.7 v2(90.87,108.88)
  IN1 w0.089: v2(90.87,108.88) 90.87,108.7 90.99,108.57 91.33,108.57 91.55,108.35 91.55,106.94 91.21,106.59 90.75,106.59 90.58,106.42 89.81,106.42 89.72,106.33 89.72,106.11 89.86,105.98 90.28,105.98 90.49,105.77 90.49,105.31 90.28,105.1 89.81,105.1 89.72,105.02 89.72,104.76 89.85,104.63 90.74,104.63 90.94,104.43 90.94,103.15 90.37,102.58 90.37,102.48 90.16,102.27 88.63,102.27 88.54,102.18 88.54,101.8 88.63,101.71 90.16,101.71 90.37,101.51 90.37,100.58 90.16,100.37 89.14,100.37 89.05,100.28 89.05,100.02 89.14,99.94 90.23,99.94 90.53,99.64 90.53,98.92 90.28,98.68 88.87,98.68 88.78,98.59 88.78,98.37 88.87,98.28 90.32,98.28 90.53,98.08 90.53,97.44 89.98,96.89 89.25,96.89 88.96,96.6 88.96,95.9 89.2,95.67 90.31,95.67 90.53,95.45 90.53,89.43 89.56,88.46 89.56,88.17 89.35,87.97 89.15,87.97 89.06,87.88 89.06,87.66 89.15,87.57 89.35,87.57 89.56,87.37 89.56,86.69 89.35,86.48 88.83,86.48 88.74,86.39 88.74,86.18 88.83,86.09 89.35,86.09 89.56,85.88 89.56,85.5 89.35,85.29 89.24,85.29 89.15,85.2 89.15,84.98 89.24,84.9 89.35,84.9 89.56,84.69 89.56,83.25 90.43,82.37 90.43,81.83 90.61,81.65 90.61,80.81 90.99,80.42 90.99,77.41 90.71,77.13 90.71,75.04 90.56,74.89 90.56,73.24 90.71,73.09 90.71,71.66 91.48,70.9 91.48,68.21 92.21,67.47 92.21,60.36 92.14,60.29 92.14,59.91 92.21,59.84 92.21,56.72 92.01,56.52 92.01,54.49 91.48,53.96 91.48,51.4 90.87,50.79 90.87,50 90.23,49.36 90.23,43.67 92.19,41.72 93.16,41.72 93.3,41.58 95.1,41.58 95.19,41.67 95.19,41.79 v2(95.03,41.95)
  BOTTOM w0.102: v2(95.03,41.95) 95.03,41.87 U24.DA7
PEG_RXP5_C: length 3.8
  TOP w0.102: C36.2 98.5,110.53 98.6,110.43 98.91,110.43 99.01,110.53 99.01,111.07 99.39,111.45 99.91,111.45 100.04,111.33 100.2,111.33 v2(100.49,111.62)
  BOTTOM w0.102: v2(100.49,111.62) 100.88,111.23 U22.AC9
PEG_RXP6: length 96.9
  TOP w0.102: v1(96.84,119.24) 97.05,119.46 97.05,119.82 97.33,120.1 98.53,120.1 99.41,120.98 99.97,120.98 100.51,121.51 101.17,121.51 101.64,121.04 101.64,120.03 C10.1
  IN1 w0.089: v2(95.65,42.97) 95.49,42.81 95.49,42.57 95.24,42.33 94.11,42.33 93.45,42.99 93.45,43.07 93.17,43.35 91.82,43.35 90.64,44.53 90.64,49.21 91.26,49.84 91.26,50.6 91.88,51.23 91.88,53.77 92.46,54.34 92.74,54.34 93.18,54.78 93.18,59.94 93.53,60.29 93.53,62.84 93.05,63.33 93.05,67.6 91.88,68.77 91.88,80.09 91.21,80.76 91.21,82.79 90.99,83.02 90.35,83.02 89.97,83.4 89.97,88.3 90.92,89.25 90.92,93.08 91.04,93.2 91.04,99.85 90.77,100.13 90.77,102.4 91.35,102.98 91.35,105.87 91.96,106.49 91.96,111.53 92.7,112.26 92.7,114.51 93.31,115.12 93.31,116.72 94.37,117.79 96.14,117.79 97.04,118.69 97.04,119.04 v1(96.84,119.24)
  BOTTOM w0.102: U24.CY6 95.65,42.76 v2(95.65,42.97)
PEG_RXP6_C: length 9.3
  TOP w0.102: C10.2 102.04,117.89 101.67,117.52 101.67,116.97 101.88,116.76 101.88,112.8 102.55,112.13 102.55,111.47 102.13,111.04 v2(102.13,110.78)
  BOTTOM w0.102: v2(102.13,110.78) 102.1,110.78 U22.AB10
PEG_RXP7: length 97
  TOP w0.102: C3.1 102.55,121.91 102.55,122.39 v1(102.32,122.62)
  IN1 w0.089: v2(95.65,43.93) 95.49,43.77 95.49,43.5 95.27,43.28 94.12,43.28 93.22,44.18 92.77,44.18 92.54,44.41 91.95,44.41 91.28,45.07 91.28,49.01 91.86,49.59 91.86,50.31 93.13,51.58 93.13,52.09 93.79,52.75 93.79,59.68 94.19,60.09 94.19,63.12 93.79,63.53 93.79,67.73 92.49,69.02 92.49,82.1 92.08,82.52 92.08,82.84 90.59,84.33 90.59,88.05 91.52,88.98 91.52,92.69 91.65,92.82 91.65,100.31 91.37,100.59 91.37,102.14 91.94,102.71 91.94,105.56 92.57,106.18 92.57,111.07 93.97,112.47 93.97,116.4 94.47,116.9 96.1,116.9 97.37,118.17 97.93,118.17 98.23,118.48 98.23,121.27 99.96,123 101.2,123 102.09,122.11 102.38,122.11 102.52,122.25 102.52,122.42 v1(102.32,122.62)
  BOTTOM w0.079: v2(95.65,43.93) 95.65,43.67 U24.CV6
PEG_RXP7_C: length 10.4
  TOP w0.102: v2(102.94,112.44) 103.11,112.44 103.17,112.5 103.17,112.8 103.38,113 103.38,115.06 102.57,115.86 102.57,119.9 102.89,120.22 102.89,120.34 102.75,120.48 102.75,120.66 102.66,120.75 C3.2
  BOTTOM w0.102: U22.AD11 102.84,112.03 102.94,112.13 v2(102.94,112.44)
PEG_RXP8: length 99.8
  TOP w0.102: v1(103.94,122.03) 104.13,122.03 104.27,121.89 104.27,121.08 103.87,120.69 103.87,119.54 103.75,119.42 103.53,119.42 C11.1
  IN1 w0.089: v2(95.06,44.81) 95.27,44.81 95.35,44.73 95.35,44.55 95.24,44.44 94.3,44.44 93.15,45.58 93.15,45.83 92.77,46.21 92.14,46.21 92.08,46.27 92.08,48.68 92.36,48.96 93.23,48.96 93.99,49.72 93.99,51.47 95.79,53.28 95.79,62.83 96.45,63.49 96.45,67.93 96.23,68.16 96.23,68.87 96.45,69.1 96.45,69.81 95.72,70.55 95.72,72.35 95.26,72.81 94.04,72.81 93.71,73.14 93.71,76.24 93.89,76.41 93.89,81.86 93.01,82.73 93.01,83.06 91.4,84.67 91.4,87.61 92.32,88.53 92.32,92.35 92.47,92.49 92.47,100.75 92.18,101.04 92.18,101.79 92.74,102.36 92.74,105.03 93.38,105.67 93.38,109.21 94.78,110.6 94.78,113.4 95.79,114.41 95.79,115.45 97.7,117.36 98.29,117.36 99.07,118.14 99.07,120.68 99.69,121.3 103.06,121.3 103.39,121.63 103.39,122.08 103.85,122.53 104.14,122.53 104.33,122.34 104.33,122.13 104.23,122.03 v1(103.94,122.03)
  BOTTOM w0.102: v2(95.06,44.81) 95.15,44.72 95.15,44.51 94.96,44.32 U24.CT7
PEG_RXP8_C: length 9.2
  TOP w0.102: C11.2 103.83,118.85 103.9,118.78 103.9,118.59 104.04,118.46 104.04,118.31 103.71,117.99 103.71,116.02 104.2,115.53 104.2,112.23 103.99,112.01 103.99,111.71 103.9,111.62 v2(103.8,111.62)
  BOTTOM w0.102: U22.AC12 103.41,111.21 103.67,111.21 103.84,111.39 103.84,111.57 v2(103.8,111.62)
PEG_TXN5: length 95.7
  IN1 w0.089: v1(103.85,37.1) 104.04,37.29 104.04,37.36 103.87,37.53 103.33,37.53 102.55,38.31 102.55,40.32 101.99,40.88 101.99,42.78 101.89,42.88 101.89,45.53 100.9,46.52 100.05,46.52 99.62,46.96 99.62,47.08 99.16,47.53 98.53,47.53 97.39,48.67 97.39,52.35 96.89,52.86 96.89,63.32 97.29,63.72 97.29,69.62 96.18,70.74 96.18,73.05 96.02,73.21 96.02,73.86 96.3,74.14 96.3,75.7 95.62,76.38 95.62,77.35 94.3,78.68 94.3,82.03 93.41,82.92 93.41,83.37 92.26,84.51 92.26,87.78 92.71,88.23 92.71,92.09 92.87,92.25 92.87,96.97 93.14,97.23 93.14,104.79 93.81,105.47 93.81,108.99 95.21,110.38 95.21,113.23 96.43,114.45 96.43,115.15 97.78,116.5 98.49,116.5 v2(98.66,116.67)
  BOTTOM w0.102: v2(98.66,116.67) 98.82,116.51 99.18,116.51 99.43,116.27 99.43,115.63 98.98,115.19 98.98,114.68 U22.AG7 ; v1(103.85,37.1) 104.07,36.87 104.07,36.78 103.95,36.65 103.48,36.65 102.23,35.4 102.16,35.4 C630.1
PEG_TXN5_C: length 8.9
  BOTTOM w0.079: U24.DE4 96.68,39.72 96.96,40 97.2,40 97.35,39.85 99.39,39.85 99.78,39.46 99.78,37.55 100.48,36.85 100.48,36.12 100.61,36 100.61,35.71 100.94,35.38 101.14,35.38 C630.2
PEG_TXN6: length 95.6
  IN1 w0.089: v2(98.84,113.22) 98.56,113.5 98.36,113.5 97.8,112.94 97.8,109.17 97.89,109.08 98.33,109.08 98.54,108.87 98.54,108.44 98.33,108.23 97.89,108.23 97.58,107.91 96.82,107.91 96.71,107.8 96.71,107.55 96.82,107.43 97.11,107.43 97.32,107.22 97.32,106.79 97.11,106.58 96.77,106.58 96.71,106.52 96.71,104.85 95.78,103.93 95.78,102.16 96.38,101.56 96.38,97.22 95.79,96.63 95.79,91.71 95.13,91.04 95.13,85.84 95.4,85.57 95.4,83.78 96.91,82.27 96.91,81.4 97.83,80.49 97.83,77.35 98.44,76.74 98.44,72.4 99.33,71.51 99.33,65.65 99.73,65.24 100.99,65.24 101.2,65.03 101.2,64.64 100.99,64.44 100.15,64.44 100.01,64.3 100.01,50.95 103.04,47.92 105.32,47.92 105.52,47.71 105.52,46.19 105.37,46.04 105.37,43.39 106.44,42.33 106.44,38.29 106.03,37.88 104.36,37.88 104.07,38.17 104.07,38.29 v1(103.82,38.54)
  BOTTOM w0.102: C625.1 102.09,36.99 102.42,36.99 102.56,37.13 102.56,37.39 102.97,37.79 103.91,37.79 104.1,37.98 104.1,38.26 v1(103.82,38.54) ; v2(98.84,113.22) 98.87,113.19 98.87,113.19 U22.AE7
PEG_TXN6_C: length 6.8
  BOTTOM w0.079: U24.DD1 98.14,40.19 99.53,40.19 100.13,39.59 100.13,37.72 100.99,36.86 101.11,36.86 101.19,36.94 101.19,37.45 101.27,37.53 101.39,37.53 101.44,37.48 C625.2
PEG_TXN7: length 91.2
  IN1 w0.089: v2(100.49,114.06) 100.24,113.8 100.16,113.8 99.91,114.06 99.82,114.06 99.21,114.67 98.38,114.67 96.51,112.8 96.51,109.06 95.77,108.33 95.77,105.28 94.96,104.46 94.96,100.56 95.44,100.08 95.44,97.73 94.96,97.25 94.96,92.32 94.33,91.7 94.33,85.51 94.6,85.24 94.6,83.44 96.11,81.93 96.11,80.76 96.99,79.89 96.99,77.02 97.62,76.38 97.62,71.96 97.9,71.68 97.9,70.92 98.51,70.31 98.51,65.28 98.92,64.87 98.92,50.8 102.64,47.08 103.59,47.08 104.18,46.49 104.18,43.45 105.6,42.02 105.6,39.48 105.33,39.22 104.32,39.22 104.24,39.29 104.24,39.44 v1(104.46,39.66)
  BOTTOM w0.102: v1(104.46,39.66) 104.16,39.37 104.16,39.22 103.94,38.99 102.88,38.99 102.73,38.85 102.73,38.53 102.43,38.24 102.17,38.24 C621.2 ; U22.AF9 100.91,113.64 v2(100.49,114.06)
PEG_TXN7_C: length 6.6
  BOTTOM w0.079: C621.1 101.28,37.96 101.15,38.09 101.15,38.36 101.2,38.41 101.2,38.91 101.13,38.99 100.78,38.99 100.34,39.42 100.34,39.66 99.57,40.43 98.42,40.43 98.08,40.56 97.97,40.56 97.82,40.51 97.65,40.51 97.45,40.59 97.35,40.59 97.23,40.52 97.1,40.39 96.87,40.39 U24.DD3
PEG_TXN8: length 91
  IN1 w0.089: v1(103.82,40.75) 104,40.93 104,41.17 103.91,41.26 102.9,41.26 102.6,41.56 102.6,43.12 102.5,43.22 102.5,45.77 102.37,45.9 102.37,46.49 100.48,48.39 99.25,48.39 98.21,49.43 98.21,52.43 97.65,52.99 97.65,63.21 97.9,63.47 97.9,69.93 97.29,70.54 97.29,71.22 97.01,71.5 97.01,76.11 96.35,76.77 96.35,77.8 95.9,78.26 95.9,78.69 94.91,79.67 94.91,82.27 94,83.18 94,84.6 92.9,85.7 92.9,87.55 93.31,87.96 93.31,91.8 93.72,92.21 93.72,92.82 93.97,93.06 93.97,98.39 94.32,98.75 94.32,102.47 93.73,103.06 93.73,104.46 95.03,105.76 95.03,108.58 95.87,109.42 95.87,113.02 98.26,115.4 99.86,115.4 99.99,115.53 v2(99.99,115.78)
  BOTTOM w0.102: v2(99.99,115.78) 100.2,115.57 100.96,115.57 101.55,114.98 101.55,114.59 U22.AG10 ; C614.2 102.24,39.9 102.51,39.9 102.92,40.31 103.9,40.31 103.99,40.4 103.99,40.59 v1(103.82,40.75)
PEG_TXN8_C: length 6.4
  BOTTOM w0.079: C614.1 101.44,40.55 101.36,40.63 101.23,40.63 101.15,40.55 101.15,40.12 101.07,40.03 100.7,40.03 99.7,41.03 99.23,41.03 98.73,41.53 98.4,41.53 98.16,41.37 97.97,41.37 97.81,41.43 97.64,41.43 97.5,41.34 97.32,41.34 97.19,41.43 96.83,41.43 96.75,41.51 U24.DA3
PEG_TXP5: length 95.7
  IN1 w0.089: v2(98.66,116.04) 98.66,116.22 98.59,116.29 97.86,116.29 96.64,115.07 96.64,114.37 95.41,113.14 95.41,110.3 94.02,108.9 94.02,105.39 93.34,104.71 93.34,97.15 93.08,96.89 93.08,92.16 92.92,92 92.92,88.14 92.47,87.69 92.47,84.59 93.61,83.45 93.61,83 94.5,82.11 94.5,78.76 95.82,77.44 95.82,76.47 96.51,75.78 96.51,74.05 96.23,73.77 96.23,73.29 96.38,73.14 96.38,70.83 97.5,69.71 97.5,63.64 97.09,63.23 97.09,52.95 97.6,52.44 97.6,48.75 98.61,47.74 99.25,47.74 99.82,47.17 99.82,47.04 100.14,46.72 100.98,46.72 102.09,45.61 102.09,42.96 102.2,42.86 102.2,40.96 102.75,40.41 102.75,38.39 103.41,37.73 103.96,37.73 104.24,37.45 104.24,37.34 v1(104.48,37.1)
  BOTTOM w0.102: U22.AG6 98.58,114.43 98.77,114.62 98.77,115.28 99.21,115.72 99.21,116.18 99.09,116.3 98.82,116.3 98.66,116.14 v2(98.66,116.04) ; C631.1 102.16,35.18 102.32,35.18 103.57,36.44 104.04,36.44 104.29,36.69 104.29,36.89 104.47,37.07 v1(104.48,37.1)
PEG_TXP5_C: length 8.9
  BOTTOM w0.079: C631.2 101.14,35.21 100.87,35.21 100.44,35.64 100.44,35.93 100.32,36.05 100.32,36.78 99.61,37.48 99.61,39.39 99.32,39.68 97.56,39.68 97.27,39.39 96.94,39.39 96.85,39.48 96.85,39.65 96.92,39.72 U24.DE3
PEG_TXP6: length 95.7
  IN1 w0.089: v2(98.84,114.02) 98.51,113.7 98.28,113.7 97.6,113.02 97.6,109.08 97.81,108.88 98.25,108.88 98.33,108.79 98.33,108.52 98.25,108.43 97.81,108.43 97.49,108.12 96.74,108.12 96.51,107.89 96.51,107.46 96.74,107.23 97.03,107.23 97.12,107.14 97.12,106.87 97.03,106.78 96.69,106.78 96.51,106.6 96.51,104.94 95.58,104.01 95.58,102.07 96.18,101.48 96.18,97.3 95.59,96.72 95.59,91.79 94.93,91.12 94.93,85.76 95.2,85.49 95.2,83.69 96.71,82.18 96.71,81.32 97.62,80.4 97.62,77.27 98.23,76.66 98.23,72.32 99.12,71.43 99.12,65.56 99.65,65.03 100.91,65.03 101,64.94 101,64.73 100.91,64.64 100.06,64.64 99.81,64.38 99.81,50.86 102.96,47.71 105.23,47.71 105.32,47.62 105.32,46.27 105.17,46.12 105.17,43.31 106.23,42.24 106.23,38.37 105.95,38.09 104.44,38.09 104.28,38.25 104.28,38.37 v1(104.46,38.54)
  BOTTOM w0.102: C628.1 102.23,36.78 102.51,36.78 102.78,37.04 102.78,37.3 103.06,37.58 104,37.58 104.32,37.9 104.32,38.4 v1(104.46,38.54) ; v2(98.84,114.02) U22.AF7
PEG_TXP6_C: length 6.8
  BOTTOM w0.079: C628.2 101.27,36.44 101.19,36.51 101.19,36.61 101.11,36.69 100.92,36.69 99.96,37.65 99.96,39.53 99.46,40.03 97.89,40.03 97.64,40.28 U24.DD2
PEG_TXP7: length 91.2
  IN1 w0.089: v1(103.82,39.66) 104.04,39.44 104.04,39.21 104.23,39.01 105.42,39.01 105.8,39.4 105.8,42.11 104.38,43.53 104.38,46.58 103.68,47.28 102.73,47.28 99.12,50.89 99.12,64.96 98.72,65.37 98.72,70.39 98.11,71 98.11,71.77 97.83,72.05 97.83,76.47 97.19,77.1 97.19,79.97 96.31,80.85 96.31,82.02 94.8,83.53 94.8,85.32 94.53,85.6 94.53,91.61 95.16,92.24 95.16,97.17 95.64,97.65 95.64,100.16 95.16,100.65 95.16,104.38 95.97,105.19 95.97,108.24 96.71,108.98 96.71,112.71 98.46,114.46 99.13,114.46 99.74,113.85 99.83,113.85 100.08,113.6 100.32,113.6 100.49,113.42 v2(100.49,113.25)
  BOTTOM w0.102: C618.2 102.15,38.45 102.34,38.45 102.51,38.62 102.51,38.94 102.79,39.21 103.85,39.21 103.95,39.31 103.95,39.53 v1(103.82,39.66) ; U22.AE9 v2(100.49,113.25)
PEG_TXP7_C: length 6.6
  BOTTOM w0.079: C618.1 101.44,38.91 101.2,39.15 100.85,39.15 100.51,39.49 100.51,39.73 99.64,40.6 98.45,40.6 98.12,40.73 97.94,40.73 97.8,40.68 97.68,40.68 97.48,40.76 97.31,40.76 97.08,40.64 97,40.56 96.64,40.56 96.36,40.28 U24.DD5
PEG_TXP8: length 91
  IN1 w0.089: v2(99.99,115.05) 99.83,115.2 98.34,115.2 96.07,112.93 96.07,109.33 95.24,108.49 95.24,105.68 93.94,104.38 93.94,103.14 94.52,102.55 94.52,98.67 94.17,98.31 94.17,92.98 93.93,92.73 93.93,92.12 93.51,91.71 93.51,87.88 93.1,87.46 93.1,85.79 94.21,84.68 94.21,83.27 95.12,82.36 95.12,79.76 96.1,78.78 96.1,78.35 96.56,77.89 96.56,76.85 97.22,76.19 97.22,71.59 97.5,71.31 97.5,70.62 98.11,70.01 98.11,63.38 97.85,63.13 97.85,53.07 98.41,52.51 98.41,49.52 99.33,48.59 100.56,48.59 102.58,46.58 102.58,45.99 102.7,45.86 102.7,43.3 102.8,43.2 102.8,41.64 102.98,41.46 103.99,41.46 104.2,41.26 104.2,40.88 104.33,40.75 v1(104.46,40.75)
  BOTTOM w0.102: v1(104.46,40.75) 104.2,40.5 104.2,40.31 103.99,40.09 103.01,40.09 102.6,39.68 102.08,39.68 C617.2 ; v2(99.99,115.05) 99.99,115.28 100.06,115.35 100.87,115.35 101.33,114.9 101.33,114.51 101.26,114.43 U22.AG9
PEG_TXP8_C: length 6.4
  BOTTOM w0.079: C617.1 101.33,39.48 100.95,39.86 100.63,39.86 99.63,40.87 99.16,40.87 98.67,41.36 98.45,41.36 98.21,41.2 97.94,41.2 97.77,41.27 97.69,41.27 97.54,41.17 97.27,41.17 97.14,41.26 96.71,41.26 96.34,41.63 U24.DA5
PEGX_RST#: length 7.5
  TOP w0.102: v1(104.02,124.19) 103.59,124.62 R1.2
  BOTTOM w0.102: R506.1 R503.2 100.65,124.58 101.13,125.06 102.53,125.06 102.64,125.17 R502.1 103.05,125.49 103.19,125.36 103.19,125.34 v1(103.69,124.83) 104.02,124.5 v1(104.02,124.19)
PEGX_RST#_C: length 2.7
  BOTTOM w0.102: v1(99.68,122.46) 99.88,122.66 R506.2 99.76,123.3 98.73,124.33 U19.4
PEX_CLKREQ#: length 38.3
  TOP w0.102: v1(94.17,110.88) 91.58,110.88 89.01,108.32 87.16,108.32 86.42,107.58 86.42,106.92 85.63,106.13 85.63,103.82 85.02,103.21 85.02,99.55 86.04,98.54 v1(86.04,98.41)
  IN2 w0.089: v1(84.52,93.46) 85.02,93.97 85.28,93.97 85.55,94.24 85.55,97.92 v1(86.04,98.41)
  BOTTOM w0.102: v1(84.52,93.46) 84.74,93.68 R542.2 84.62,94.21 84.62,94.87 R537.1 85.04,95.46 v1(84.29,95.46) 84.19,95.46 83.12,94.4 83.12,92.52 83.95,91.69 Q31.1 ; v1(94.17,110.88) 94.78,110.88 94.91,110.76 97.95,110.76 U22.AC6
PEX_TERMP: length 7.3
  BOTTOM w0.102: v1(116.67,119.44) 117.08,119.04 117.08,118.1 116.82,117.83 R511.2 116.65,116.83 114.49,114.67 114.49,113.99 U22.AF25
PEX_TSTCLK: length 6.3
  BOTTOM w0.102: U22.AF22 112.2,114.2 112.2,114.81 113.46,116.06 114.49,116.06 115.16,116.73 115.16,117.45 115.03,117.58 R512.2
PEX_TSTCLK#: length 7.2
  BOTTOM w0.102: U22.AE22 112.08,113.28 112.08,113.81 112.39,114.12 112.39,114.73 113.54,115.87 114.57,115.87 115.35,116.65 115.35,117.43 115.48,117.56 R512.1
PINSET_TSEN: length 10.1
  TOP w0.178: PR47.1 141.39,60.21 141.49,60.31 143,60.31 143.52,59.79 v1(143.52,59.68) 143.29,59.45 143.29,58.05 v1(141.42,56.17)
  BOTTOM w0.178: 142.03,56.02 141.87,56.17 v1(141.42,56.17) 140.85,56.17 140.59,56.44 PR177.1
  BOTTOM w0.203: 142.03,56.02 142.3,56.02 142.57,55.75 PR181.2
PIRQA#: length 117.2
  TOP w0.102: R400.1 121.99,24.21 v2(122.01,24.19)
  IN2 w0.089: v2(53.91,26.4) 53.27,25.77 52.98,25.77 52.64,25.42 52.64,25.02 54.05,23.61 55.46,23.61 56.6,24.75 59.73,24.75 60.41,25.44 62.77,25.44 63.12,25.09 63.12,24.03 62.88,23.79 62.88,23.47 64.39,21.96 65.74,21.96 66.12,22.34 71.64,22.34 72.27,21.7 73.94,21.7 75.01,20.64 76.36,20.64 77.31,19.69 79.13,19.69 83.7,24.26 83.7,24.62 83.97,24.89 87.51,24.89 87.96,24.45 89.49,24.45 90.57,23.37 90.75,23.37 90.99,23.13 90.99,22.47 91.12,22.34 91.83,22.34 93.43,20.74 96.28,20.74 97.22,21.68 111.67,21.68 112.76,22.76 114.86,22.76 116.19,24.09 118.76,24.09 119.04,24.37 121.55,24.37 121.73,24.19 v2(122.01,24.19)
  BOTTOM w0.079: 68.64,42.38 70.12,42.38 71.02,43.28 72.28,43.28 73.29,44.28 74.26,44.28 U24.CT49
  BOTTOM w0.102: 68.64,42.38 65.59,42.38 65.01,41.8 R671.2 64.21,41.8 63.52,41.11 62.7,41.11 60.6,39.01 60.6,29 59.8,28.21 57.16,28.21 56.27,27.32 55.87,27.32 55.33,26.78 54.29,26.78 v2(53.91,26.4)
PLTRST#: length 468.4
  TOP w0.102: U1.19 47.51,104.8 48.02,104.28 v1(48.02,104.23) ; v1(29.53,3.42) 29.4,3.54 R497.2 ; v1(95.92,121.3) 94.85,120.23 94.85,117.46 93.33,115.94 92.14,115.94 90.23,114.03 90.23,111.21 88.61,109.59 87.85,109.59 v1(87.27,109.01) 85.91,107.65 85.91,107.05 85.23,106.36 85.23,104 84.54,103.31 84.54,98.82 v1(84.49,98.77) ; R398.1 122.42,24.72 122.34,24.8 118.86,24.8 118.09,24.04 115.05,24.04 113.09,22.08 113.09,20.82 111.49,19.22 111.49,16.9 110.78,16.19 v1(110.76,16.19)
  IN1 w0.089: v1(29.53,3.42) 30.87,2.07 38.09,2.07 39.15,3.14 39.15,5.63 41.74,8.22 44.23,8.22 v1(46.11,10.1) 46.16,10.15 46.16,10.5 49.19,13.52 53.15,13.52 53.53,13.14 55.36,13.14 55.56,13.35 55.56,16.86 53.38,19.05 53.38,19.57 51.6,21.35 51.6,23.09 50.95,23.74 50.42,23.74 48.93,25.23 48.93,26.07 v1(49.31,26.45) 48.93,26.83 48.93,27.39 44.96,31.36 44.96,31.74 42.74,33.96 36.21,33.96 35.42,34.75 31.15,34.75 27.14,38.76 27.14,39.75 27.01,39.88 27.01,56.52 27.82,57.34 27.82,62.7 27.21,63.31 27.21,64.32 27.83,64.94 27.83,65.24 29.04,66.46 v2(29.27,66.46) ; v2(55.54,27.57) 55.54,26.2 56.83,24.9 57.52,24.9 57.91,24.51 57.91,23.79 59.44,22.26 59.44,21.26 60.22,20.47 61.52,20.47 66.02,15.98 70.63,15.98 71.18,15.43 74.29,15.43 74.74,14.97 80.2,14.97 80.66,14.51 80.66,13.05 83.14,10.56 84.03,10.56 84.55,10.04 87.78,10.04 87.87,10.14 88.31,10.14 88.62,10.45 88.88,10.45 91.42,12.99 91.42,13.25 91.6,13.43 91.6,14.07 93.09,15.56 109.38,15.56 109.99,16.17 110.73,16.17 v1(110.76,16.19) 110.78,16.17 117.68,16.17 118.29,15.55 177.3,15.55 178.57,16.83 181.8,16.83 184.45,14.18 192.51,14.18 193.53,15.2 193.53,15.71 v2(193.65,15.82) ; v1(48.02,104.23) 48.47,104.68 48.78,104.68 51.35,107.26 54.28,107.26 54.98,106.56 54.98,106.16 55.88,105.25 58,105.25 58.16,105.08 59.75,105.08 62.1,102.73 62.98,102.73 63.41,102.3 63.41,101.94 62.75,101.28 62.75,100.93 63.03,100.65 66.31,100.65 66.37,100.71 82.55,100.71 v1(84.49,98.77)
  IN3 w0.089: v2(29.27,66.46) 29.07,66.46 28.62,66.91 28.62,72.08 25.47,75.23 25.47,76.34 23.54,78.26 23.54,84.08 24.87,85.41 24.87,86.82 25.66,87.62 26.86,87.62 27.95,88.71 27.95,91.44 29.57,93.07 29.57,95.39 32.33,98.16 42.48,98.16 44.39,100.06 45.32,100.06 v1(45.88,100.62)
  BOTTOM w0.079: 68.64,42.79 69.91,42.79 70.19,43.06 70.19,43.57 70.42,43.8 70.42,44.4 71.45,45.43 71.72,45.43 72.46,46.17 74.62,46.17 U24.CM49
  BOTTOM w0.102: CN17.2 46.45,10.69 46.11,10.35 v1(46.11,10.1) ; v1(49.31,26.45) 49.31,26.88 50.81,28.38 51.73,28.38 52.92,27.19 55.01,27.19 55.39,27.57 v2(55.54,27.57) 55.69,27.72 56.1,27.72 56.99,28.61 59.64,28.61 60.2,29.17 60.2,39.85 62.32,41.97 63.17,41.97 63.94,42.75 R662.1 64.12,43.19 64.53,42.79 68.64,42.79 ; v1(95.92,121.3) 96.23,121.3 96.77,121.84 96.77,122.37 97.24,122.84 97.24,123.53 97.09,123.68 U19.2 ; v1(48.02,104.23) 48.02,100.9 47.64,100.52 45.99,100.52 v1(45.88,100.62) ; v2(193.65,15.82) 193.66,15.81 193.66,15.48 193.28,15.1 R832.1 192.95,14.8 193.15,14.59 193.56,14.59 193.86,14.9 194.68,14.9 194.88,15.1 194.88,16.19 194.68,16.39 194.68,16.76 194.91,16.99 195.12,16.99 195.44,17.31 195.44,18.48 194.94,18.99 194.2,18.99 193.85,19.34 R819.2
PLTRST#_EC: length 4.4
  TOP w0.102: U13.22 181.71,19.78 v1(181.66,19.84) C437.1 181.22,18.45 180.52,18.45 180.22,18.15 R441.2
PM_EXTTS#0: length 2.3
  BOTTOM w0.102: R615.2 60.42,63.11 60.01,62.7 JDIM1.134
PM_THRMTRIP#: length 42.1
  TOP w0.102: Q11.1 111.7,64.69 v1(111.7,63.71) R196.1 111.92,62.72 112.15,62.95 112.15,64.04 113.52,65.41 113.52,66.33 v1(113.85,66.66)
  IN2 w0.089: v1(113.85,66.66) 113.41,67.1 113.41,77.14 110.04,80.51 110.04,80.53 109.03,81.55 106.21,81.55 105.34,82.41 v1(105.07,82.41)
  BOTTOM w0.079: 98.86,80.26 98.49,79.88 98.49,79.62 98.14,79.27 97.56,79.27 97.28,78.99 U24.E3
  BOTTOM w0.102: 98.86,80.26 98.98,80.38 98.98,81.66 100.85,83.53 102.17,83.53 102.55,83.15 R584.1 102.55,83.38 102.73,83.55 103.41,83.55 103.67,83.81 104.38,83.81 105.07,83.12 v1(105.07,82.41)
PMON: length 43
  TOP w0.203: v2(138.72,32.88) 138.72,32.83 138.08,32.19 v1(138.08,32.15) 137.87,32.36 137.87,32.36 137.35,32.88 PR76.1 137.1,32.62 137.23,32.49 PC77.2
  IN3 w0.089: v1(141.7,51.2) 141.7,51.46 142.02,51.78 142.91,51.78 143.6,51.09 143.6,50.23 142.86,49.49 135.93,49.49 135.32,48.88 135.32,48.58 136.43,47.46 138.39,47.46 138.97,46.87 139.46,46.87 140.6,45.73 140.6,44.82 140.04,44.26 140.04,39.84 139.42,39.22 136.77,39.22 135.77,38.22 135.77,36.08 136.54,35.31 136.54,34.73 137.12,34.15 138.01,34.15 138.72,33.44 v2(138.72,32.88)
  BOTTOM w0.203: PR195.1 141.83,51.33 v1(141.7,51.2) ; v2(138.72,32.88) 137.8,31.96 PR251.1
PP: length 2
  TOP w0.102: R423.2 v1(129.45,20.56) 129.35,20.56 129,20.21 U15.4
PROCHOT#_CPU: length 5
  BOTTOM w0.079: 97.17,80.76 97.17,80.45 96.79,80.08 U24.C3
  BOTTOM w0.102: R583.2 98.29,82.59 97.72,82.03 97.72,81.65 97.47,81.39 97.47,81.32 97.17,81.02 97.17,80.76
PROCHOT_EC: length 11.1
  TOP w0.102: Q20.2 v1(176.49,16.89) 177.17,16.89 177.61,17.33 R440.2 C440.2 178.99,18.17 178.99,18.92 179.41,19.34 179.41,20.19 180.52,21.29 180.99,21.29 181.35,21.65 182,21.65 182.13,21.78 U13.17
PROCPWRGD: length 4.4
  BOTTOM w0.079: 100.64,50.6 99.37,49.33 98.66,49.33 98.52,49.19 98.2,49.19 U24.CF1
  BOTTOM w0.102: C726.2 R643.2 100.7,50.66 100.64,50.6
PS_FB_CLAMP: length 5.9
  BOTTOM w0.102: R528.1 91.25,98.16 92.75,96.66 95.46,96.66 U22.F3
PTP_PWR_EN#: length 1.6
  TOP w0.102: U13.125 186.05,30.79 185.76,31.08 TP35.1
PULSAR_38P4M_REFCLK: length 4
  BOTTOM w0.102: CN9.64 191.55,15.38 192.75,14.18 193.91,14.18 TP99.1
PWM-VID: length 41.8
  TOP w0.102: v1(72.17,113.45) PR22.1
  IN1 w0.089: v1(89.11,89.06) 89.6,89.55 89.6,89.67 89.86,89.93 89.86,94.25 89.6,94.5 89.11,94.5 88,95.62 88,99.48 83.41,104.07 77.21,104.07 76.64,104.63 75.88,104.63 75.15,105.36 75.15,105.49 73.51,107.14 73.51,107.72 73.05,108.18 72.58,108.18 72.55,108.21 70.63,108.21 70.15,108.69 70.15,112.57 71,113.42 72.15,113.42 v1(72.17,113.45)
  BOTTOM w0.102: v1(89.11,89.06) 89.11,89.2 89.84,89.92 R551.1
PWR_GATE#: length 45.3
  TOP w0.102: v1(70.09,12.31) 70.09,12 70.19,11.9 72.8,11.9 74.41,13.51 74.41,14.45 75.8,15.84 76.65,15.84 77.35,16.55 77.35,19.24 76.24,20.36 76.24,21.65 75.91,21.98 75.91,23.57 76.3,23.96 76.48,23.96 77.19,24.67 v1(77.43,24.67) ; v1(56.2,12.05) 56.75,12.61 56.75,13.85 57.11,14.21 R473.1
  IN3 w0.089: v1(56.2,12.05) 56.9,12.76 58.04,12.76 59.23,11.57 61.94,11.57 62.04,11.67 69.02,11.67 69.53,12.18 69.96,12.18 v1(70.09,12.31)
  BOTTOM w0.102: R776.2 81.21,25.22 79.92,23.93 79.92,23.38 78.75,22.21 v1(78.18,22.21) 77.61,22.21 77.4,22.41 77.4,24.6 77.43,24.62 v1(77.43,24.67)
PWRLED#: length 52
  TOP w0.102: v2(192.52,22.29) 192.14,22.67 189.4,22.67 186.28,19.54 184.48,19.54 183.92,18.98 U13.24
  IN1 w0.089: v2(212.16,37.3) 212.43,37.3 216.09,33.64 216.09,32.24 215.61,31.76 215.61,30.36 215.03,29.79 215.03,26.05 213.08,24.1 209.32,24.1 208.55,24.87 207.61,24.87 206.79,25.69 206.21,25.69 205.93,25.97 v2(205.78,25.97)
  IN2 w0.089: v2(192.52,22.29) 193.74,22.29 194.13,22.67 195.31,22.67 195.7,22.29 196.73,22.29 197.39,22.95 197.67,22.95 199.14,24.42 200.96,24.42 201.1,24.28 201.56,24.28 202.72,25.44 203.65,25.44 204.36,26.15 205.6,26.15 v2(205.78,25.97)
  BOTTOM w0.102: v2(212.16,37.3) 212.26,37.4 CN6.22
R_SPK+: length 103.6
  TOP w1.016: v1(183.58,14.65) 182.15,14.65 181.44,15.35 119.75,15.35 119.19,15.91
  IN3 w1.016: 208.88,30.62 208.14,29.88 208.14,28.48 209.07,27.56 209.07,25.09 206.94,22.97 206.94,21.31 205.78,20.14 205.78,18.58 204.47,17.28 204.47,16.12 202.72,14.36 198.99,14.36 198.61,13.98 191.89,13.98 190.1,15.76 186.91,15.76 185.76,14.62 184.97,14.62
  vias: v1(209.23,31.08) v1(209.87,31.08) v2(184.44,15.4) v2(185.05,15.37)
R_SPK+_1:
  vias: v1(118.88,20.2) v1(118.86,19.57)
R_SPK-: length 109.7
  TOP w1.016: 117.69,15.15 118.81,14.03 180.87,14.03 181.65,13.24 182.48,13.24 184.44,11.29 184.97,11.29
  IN3 w1.016: 210.91,30.59 210.91,29.86 210.75,29.7 210.75,28.18 211.44,27.49 211.44,25.59 208.27,22.41 208.27,18.6 206.96,17.3 206.96,14.66 205.75,13.45 203.69,13.45 203.29,13.04 199.68,13.04 199.29,12.65 191.34,12.65 189.56,14.44 187.45,14.44 186.35,13.33
  vias: v1(186.14,11.72) v1(209,31.68) v1(209.69,31.71) v2(185.84,12.33) v2(186.42,12.33)
R_SPK-_1:
  vias: v1(117.92,20.23) v1(117.94,19.59)
RAM_ID0: length 11.6
  BOTTOM w0.102: U24.DK34 81.71,37.31 81.34,36.94 81.34,35.14 82.1,34.38 R730.2 82.22,29.46 82.61,29.07 82.61,28.36 82.41,28.15 82.41,26.84 R763.1
RAM_ID1: length 16.8
  TOP w0.102: R392.1 83.64,25.92 83.64,26.54 84.01,26.91 v1(84.59,26.91) 85.43,26.91 R385.2 85.61,26.74 85.61,27.32 85.86,27.57 85.86,28.09 85.63,28.33 84.61,28.33 83.63,29.32 83.63,30.45 82.69,31.39 82.69,33.56 82.5,33.76 82.5,34.31 82.85,34.66 82.85,35.89 82.62,36.12 82.62,36.71 v2(82.16,37.17)
  BOTTOM w0.102: v2(82.16,37.17) U24.DL34
RAM_ID2: length 8.8
  BOTTOM w0.079: 82.45,32 82.45,32.26 82.74,32.55 82.74,34.91 82.99,35.17 82.99,35.8 82.72,36.07 U24.DN33
  BOTTOM w0.102: R731.1 R732.2 83.75,29.84 83.75,30.69 82.45,32
RAM_ID3: length 14
  TOP w0.102: v2(82.99,36.37) 83.04,36.32 83.04,34.57 82.71,34.24 82.71,33.87 82.92,33.67 82.92,31.48 83.86,30.54 83.86,29.41 84.48,28.79 v1(85.05,28.79) 85.49,28.79 86.36,27.92 86.36,27.67 86.79,27.24 R376.2 87.26,26.7 87.26,25.92 87.35,25.83 R389.1
  BOTTOM w0.102: U24.DL33 82.65,36.72 82.97,36.4 82.97,36.38 82.98,36.37 v2(82.99,36.37)
REGN6V: length 12.5
  TOP w0.254: PR75.1 134.52,34.26 134.03,34.75 133.38,34.75 133.16,34.53 131.38,34.53 131.13,34.28 131.13,33.25 131.6,32.78 131.6,31.9 131.22,31.52 PC80.1 130.9,31.18 130.47,30.75 130.47,28.89 v1(130.36,28.79)
  BOTTOM w0.198: PU12.24 131.38,29.51
  BOTTOM w0.203: 131.38,29.51 131.23,29.51 130.52,28.79 v1(130.36,28.79)
REQ_WLAN#: length 13.3
  TOP w0.102: Q18.1 174.89,21.52 174.36,22.06 v2(174.36,22.13) ; v2(181.27,20.86) 181.23,20.82 v1(180.66,20.82)
  IN3 w0.089: v2(174.36,22.13) 174.36,21.98 175.13,21.21 178.78,21.21 179.16,20.83 181.24,20.83 v2(181.27,20.86)
  BOTTOM w0.102: CN9.53 182.48,18.13 182.21,18.4 182.21,19.59 181.78,20.02 R816.2 181.47,20.41 181.39,20.48 181.39,20.71 181.27,20.84 v2(181.27,20.86)
RF_EN: length 14.7
  TOP w0.102: v2(194.45,18.17) 194.45,17.94 194.61,17.78 195.25,17.78 195.7,17.33 196.6,17.33 196.83,17.55 197.22,17.55 197.42,17.35 197.42,16.45 197.14,16.17 197.14,15.34 197.55,14.93 197.55,13.19 v1(198.05,12.69) 197.32,11.95 R487.2
  BOTTOM w0.102: v2(194.45,18.17) 194.45,17.97 194.09,17.61 193.76,17.61 193.53,17.39 192.98,17.39 192.88,17.49 R828.1 192.34,17.77 192.09,17.51 191.6,17.51 191.47,17.38 CN9.56
RING2: length 25.3
  IN3 w1.016: 199.02,34.38 199.02,35.8 201.08,37.86 202.35,37.86 203.62,39.12 203.62,39.64 207.45,43.47 207.96,43.47 210.38,45.88 214.36,45.88 214.9,45.35
  BOTTOM w0.203: 200.9,32.03 U30.17
  BOTTOM w0.381: v1(198.51,32.7) 198.69,32.52 v1(199.12,32.52) 199.15,32.52 199.65,32.03 200.9,32.03
  vias: v1(214.6,44.61) v1(214.92,44.08) v1(215.24,44.63)
ROM_CS: length 1.8
  TOP w0.152: v2(103,95.04) 103.69,95.73 TP6.1
  BOTTOM w0.102: U22.D12 v2(103,95.04)
ROM_SCLK: length 7.2
  TOP w0.102: v2(102.97,94.21) 102.17,93.41 102.17,93.08 102.61,92.63 v2(102.67,92.63)
  BOTTOM w0.102: U22.C12 103.37,94.63 102.97,94.23 v2(102.97,94.21) ; R565.1 R552.2 104.08,90.02 102.8,91.3 102.8,92.49 v2(102.67,92.63)
ROM_SI: length 6.3
  BOTTOM w0.102: R566.1 R553.2 104.84,89.78 104.33,90.28 104.14,90.28 103.05,91.38 103.05,93.49 U22.B12
ROM_SO: length 7.4
  BOTTOM w0.102: R567.1 106.86,89 R554.2 107.64,90.15 107,90.79 105.09,90.79 103.39,92.49 U22.A12
RSET: length 5.6
  TOP w0.203: U1.31 43.64,108.17
  TOP w0.254: 43.64,108.17 43.24,108.57 42.73,108.57 42.51,108.79 42.51,110.9 v1(42.28,111.14) 42.91,111.77 R6.2
RSMRST#: length 263.4
  TOP w0.102: U13.112 191.25,29.09 190.63,28.47 190.54,28.47 189.82,27.75 189.57,27.75 188,26.17 188,25.94 v2(187.56,25.51) ; v2(72.45,38.85) 72.26,38.85 71.13,37.71 71.13,35.99 68.87,33.73 v1(68.87,32.85)
  IN1 w0.089: v2(72.45,38.85) 72.45,39.28 73.87,40.7 74,40.7 76.39,43.09 76.39,43.52 77.25,44.39 77.25,45.68 77.53,45.96 80.2,45.96 81.09,46.85 81.98,46.85 82.26,47.13 82.26,50.2 82.54,50.48 82.54,51.09 83.3,51.85 83.3,53.43 83.75,53.88 84.62,53.88 85.46,54.71 85.46,57.29 85.93,57.76 85.93,74.52 84.44,76 84.44,82.69 83.45,83.68 v1(83.45,84.44) ; v2(55.76,28.13) 55.76,27.98 55.94,27.8 55.94,26.35 56.99,25.3 57.68,25.3 58.3,24.68 58.3,23.95 59.83,22.42 59.83,21.42 60.32,20.93 61.62,20.93 66.18,16.37 70.9,16.37 71.39,15.88 74.16,15.88 74.69,16.41 79.86,16.41 81.13,15.14 81.13,13.14 83.31,10.96 84.2,10.96 84.71,10.44 87.61,10.44 88.02,10.84 88.71,10.84 91.02,13.15 91.02,14.04 91.32,14.34 91.32,15.25 92.98,16.9 95.13,16.9 95.26,16.78 101.38,16.78 102.13,16.03 108.56,16.03 109.38,16.85 111.01,16.85 111.3,16.56 117.94,16.56 118.55,15.94 177.13,15.94 178.41,17.22 181.96,17.22 184.61,14.57 189.4,14.57 190.79,15.96 190.79,19.24 190.05,19.98 190.05,22.06 187.56,24.55 v2(187.56,25.51)
  IN3 w0.089: v1(68.87,32.85) 68.87,32.5 66.76,30.39 65.99,30.39 65.88,30.28 65.11,30.28 64.77,29.93 64.41,29.93 64.07,30.28 63.23,30.28 63.1,30.4 58.12,30.4 57.66,29.95 57.05,29.95 55.76,28.66 v2(55.76,28.13)
  BOTTOM w0.079: U24.DG49 74.56,38.83 74.17,38.83 74.03,38.98 72.58,38.98 v2(72.45,38.85)
  BOTTOM w0.102: v1(83.45,84.44) 83.93,84.92 83.93,85.95 84.33,86.35 85.17,86.35 85.22,86.4 87.06,86.4 87.77,85.69 88.17,85.69 88.36,85.87 R573.1 89.17,85.87 89.2,85.9 Q32.3 ; v1(68.87,32.85) 67.6,32.85 67.12,32.37 R704.2 R709.2 66.96,31.26 67.12,31.1 68.16,31.1 R711.2
RT3612_ALERT#: length 3
  TOP w0.102: PR61.2 137.6,49.5 138.06,49.96 138.06,50.54 138.6,51.08 138.74,51.08 138.86,51.2 PU4.3
RT3612_BOOT1: length 3.2
  TOP w0.203: PC55.2 134.97,55.88 135.19,56.09 v1(135.55,56.09) 136.61,56.09 137.04,55.67 137.13,55.67 137.33,55.47 PU4.25
RT3612_BOOT2: length 4.1
  TOP w0.203: PU4.1 138.06,51.25 137.69,50.88 135.68,50.88 v1(135.65,50.84) 135.45,51.04 134.71,51.04 PC59.2
RT3612_COMP: length 4.1
  TOP w0.203: PU4.15 142.13,54.86 142.51,55.24 143.06,55.24 143.31,54.98 PC56.2 PR56.1 v1(145.4,54.98)
RT3612_FB: length 5.6
  TOP w0.178: 143.48,56.99 143.48,57.35 143.78,57.65 PR54.1
  TOP w0.203: PC56.1 PR56.2 ; PC56.1 143.55,56.47 143.48,56.54 PC53.2 143.48,56.99 ; PC56.1 142.96,55.76 v1(142.66,56.07) 142.66,55.92 142,55.26 PU4.16
RT3612_IMON: length 2.4
  TOP w0.203: PR58.2 143.17,52.32 142.23,53.26 PU4.11
RT3612_ISEN1N: length 2.5
  TOP w0.178: PR49.2 140.27,58.32 140.27,57.7 140.32,57.65 140.32,56.98 140.06,56.72 PU4.19
RT3612_ISEN1P: length 4.6
  TOP w0.178: PR48.1 138.85,58.31 138.85,58.31 PC51.2 139.3,58.12 139.82,57.6 v1(139.82,57.29) 139.66,57.13 PU4.20
  BOTTOM w0.178: v1(139.82,57.29) 140.35,57.82 PR174.1
RT3612_ISEN2N: length 2.9
  TOP w0.178: PR50.2 141.26,57.97 140.86,57.97 140.63,57.74 140.63,56.78 140.46,56.61 PU4.18
RT3612_ISEN2P: length 6.1
  TOP w0.178: PC49.2 142.7,59.55 142.98,59.28 142.98,58.56 142.51,58.09 PR51.1 142.5,58.04 v1(141.77,57.32) v1(141.27,56.82) 140.86,56.4 PU4.17
  BOTTOM w0.178: PR176.1 142.08,56.5 141.81,56.77 141.75,56.77 141.7,56.82 v1(141.27,56.82)
RT3612_LG1: length 25.5
  TOP w0.203: PU4.28 136.54,54.06 136.29,54.3 135.56,54.3 v4(135.41,54.15) 135.38,54.15 135.14,54.39 v1(133.77,54.39)
  IN3 w0.61: v4(124.42,65.13) 123.76,64.47 123.76,59.02 123.96,58.81 123.96,56.1 125.39,54.66 134.89,54.66 v4(135.41,54.15)
RT3612_LG2: length 13.6
  TOP w0.203: PU4.30 136.4,53.26 v4(136.23,53.1)
  IN3 w0.61: v4(124.18,53.88) 130.37,53.88 131.12,53.14 135.13,53.14 135.2,53.07 136.21,53.07 v4(136.23,53.1)
RT3612_PHASE1: length 23.6
  TOP w0.203: PU4.27 136.7,54.46 136.36,54.8 135.85,54.8 v4(135.78,54.88)
  TOP w0.305: v1(133.51,55.71) 134.13,55.1 PC55.1 135.55,55.1 v4(135.78,54.88)
  IN3 w0.61: v4(124.67,59.72) 124.9,59.95 127.56,59.95 132.05,55.46 135.2,55.46 v4(135.78,54.88)
  BOTTOM w0.178: 122.35,62.97 PL7.1 120.69,62.97 120.39,63.26 120.39,66.09 120.94,66.64 PR165.1
RT3612_PHASE2: length 25.3
  TOP w0.203: PU4.31 136.81,52.86 136.29,52.35 v4(136.13,52.35)
  TOP w0.305: v1(133.46,51.29) 134.01,51.84 PC59.1 135.63,51.84 v4(136.13,52.35)
  IN3 w0.61: v4(136.13,52.35) 130.62,52.35 129.88,53.09 122.66,53.09 v4(121.99,53.76)
  BOTTOM w0.178: PR183.1 120.48,55.21 120.48,51.89 120.84,51.52 PL8.1
RT3612_PSYS: length 3.5
  TOP w0.203: v1(142.34,51.22) 142.34,51.3 141.58,52.06 PU4.9
  BOTTOM w0.203: PC199.2 PR188.1 142.28,52.31 PR195.2 142.28,51.28 v1(142.34,51.22)
RT3612_PVCC: length 6.5
  TOP w0.203: v1(136.04,53.81) 136.19,53.66 PU4.29
  TOP w0.305: v1(136.04,53.81) 135.35,53.12 PC58.1 134.68,52.81 134.43,52.56 v1(133.06,52.56)
  BOTTOM w0.381: PR186.1 136.9,54.35 136.36,53.81 v1(136.04,53.81)
RT3612_RGND: length 4
  TOP w0.203: PU4.13 142.57,54.06 142.63,54 v1(142.65,54) 143.39,53.26 PC57.2
  BOTTOM w0.203: v1(142.65,54) 142.88,54.23 PR185.1
  BOTTOM w0.305: v1(142.65,54) 142.4,54 PC198.1
RT3612_SET1: length 4.7
  TOP w0.102: PU4.8 140.86,50.49 v1(141.12,50.23) v1(141.12,49.59)
  BOTTOM w0.178: PR209.2 140.99,48.88 141.33,49.22 141.33,50.03 v1(141.12,50.23) 141.12,50.26 141.09,50.3 PR196.2
RT3612_SET2: length 5
  TOP w0.102: PU4.7 140.46,50.67 140.5,50.63 140.5,50.24 v1(140.42,50.15) 140.42,48.8 v1(140.22,48.6)
  BOTTOM w0.178: PR198.2 140.24,50.38 140.4,50.23 ; v1(140.42,50.15) 140.52,50.15 140.99,49.68 PR202.2
  BOTTOM w0.203: v1(140.42,50.15) 140.42,50.21 140.4,50.23
RT3612_SET3: length 7
  TOP w0.102: PU4.6 140.06,50.47 v1(139.73,50.15) 139.73,48.42 v1(139.15,47.84)
  BOTTOM w0.178: PR194.2 138.9,52.15 139.12,51.94 139.12,51.05 139.26,50.91 PR197.1 139.52,50.41 139.73,50.2 v1(139.73,50.15)
RT3612_TSEN: length 23.5
  TOP w0.178: PR52.1 137.54,57.94 137.59,57.94 137.96,57.57 v1(138.13,57.57) 138.4,57.84 139.09,57.84 139.31,57.62 139.31,56.61 139.26,56.56 PU4.21
  IN3 w0.102: v1(125.04,68.21) 125.25,68.01 126.78,68.01 133.29,61.5 136.49,61.5 137.92,60.08 137.92,57.84 138.13,57.63 v1(138.13,57.57)
  BOTTOM w0.178: PR160.1 124.99,68.16 v1(125.04,68.21)
RT3612_UG1: length 10
  TOP w0.203: v4(136.36,55.41) 136.36,55.31 136.81,54.86 PU4.26
  IN3 w0.61: v4(136.36,55.41) 136.36,55.46 135.58,56.23 132.5,56.23 131.22,57.52 v4(131.22,60.18)
RT3612_UG2: length 5.9
  TOP w0.203: v4(136.28,51.58) 136.7,51.58 v1(136.93,51.36) 137.33,51.76 PU4.32
  BOTTOM w0.61: PR187.1 134.17,52.92 135.51,51.58 v4(136.28,51.58)
RT3612_VCC: length 5.8
  TOP w0.203: PU4.10 142.11,52.86 142.37,52.6 142.37,51.91 143.57,50.71 PC61.1
  TOP w0.457: PC61.1 143.08,50.54 142.94,50.68 v1(142.81,50.68)
  BOTTOM w0.457: PR207.1 143.17,50.35 142.84,50.68 v1(142.81,50.68)
RT3612_VCLK: length 3.1
  TOP w0.102: PU4.5 139.66,50.86 139.41,50.61 138.86,50.61 138.62,50.37 138.62,49.82 PR63.2
RT3612_VDIO: length 2.8
  TOP w0.102: PR62.2 138.2,49.63 138.38,49.81 138.38,50.5 138.74,50.86 139.02,50.86 139.26,51.1 PU4.4
RT3612_VIN: length 3.6
  TOP w0.203: v1(138.76,57.34) 138.76,56.93 138.86,56.83 PU4.22
  BOTTOM w0.508: PC191.2 139.16,56.94 v1(138.76,57.34) 139.14,57.72 PR172.2
RT3612_VR_READY: length 3.8
  TOP w0.178: 136.69,56.78 v1(136.69,56.68) 136.69,56.58 137.28,55.98 PU4.24
  TOP w0.203: PR53.2 135.59,58.13 136.31,57.42 136.31,57.39 136.69,57.01 136.69,56.78
RT3612_VRHOT: length 3.3
  TOP w0.102: PR60.2 136.72,49.69 136.88,49.85 137.4,49.85 137.65,50.1 137.65,50.48 138.46,51.29 PU4.2
RT3612_VRON: length 11.6
  TOP w0.102: v1(137.48,56.58) 137.48,56.65 136.64,57.49 136.64,58.68 137.15,59.19 137.32,59.19 139.17,61.05 v1(140.57,61.05) 140.9,60.72 PR46.2
  TOP w0.203: v1(137.48,56.58) 137.68,56.58 137.83,56.73 138.22,56.73 138.46,56.5 PU4.23
  BOTTOM w0.178: v1(137.48,56.58) 137.53,56.63 137.95,56.63 138.1,56.48 PC192.2
RT3612_VSEN: length 12
  TOP w0.178: PR54.2 144.26,57.98 144.26,56.99 ; 144.26,56.98 PC53.1
  TOP w0.203: 144.26,56.99 144.26,56.98 ; PC53.1 144.41,56.58 v1(145.19,56.58) 145.19,56.04 146.01,55.22 146.01,54.75 145.76,54.5 144.53,54.5 144.53,54.5 144.01,54.5 PC57.1 142.93,54.67 v1(142.66,54.67) 142.44,54.46 PU4.14
  BOTTOM w0.203: PR184.1 143.12,54.94 142.85,54.67 v1(142.66,54.67)
  BOTTOM w0.305: PC195.1 141.87,55.53 142.66,54.75 v1(142.66,54.67)
RT6543_BOOT: length 3.3
  BOTTOM w0.203: 136.13,40.24 136.84,40.94 PU10.10
  BOTTOM w0.305: PC214.2 134.86,39.94 v1(135.16,40.24) 136.13,40.24
RT6543_COMP: length 3.7
  BOTTOM w0.203: PC213.1 141.56,40.82 141.09,40.34 PC217.1 141.08,39.86 139.56,41.38 PU10.5
RT6543_CS_DSI: length 2.1
  BOTTOM w0.203: PU10.1 141.39,43.34 PR224.2
