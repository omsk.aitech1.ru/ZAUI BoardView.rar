# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCSTG: length 15.2
  BOTTOM w0.254: 99.03,55.32 99,55.29 99,52.92 98.19,52.11 U24.BY1
  BOTTOM w0.381: 99.03,55.32 99.03,59.87 99.91,60.75 C588.1 101.41,60.75
  BOTTOM w0.508: C589.2 101.41,60.75 ; 105.75,65.85 105.75,65.42 105.73,65.42 105.29,64.98 105.29,63.71 104.69,63.11 C585.1
  vias: v1(104.68,61.71)
+VCCSTG_OUT_FUSE: length 1.1
  BOTTOM w0.203: v2(83.02,78.49) 82.87,78.49 U24.F33 ; v2(83.02,77.9) 82.94,77.9 82.72,78.12 U24.G33
  vias: v1(83.6,71.94)
+VCCSTG_OUT_LGC: length 0.5
  BOTTOM w0.254: v2(96.06,79.54) U24.E5
  vias: v1(100.51,80.61) v1(104.15,79.87)
+VCCSTG_TERM: length 16.7
  TOP w0.203: R129.2 102.65,77.4 v1(102.53,77.28) 103.28,77.28 103.52,77.52 v1(103.52,77.65)
  IN1 w0.203: v1(99.15,83.37) 100.16,82.36 100.72,82.36 102.25,80.83 102.45,80.83 102.65,80.63 102.65,79.29 103.52,78.42 v1(103.52,78.28)
  BOTTOM w0.203: v1(99.15,83.37) 99.43,83.65 R582.2 ; R596.1 105.12,77.02 105.78,77.02 105.9,76.9 105.9,75.5 105.34,74.94 103.54,74.94 103.44,74.84 R607.2
+VDDQ: length 36.1
  TOP w0.508: v1(52.16,100.7) 51.55,100.7 50.94,100.09 v1(50.81,100.09) 49.86,100.09 R47.1 ; PR9.2 68.63,119 v1(68.13,119.49)
  IN1 w0.508: v1(64.2,107.56) 64.2,107.58 63.93,107.85 63.93,117.45 64.83,118.35 64.83,119.87 65.34,120.38 67.12,120.38 68.01,119.49 v1(68.13,119.49)
  IN2 w0.508: v1(64.2,107.56) 63.49,106.84 60.56,106.84 57.52,103.8 56.51,103.8 56.33,103.62 55.1,103.62 52.18,100.7 v1(52.16,100.7)
+VDDQ_BOOT1: length 2.4
  BOTTOM w0.381: v1(60.01,118.56) 60.01,119.36 PR132.1
  BOTTOM w0.508: PR132.1 60,119.69 60,120.26 PC139.1
+VDDQ_SR: length 1.7
  BOTTOM w0.508: PR129.2 62.41,121.16 62.9,121.65 62.9,122.3 PC136.1
+VDDQ_VTT: length 107.8
  TOP w0.254: R139.1 28.18,76.69 28.18,74.08 27.8,73.7 v1(27.62,73.7)
  TOP w0.508: 28.64,98.54 28.64,100.32 v1(24.4,104.56) ; 42.91,98.74 42.94,98.77 44.01,98.77 44.78,99.54 47.92,99.54 49.21,100.82 v1(49.21,101.56)
  IN1 w0.254: v1(27.62,73.7) 27.32,73.7 26.34,74.67 26.34,82.65 26.73,83.04 26.73,84.31 27.44,85.03 v1(27.44,85.33)
  IN2 w0.508: v1(43.47,116.34) 41.69,114.57 41.69,112.46 41.18,111.95 41.18,109.54 37.65,106.01 25.84,106.01 v1(24.4,104.56)
  IN3 w0.508: v1(43.47,116.34) 43.47,118.32 44.38,119.24 44.38,120.51 43.95,120.94 43.95,122.6 44.46,123.11 50.6,123.11 50.79,123.3 57.97,123.3 61.66,119.62 65.01,119.62 v1(65.7,118.93)
  BOTTOM w0.254: JDIM1.258 59.66,95.7 59.75,95.62 v1(60.01,95.62)
  BOTTOM w0.508: v1(49.21,101.56) 51.34,99.43 51.45,99.43 51.91,98.97 56.27,98.97 56.7,98.54 56.7,97.42 57.14,96.99 59.6,96.99 60.01,96.58 v1(60.01,95.62) ; v1(65.7,118.93) 65.05,119.58 PR130.2
  vias: v1(42.63,97.98)
+VIN: length 107.3
  TOP w0.152: 52.75,116.9 52.34,116.9 52.11,116.67 52.11,114.99 PR19.1
  TOP w0.508: v1(25.97,41.92) 25.97,41.86 PR67.1 27.04,41.2 27.7,41.86 PR64.1 ; PR1.1 118.87,125.69 95.79,125.69 95.18,125.08 95.18,122.18 94.84,121.84 94.84,121.23 94.24,120.63 94.24,117.97 93.7,117.42 87.08,117.42 86.04,116.38 81.15,116.38 80.45,117.08 80.45,118.22 79.56,119.11 72.96,119.11
  BOTTOM w0.254: PU9.22 138.56,66.79 PU9.24
  BOTTOM w0.508: 51.19,18.83 50.23,19.8 48.92,19.8 48.41,20.31 PC261.2 47.72,21.1 47.86,21.25 47.86,22.11 46.54,23.43 46.54,26.66 46.09,27.11 45.58,27.11 45.05,27.65 45.05,31.25 43.92,32.37 38.19,32.37 37.04,31.23 31.74,31.23 28.97,34 28.97,35.98 26.73,38.21 26.73,41.16 v1(25.97,41.92)
  vias: v1(64.22,116.32) v1(71.74,120.28) v1(76.39,14.06) v1(77.02,14.06) v1(77.66,14.06) v1(78.29,14.06) v1(78.93,14.06) v1(79.56,14.06) v1(79.82,105.02) v1(80.45,105.02) v1(81.1,105.02) v1(81.74,105.02) v1(82.38,105.02) v1(83.02,105.02) v1(101.61,83.25) v1(119.7,32.75) v1(119.91,32.13) v1(120.38,32.76) v1(120.54,32.13) v1(121.02,32.76) v1(121.18,32.13) v1(121.65,32.76) v1(121.81,32.14) v1(122.29,32.76) v1(129.6,56.63) v1(131.94,57.9) v1(133.91,59.8) v1(134.56,59.8) v1(135.25,59.8) v1(135.91,59.8) v1(136.58,59.8) v1(138.03,37.07) v1(138.34,63.87) v1(138.67,37.07) v1(138.8,63.41) v1(139.3,37.07) v1(139.43,63.41) v1(139.46,62.75) v1(139.94,37.07) v1(140.57,37.07) v1(141.21,37.07) v4(53.78,116.88) v4(53.78,116.05) v4(54.54,117.19) v4(54.52,116.39) v4(55.31,116.88) v4(55.33,116.07) v4(56.07,117.19) v4(56.09,116.38) v4(56.83,116.83) v4(56.83,116.06) v4(66.08,109.71) v4(67.07,112.97) v4(70.27,120.43) v4(70.67,125.46) v4(70.67,121.91) v4(71.41,121.91) v4(72.15,121.91)
+VIN_BLIGHT:
  vias: v1(63.74,105.93)
+VIN_VCCIN_AUX: length 11.4
  IN3 w0.203: v1(140.17,45.05) 139.41,44.29 139.41,41.21 138.53,40.33 137.26,40.33 136.92,39.99 v1(136.92,39.83)
  BOTTOM w0.305: PR220.2 141.01,45.89 v1(140.17,45.05) ; v1(136.92,39.83) 136.89,39.8 135.54,39.8 134.78,39.04 134.78,38.67
AVDD2: length 6.7
  BOTTOM w0.203: L13.2 209.98,34.1 208.87,34.1 208.4,33.63 U30.40
  BOTTOM w0.508: L13.2 210.16,34.28 210.16,36.93 v1(210.42,37.2) 210.42,37.65 C619.1
DVDD_IO: length 2.5
  BOTTOM w0.203: U30.9 203.66,28.7 v2(203.53,28.57) 203.38,28.57 202.74,27.93 202.65,27.93 C661.1
  vias: v1(202.93,28.74)
GND: length 2042.7
  TOP w0.102: R286.1 100.77,36.03 100.77,35.93 100.95,35.75 v2(100.95,34.76) 100.93,34.76 100.7,34.53 99.38,34.53 v2(98.87,35.04) 98.87,35.29 99.6,36.03 99.6,36.13 v2(99.63,36.16) ; v2(95.95,37.35) 95.95,37.29 96.28,36.97 96.28,36.77 97.09,35.95 v2(97.09,34.96) ; 73.69,32.4 73.79,32.29 73.79,32.2 74.46,31.53 74.94,31.53 75.14,31.74 75.14,32.6 76.49,33.95 76.49,34.5 v2(76.08,34.91) 75.86,34.91 74.13,33.18 73.95,33.18 v2(73.75,32.98) 73.75,32.48 v2(73.66,32.4) 73.69,32.4
  TOP w0.203: C451.2 v1(216.44,16.14) ; v2(195.82,27.14) 195.29,27.14 195.01,27.42 195.01,28.18 194.45,28.74 U13.104 ; R290.2 90.49,36.27 v2(90.37,36.38) ; R166.2 105.04,73.52 v1(105.42,73.9) 105.09,74.23 R161.2 ; v2(165.64,30.87) 165.64,31.05 165.06,31.63 C370.2 ; v2(205.87,17.26) 205.85,17.24 205.85,16.95 206.06,16.75 R460.1 ; R446.1 206.59,18.15 v2(206.79,18.35) 206.59,18.55 R436.1 ; C353.1 66.65,36.31 67.52,37.17 v1(67.98,37.17) ; R287.1 93.56,36.44 v2(94.12,36.99) ; PU1.3 v1(64.02,118.82) ; D3.1 16.32,82.94 v2(16.44,82.82) 16.44,82.51 16.22,82.28 D4.1 ; v2(78.22,44.49) 78.27,44.44 R256.1 ; C365.2 191.45,32.63 191.32,32.75 191.32,33.16 191.63,33.46 v2(191.63,33.89) ; v2(76.85,44.58) 76.85,44.8 77,44.94 77.22,44.94 C329.1 ; v2(93.12,78.35) 93.21,78.44 R125.2 ; PU6.11 20.2,27.42 20.04,27.25 19.48,27.25 PC92.2 ; v1(59.65,18.05) 59.78,17.92 59.78,17.46 C447.2 ; R359.2 65.97,28.62 65.78,28.81 R339.1 65.78,29.55 v1(65.57,29.75) 65.57,29.95 65.83,30.21 C724.1 ; v1(67.24,118.73) 66.81,118.3 PC15.1 ; R177.2 105.14,70.14 v1(105.45,70.45) 105.34,70.45 R174.2 ; R146.2 104.99,76.11 v1(105.37,75.73) 104.99,75.35 R151.2 ; v1(61.91,45.3) 61.5,45.71 R243.2 ; R156.1 97.49,74.58 96.73,73.82 96.73,73.66 v2(96.62,73.55) ; U13.91 199.74,26.18 199.99,26.43 200.49,26.43 ; R337.2 86.43,30.42 86.43,31.1 v2(86.55,31.23) 86.22,31.23 86.1,31.1 R328.1 ; R235.1 16.7,46.21 16.69,46.21 C328.2 ; U13.1 184.22,28.18 184.39,28.01 184.5,28.01 184.85,27.67 184.85,26.83 v2(184.82,26.81) ; v1(51.57,32.93) 50.73,33.77 C361.2 ; v2(80.77,49.35) 80.81,49.32 R226.2 ; R303.2 88.43,34.08 v2(88.43,34.09) ; v2(205.65,12.51) 206.11,12.51 206.16,12.56 R485.1 R477.1 ; v1(105.09,67.52) 105.48,67.52 R193.2 ; PR112.2 99.02,20.59 98.87,20.43 v2(98.87,20.18) ; v2(178.57,23.68) 178.6,23.66 179.59,23.66 180.27,22.97 180.91,22.97 181.07,23.13 C388.2 ; R192.2 R191.2 v1(107.5,67.04) ; PU3.11 22.54,95.49 v1(22.67,95.62) ; R173.2 102.2,71.26 101.93,70.99 101.57,70.99 v2(101.48,70.9) ; v1(55.18,73.6) 55.21,73.62 C208.2 ; v1(66.53,23.4) 66.56,23.4 66.64,23.48 R405.2 ; R459.2 201.63,17.25 201.84,17.46 v2(201.84,17.51) ; v1(216.47,15.48) 216.37,15.48 216.09,15.76 215.58,15.76 215.2,16.14 C450.2 C449.2 213.62,16.14 213.4,16.37 U17.18 ; C326.1 63.53,46.75 63.46,46.82 v1(63.16,46.82) 63,46.67 R239.1 ; R326.2 85.28,31.26 v2(85.3,31.23) 85.3,31.36 85.36,31.41 85.36,31.92 R311.2 ; R143.1 99.56,77.66 v1(100.54,77.66) 100.54,77.71 100.59,77.76 R128.2 ; v2(85.89,34.09) 86.39,34.09 R302.2 ; v1(37.5,26.84) 37.32,26.84 37.02,27.14 PC95.2 ; U5.8 16.64,55.68 v1(16.19,55.23) 16.54,54.89 U5.9 ; v2(206.03,15.73) 206.16,15.61 R466.1 ; v2(78.97,45.48) 78.97,45.34 78.62,45 R250.2 ; U5.3 19.82,55.29 20.13,54.98 v1(20.25,54.98) ; v2(200.85,25.94) 200.85,26.25 200.67,26.43 200.49,26.43 ; U11.8 17.53,34.98 v1(17.14,34.59) 17.55,34.18 U11.9 ; v1(67.91,32.12) 67.88,32.14 R317.1 ; R291.1 66.16,34.31 v1(66.53,33.94) ; v1(105.4,72.87) 105.4,72.86 105.27,72.73 R168.2 ; C395.1 57.67,21.83 57.54,21.7 v1(57.39,21.7) ; v1(51.55,50.41) 50.96,50.99 EC2.1 ; R230.1 80.31,47.8 v2(80.31,47.27) ; C364.2 187.01,32.88 187.06,32.93 v2(187.06,33.49) ; EC1.1 55.21,87.33 v1(55.05,87.18) ; C392.2 131.89,22.94 ; v1(52.26,53.15) 53.23,54.12 C293.1 ; v1(68.92,37.45) 68.92,37.17 68.35,36.6 67.79,36.6 66.84,35.64 C723.1 ; v2(99.63,36.16) 99.64,36.17 100.13,36.17 100.23,36.27 R286.1 ; v2(181.82,16.22) 181.68,16.08 180.82,16.08 180.75,16.14 R462.2 ; R277.2 93.6,38.29 93.79,38.1 95.27,38.1 95.95,37.42 v2(95.95,37.35) 95.47,36.86 R285.2 95.47,36.15 96.55,35.07 R296.1 96.91,34.78 v2(97.09,34.96) 97.32,34.74 R301.2 ; v2(94.78,32.13) 94.78,32.38 95.03,32.63 R308.2 ; 200.49,26.43 C386.2 ; v2(184.76,31.23) 184.76,31.31 184.73,31.33 184.73,31.33 184.65,31.26 C372.2 ; C159.2 54.52,93.92 53.95,93.36 v1(53.48,93.36) ; R181.2 105.01,69.02 v1(105.09,68.95) 105.09,68.59 R186.2 ; PC25.2 78.34,111.06 77.99,111.06 PR25.2 ; C369.2 46.8,31.89 v1(46.29,31.89) ; R408.2 77.38,23.4 77.58,23.61 v1(77.86,23.61) ; v1(105.38,72.02) 105.37,72.02 105.34,72 R171.2 ; 191.25,13.17 U13.49 ; v1(62.21,118.83) 62.16,118.78 PC16.2 ; R140.2 105.09,77.25 v1(105.42,77.58) 105.04,77.96 R132.2 ; v2(181.06,29.04) 181.04,29.07 R348.2 ; v2(89.39,31.33) 89.39,31.13 89.55,30.97 R334.2 ; U11.3 18.93,34.58 U11.11 ; C374.1 v2(165.06,30.87) ; U15.23 122.41,19.21 122.17,18.97 122.17,18.66 v2(121.79,18.27) 121.78,18.29 121.78,18.3 121.35,18.73 C432.2 C413.2 ; R491.1 22.06,10.73 v1(21.98,10.81) ; v1(68.9,39.48) 68.16,38.75 C344.1 ; v2(179.28,16.42) 179.28,16.46 180.05,17.23 180.57,17.23 C442.2 C443.2 182.19,17.57 182.4,17.78 U13.27 ; v2(207.96,14.59) 207.68,14.31 206.82,14.31 206.59,14.54 R471.1 ; v1(209.36,13.45) 208.98,13.45 208.72,13.19 C466.2 208.72,12.69 208.69,12.66 C476.2 ; v1(13.65,86.98) R93.1 ; C480.1 199.33,11.71 v2(199.32,11.72) ; PU7.11 PU7.15
  TOP w0.254: 191.25,13.17 189.9,11.82 189.9,11.31 189.8,11.21 v2(189.8,10.98) ; v1(60.16,12.03) 59.64,12.54 U18.3 ; U3.17 18.69,75.92 v1(18.45,76.16) ; U10.3 109.27,37.09 109.84,36.51 109.84,34.91 v1(109.74,34.81) ; v2(125.65,25.1) 125.61,25.06 125.61,24.57 125.22,24.18 124.46,24.18 123.94,23.66 U15.16 ; U6.N9 37.07,51.03 v1(37.07,51.01) ; C134.1 107.77,98.67 v2(107.77,99.22) ; v1(49.62,103.7) 49.62,103.75 49.98,104.11 49.98,104.45 49.82,104.61 R30.1 ; v2(108.39,100.15) 108.68,100.44 C111.1 ; R245.2 65.06,45.4 65.01,45.35 v1(64.96,45.35) ; R234.2 23.31,46.97 v1(22.92,47.36) ; U16.12 64.2,19.23 63.94,19.49 63.1,19.49 60.92,21.68 v1(60.46,21.68) 60.36,21.58 60.36,21.42 63.26,18.53 U16.13 ; PR118.2 43.22,15.34 43.22,14.75 43.13,14.66 v1(43.13,14.56) ; Q24.4 56.49,15.65 v1(56.81,15.96) ; R255.2 81.72,44.44 82.36,45.07 82.74,45.07 83.15,44.66 v2(83.15,44.49) ; U4.N9 37.07,70.93 v1(37.07,70.91) ; v1(62.82,21.6) 62.82,21.47 65.21,19.08 U16.10 ; PC104.1 166.38,23.75 166.33,23.75 166.19,23.89 166.1,23.89 v2(166.08,23.91) ; v1(68.51,12.55) 67.63,12.55 65.7,14.48 U16.5 ; PC73.1 138.88,34.74 v1(138.92,34.78) ; C139.1 105.97,97.17 v2(105.45,96.65) ; R404.2 147.41,23.9 147.67,24.16 v2(147.67,24.26) 147.67,24.39 R396.2 147.22,24.91 U12.3 ; R259.2 81.05,43.99 81.05,44.4 v2(80.93,44.52) ; v1(40.27,50.33) 40.75,50.81 40.75,51.35 U6.H9 ; v2(106.36,98.84) 106.36,98.71 C135.1 ; U9.3 105.96,40.5 105.71,40.75 v1(105.09,40.75) ; U17.13 v1(210.88,13.45) ; PR69.2 132.55,35.91 v1(132.55,35.42) ; v1(58.41,17.26) 58.41,17.23 58.45,17.19 C448.2 ; C384.2 201.39,27.93 201.92,28.45 201.92,28.99 v2(201.82,29.09) ; v1(210.78,19.19) 210.78,19.16 210.88,19.06 U17.3 ; U16.16 61.52,16.5 60.31,17.72 v1(60.31,18.07) 60.59,18.07 61.66,17 U16.15 ; U2.N9 37.07,84.23 v1(37.07,84.21) ; U8.N9 36.55,38.16 36.55,37.8 v1(36.76,37.58) ; C33.1 46.96,110.86 v1(47.2,110.86) ; v1(147.69,18.76) 147.66,18.76 147.47,18.56 147.3,18.56 147.12,18.74 U14.3
  TOP w0.305: C38.2 111.26,111.6 v2(111.26,111.61) ; C72.1 103.76,105.51 v2(103.48,105.23) ; U8.F1 42.64,45.06 v1(42.64,45.11) ; v1(67.71,113.2) 68.15,112.76 PR23.1 ; v1(38.67,37.88) U8.K9 ; C41.1 99.81,110.65 v2(99.65,110.81) ; C48.2 111.23,109.11 v2(112.11,109.11) ; v2(105.53,107.23) 105.99,107.69 C55.1 ; v1(13.04,16.24) 12.13,16.24 12,16.12 RV1.3 ; Q4.4 57.23,102.71 57.69,102.25 57.69,101.61 58.05,101.26 v2(58.46,101.26) ; C91.1 54.8,102.47 55.6,101.67 Q4.1 55.93,101.19 v1(55.4,100.66) ; U7.14 17.4,48.88 17.05,49.23 R223.1 ; RV1.8 v1(9.84,16.12) ; v1(41.9,52.63) 41.87,52.63 U6.G8
  TOP w0.356: v2(131.41,87.01) 131.3,87.12 C175.1 ; v1(42.68,72.52) 42.68,72.49 43.04,72.13 U4.E8 ; v1(39.47,70.93) U4.K9 ; v1(43.47,90.63) U2.D2 ; v1(41.07,84.23) U2.H9 ; U2.K9 39.07,84.12 39.59,83.59 v1(39.99,83.59) ; U8.H9 v1(41.07,37.88) ; U6.E1 v1(42.67,57.43) U6.F1 ; C26.1 131.74,112.61 v2(131.41,112.61) ; v1(41.87,45.08) 41.72,45.23 41.22,45.23 U8.H1 ; C18.1 131.6,117.22 v2(132.21,116.61) ; v2(139.41,86.21) 139.26,86.35 C172.1 ; v2(126.63,105.42) 126.21,105 C81.2 ; U8.E1 43.47,45.08 v1(43.5,45.08) ; U6.K1 39.37,58.13 39.37,58.21 40.35,59.19 41.36,59.19 41.36,59.2 v1(41.36,59.22) ; v1(141.57,116.67) 141.57,116.75 142.04,117.22 C20.2 ; U8.A8 46.8,38.55 v1(46.8,37.91) ; v1(44.26,37.88) 44.27,37.88 U8.C9 ; v2(101.23,101.23) 101.5,100.96 C110.1 ; v1(43.39,78.85) 43.39,78.06 U4.E1 ; v1(29.93,60.46) 29.8,60.33 C268.2 29.8,59.53 30.47,58.86 30.82,58.86 31.69,57.99 34.11,57.99 U6.T1 ; U4.N1 36.67,78.54 36.29,78.92 v1(36.16,78.92) ; v1(43.47,42.68) U8.E3 ; v1(41.07,70.93) U4.H9 ; U4.C9 v1(44.26,71.74) ; v1(44.27,44.28) U8.D2 ; C74.1 108.26,105.51 108.8,106.06 v2(108.8,106.21) ; U4.D8 44.25,72.51 v1(44.25,72.53) ; C73.1 105.51,105.51 v2(105.78,105.24) ; C109.1 103.05,100.75 v2(102.58,100.28) ; U2.C9 44.67,84.61 v1(45.05,84.23) ; v1(30.54,45.38) 30.54,45.22 31.63,44.13 33.72,44.13 U8.T1 ; U2.E1 43.31,91.27 43.34,91.27 43.72,91.65 43.72,91.68 v1(43.72,91.68) ; C50.2 102.68,107.99 v2(103.48,107.18) ; v2(133.81,115.81) 134.44,115.18 C21.1 ; v2(128.21,86.21) 128.08,86.34 C174.1 ; v1(39.46,91.5) 39.43,91.48 39.43,91.39 U2.K1 ; v1(41.07,77.33) U4.H1 ; v2(100.44,101.61) 100.44,102.32 C96.1 ; U4.A8 46.82,72.69 46.82,73.24 v1(46.52,73.54) ; v2(106.36,102.22) 106.62,101.96 C101.1 ; C133.1 102.66,99.05 v2(102.17,99.05) 101.53,99.05 C129.2 ; C82.1 101.42,104.94 v2(101.42,105.13) ; v2(135.41,90.21) 135.99,90.21 C168.2 ; v1(40.27,45.08) 40.15,45.2 39.59,45.2 U8.K1 ; v2(102.42,106.25) 102.07,105.9 C66.1 ; U2.N1 v1(36.67,92.19) ; v2(102.4,102.35) 102.01,101.96 C98.1 ; C108.1 106.99,100.41 v2(106.52,99.95) ; C69.1 128.2,105.42 v2(128.21,105.41) ; v1(100.36,103.97) 100.36,103.46 C90.1 ; v1(44.27,85.03) U2.D8 ; v1(44.3,76.53) 44.27,76.53 U4.D2 ; C107.1 105.99,101.02 v2(105.57,101.43) ; v2(133.01,116.61) 133.61,117.21 C16.1 ; U2.F1 42.76,91.52 v1(42.79,91.52) ; U6.E8 U6.D8 v1(44.27,52.63) ; U4.E3 43.46,76.52 v1(43.46,76.53) ; v1(41.07,71.73) U4.G8 ; v1(45.87,85.86) 45.87,85.83 46.27,85.43 U2.A8 46.67,85.03 v1(46.67,85.01) ; v1(43.47,56.63) U6.E3 ; Q22.1 20.57,14.04 v1(20.23,13.7) ; C99.1 104.07,101.8 v2(103.57,101.29) ; U4.K1 39.37,78.03 39.41,78.03 40.84,79.46 v1(41.72,79.46) ; v1(45.87,56.62) 45.87,56.63 U6.B2 ; v2(108.82,102.22) 109.09,102.48 C104.1 ; v1(42.67,85.81) 42.7,85.81 U2.E8 ; C102.1 108.06,101.96 v2(107.52,101.42) ; U8.A2 46.27,43.88 v1(45.87,44.28) ; C160.1 140.28,94.14 v2(140.21,94.21) ; C80.1 109.89,104.79 v2(109.41,105.27) 109.89,105.75 C75.1 ; v1(46.67,76.53) U4.A2 ; v1(45.07,44.28) 45.47,43.88 U8.B2 ; U2.H1 40.67,91.01 v1(41.04,90.63) ; Q22.4 21.87,16.89 v1(22,17.01) ; v2(108.82,104.23) 108.54,104.52 C86.1 ; U4.F1 42.78,78.25 v1(42.78,78.32) ; v2(109.49,104.28) 109.92,103.85 C87.1 ; C100.1 105.01,101.96 v2(104.63,102.35) ; v1(45.87,89.86) 45.5,90.23 U2.B2 ; v1(36.26,45.96) 36.26,45.35 36.67,44.94 U8.N1 ; v1(46.67,56.63) U6.A2 ; U2.A2 46.3,90.23 v1(46.67,89.86) ; U2.T1 33.62,91.68 v1(33.44,91.68) ; C52.1 130.78,108.47 131.24,108.47 v2(131.41,108.64) ; v1(42.67,39.48) U8.E8 ; C70.1 107,104.54 C85.1 106.62,104.52 v2(106.36,104.25) ; v1(45.87,51.83) 45.87,51.86 46.25,52.23 U6.A8 ; C199.2 30.7,77.87 33.34,77.87 33.36,77.89 34.11,77.89 U4.T1 ; C49.1 134.93,109.46 v2(135.41,109.46) ; C84.1 105.02,104.52 v2(104.63,104.12) 104.23,104.52 C83.1 ; v1(41.07,85.03) U2.G8 ; v2(107.4,107.12) 107.89,107.61 C56.1 ; v1(41.07,38.68) U8.G8 ; v1(44.27,56.63) U6.D2 ; v1(44.26,38.68) 44.26,38.69 U8.D8 ; U2.E3 v1(42.67,89.83) ; v1(40.27,50.33) 40.17,50.33 U6.K9 ; U6.C9 45.1,51 v1(45.1,50.98) ; v1(36.16,59.02) 36.29,59.02 36.67,58.63 U6.N1 ; v1(41.07,57.43) U6.H1 ; v2(138.61,113.41) 138.5,113.3 C27.1 ; v1(45.87,76.53) U4.B2 ; C63.1 108.88,106.95 108.52,107.3 v2(108.39,107.3) ; v1(136.21,101.58) Q5.1
  TOP w0.381: R19.2 59.62,109.2 59.62,109.59 v1(59.75,109.71) ; v1(132.43,75.77) 132.99,75.77 133.54,76.31 PR42.2 ; C317.1 78.87,47.91 78.4,47.44 v2(78.4,47.29) ; C71.1 99.23,106.29 v2(98.74,105.8) 98.05,105.8 C76.1 ; C342.1 95.67,41.02 v2(95.62,41.06) ; C390.2 202,23.96 C387.1 202.28,24.29 202.68,24.29 202.7,24.32 v1(202.73,24.32) ; C54.1 v1(99.76,106.97) 100.19,106.97 100.26,107.04 C60.1 ; v1(68.39,43.22) 67.76,42.59 R262.2 ; 147.28,30.52 147.44,30.36 R350.2 147.74,29.41 v2(147.74,28.82) ; v1(19.62,32.04) 19.04,32.04 PC78.2 ; v1(16.04,50.79) 16.31,50.79 16.64,50.46 C310.1 ; v1(55.56,12.05) 55.56,12.43 54.91,13.08 Q24.1 ; C45.2 C39.2 42.98,110.49 42.93,110.54 42.93,111.05 v1(43.24,111.37) ; C444.1 20.36,18.03 v1(19.78,18.03) ; C348.2 49.86,38.39 v1(48.75,38.39) ; SW1.3 171.43,23.02 170.78,22.36 168.82,22.36 168.72,22.47 ; C437.2 180.25,18.88 180.22,18.91 v2(180.2,18.91) ; R104.2 20.89,84.44 ; R35.1 132.26,104.27 v1(132.26,103.8) C92.2 ; v2(144.15,33.68) 144.15,33.81 144.45,34.11 PC71.1 ; v1(100.36,103.97) 100.65,104.25 C77.1 ; v2(141.21,29.6) 141.21,30.47 141.07,30.6 PR82.2 ; C184.2 50.89,83.86 51.74,83.01 v1(51.75,83.01) 51.75,82.99 50.74,81.99 C188.1 ; C213.2 50.87,72.76 51.88,72.76 52.31,73.19 v1(52.31,73.44) ; R281.2 211.2,38.01 v1(211.85,38.01) ; R228.2 40.77,47.68 v1(40.51,47.42) ; v2(178.57,23.68) 178.57,23.07 C389.1 ; v1(201.93,21.22) 201.89,21.22 201.81,21.14 201.39,21.14 L9.2 ; v1(20.81,31.58) 21.39,31.01 PC81.2 ; v1(51.88,72) 51.88,71.87 50.86,70.85 C216.1 ; C136.1 109.78,98.42 109.24,98.96 109.24,99.2 C118.1 109.02,99.52 v2(108.39,100.15) ; v1(24.19,30.97) 23.94,30.97 C368.1 22.8,31.35 PC82.2 ; v2(178.52,20.38) 178.52,20.2 178.01,19.69 C435.2 177.61,19.1 R440.1 C440.1 ; v1(42.6,81.92) 42.93,81.59 R113.2 ; v2(131.41,91.81) 131.41,91.8 C163.1 ; Q3.1 60.86,112.09 61.28,112.51 v1(61.28,112.76) ; v1(132.41,77.12) PQ6.1 ; R343.1 96.58,29.96 97.82,28.72 v1(97.82,28.36) ; v1(81.85,28) 81.85,28.05 82.24,28.44 C383.1 ; C261.2 51.12,61.33 51.75,60.69 52.39,60.69 52.77,61.07 v1(52.77,61.33) ; C385.2 203.88,26.87 203.47,26.45 203.31,26.45 203.26,26.4 v2(203.24,26.4) ; v1(64.15,97.27) 63.12,98.29 Q7.1 ; R464.1 v1(69.15,17.39) ; C204.2 57.22,75.39 v1(57.06,75.23) ; v2(203.11,21.27) 204.27,21.27 R421.1 ; v2(99.83,101.61) 99.59,101.61 C105.1 ; v2(138.61,109.41) 138.67,109.47 C47.2 ; v2(116.01,104.13) 116.01,104.6 118.72,107.31 R29.2 ; v1(39.3,35.92) 39.52,35.7 39.52,35.02 R294.2 ; R48.2 56.22,99.77 v2(56.22,99.99) ; v2(109.58,108.19) 109.08,108.69 C46.2 ; R375.2 206.75,27.09 207.19,26.66 v2(207.33,26.66) ; v2(201.82,29.09) 202.29,29.56 ; v2(68.46,111.52) 68.46,111.39 68.84,111.02 PC24.2 PC27.2 ; v1(52.62,59.76) 52.62,59.65 52.13,59.17 51.5,59.17 50.73,59.93 C267.1 ; v2(140.21,116.61) 140.21,116.84 140.59,117.22 C19.2 ; R289.2 211.14,35.46 211.57,35.04 v1(211.72,35.04) ; v1(71.82,116.67) 71.99,116.5 71.99,116.43 PR15.1 ; v2(97.98,96.68) 98.32,97.02 R64.1 ; C331.1 100.06,44.06 100.32,43.8 v2(100.32,43.42) 100.6,43.13 C339.1 ; v2(100.26,99.68) 100.26,99.26 C128.2 ; C371.2 182.3,31.76 181.92,32.14 v2(181.85,32.14) ; 131.89,22.94 v1(131.89,23.1) ; v1(211.67,29.27) 211.64,29.27 211.62,29.3 R355.2 ; PC68.2 24.37,34.91 v1(23.99,34.53) ; v1(73.32,19.13) 73.22,19.04 C439.2 ; v2(181.67,29.04) 181.67,29.45 182.19,29.97 C381.2 D10.2 ; v1(71.54,13.32) 71.56,13.35 C460.2 ; C362.2 109.78,34.77 v1(109.74,34.81) ; C59.2 v1(90.24,108.49) ; v1(123.25,95.34) 123.25,94.76 C158.1 ; Q20.1 174.45,18.79 v2(173.8,19.44) ; R62.2 57.97,97.55 v1(57.42,98.11) 57.36,98.11 R58.2 ; v1(45.91,26.28) 45.93,26.28 46.44,25.77 R386.2 ; R388.1 79.05,25.38 79.31,25.64 v1(79.49,25.64) ; v1(57.08,94.42) 57.08,94.6 56.57,95.12 C152.2 ; v1(54.06,64.91) 54.06,65.24 53.78,65.52 51,65.52 C235.2 ; v2(106.52,99.95) 106.91,99.56 C126.1 ; v1(129.65,23.1) 129.68,23.07 130.43,23.07 C391.2 ; v1(71.44,106.69) 71.44,106.67 71.46,106.64 71.46,106.54 71.72,106.28 PC29.1 ; C29.1 46.81,111.98 47.18,111.62 v1(47.18,111.49) ; Q8.1 89.28,95.91 89.44,96.07 89.44,96.1 v1(89.44,96.1) ; R86.2 90.13,92.71 89.51,92.09 v1(89.33,92.09) ; v1(16.04,51.42) 16.61,51.42 C304.1 ; v2(62.5,101.78) 62.5,101.17 C106.2 ; C143.2 100.39,95.96 100.47,95.88 v2(100.47,95.85) ; R376.1 87.67,27.07 v2(87.67,26.48) ; Q17.4 47.88,28.32 47.61,28.05 47.61,27.72 47.33,27.44 46.29,27.44 v1(45.99,27.75) ; C65.2 50.26,106.82 C58.2 50.26,107.82 v2(50.76,108.32) ; v1(52.34,84.95) 52.34,85.25 51.62,85.97 C178.2 ; C393.1 50.14,22.02 v2(49.8,21.68) ; v1(89.25,94.02) 89.09,94.02 88.78,93.7 Q9.1 ; v2(110.41,112.43) 110.25,112.27 C34.2 ; R223.1 16.47,49.23 16.19,49.52 15.89,49.52 ; PC47.2 139.26,70.45 v1(140.17,71.36) ; C153.2 55.43,95.11 55.81,94.73 v1(55.81,94.42) ; C453.1 202.25,16.28 202.13,16.41 202.13,17.23 v2(201.84,17.51) ; C133.1 102.78,99.02 103.18,99.42 C127.1 ; v2(97.97,100.83) C115.2 ; v1(100.52,76.8) 100.88,76.43 C202.2 ; C195.2 C194.2 28.85,80.29 R120.2 28.25,79.88 27.87,80.25 v1(27.62,80.25) ; v1(23.38,40.63) 23.38,40.94 23.76,41.32 PQ7.1 ; v2(97.12,105.8) 97.12,106.44 97.97,107.29 C57.1 ; C378.2 206.93,30.47 206.55,30.85 v1(206.44,30.85) ; v1(60,94.47) C155.2 C154.2 ; PC72.2 158.43,33.92 158.81,33.54 v2(158.81,33.23) ; v1(30.54,45.38) 29.73,44.56 29.73,43.34 30.54,42.53 R264.1 ; v1(137.65,34.78) 137.63,34.76 137.6,34.76 137.25,34.4 136.46,34.4 136.08,34.78 PQ9.1 ; PC79.1 144.71,30.72 143.25,29.26 PQ12.1 143.25,27.96 142.96,27.67 v2(142.96,27.57) ; C239.2 22.3,64.76 v1(21.78,64.25) ; v1(171.44,25.89) 171.51,25.97 SW1.4 ; v2(80.91,42.75) 80.62,43.04 80,43.04 C338.1 ; C166.1 131.61,90.4 v2(131.41,90.21) ; v2(77.3,48.25) 77.3,48.22 77.4,48.12 77.7,48.12 C316.2 ; C95.1 111.45,102.65 v2(112.11,103.31) ; v2(129.03,90.22) 128.98,90.28 C165.2 ; v1(107.91,39.08) 107.91,39.03 108.24,38.7 C347.2 ; v2(132.79,34) 132.86,34.06 133.54,34.06 PR74.2 ; PC25.2 v1(79.2,111.3) ; v1(135.7,79.11) 135.7,77.86 PQ5.1 ; C463.2 v1(57.34,12.05) ; v2(84.73,26.24) 84.78,26.24 85.06,25.96 R385.1 ; C44.2 103.98,108.63 v2(103.69,108.34) ; v2(156.98,33.23) 156.98,32.45 157.91,31.52 158.38,31.52 C373.2 ; PC14.2 v1(11.69,118.04) ; Q29.1 18.44,6.57 18.91,6.11 v1(19.06,6.11) ; R275.2 C343.2 211.09,39.94 v2(211.62,39.94) ; C377.2 v1(211.92,30.39) ; C354.1 51.23,35.55 51.55,35.24 52.06,35.24 52.44,34.86 v1(52.44,34.66) ; Q17.1 50.47,27.02 51.19,27.75 v1(51.19,27.93) ; D17.1 150.81,17.72 150.81,17.68 v2(151.42,17.07) 150.59,17.07 D18.2 ; v1(16.34,6.39) 16.23,6.5 Q28.1 ; C68.1 v1(90.87,106.03) ; C209.2 R158.2 59.12,73.37 59.6,72.88 v1(60.11,72.88) ; v1(26.25,28.56) PC87.2 ; v1(51.73,87.24) 50.96,88 C171.2 ; PC22.2 70.26,114.12 69.85,114.52 PC21.2 69.1,114.98 69.1,115.14 68.5,115.74 PC19.2 67.91,116.19 v1(67.58,116.19) ; R82.1 120.59,94.83 ; v1(52.37,67.09) 51.96,67.09 C224.2 C219.1 ; PC42.2 138.22,77.73 137.7,78.24 137.63,78.24 v1(137.58,78.29) ; v1(26.3,25.61) 26.25,25.67 PC101.2 PC99.2 v1(26.35,26.63) ; C61.2 R27.2 55.51,107.94 v1(55.51,108.34) ; v1(26.25,27.6) PC93.2 ; C116.2 C117.2 100.02,100.2 v2(100.14,100.32) ; C207.2 101.05,74.76 101.48,74.33 v2(101.48,74.13) ; R187.1 v1(109.41,69.73) ; C249.2 20.52,62.21 v1(20.38,62.34) ; v1(43.23,60.83) C251.2 ; v1(18.45,76.16) 17.71,75.42 C205.1 ; v1(41.46,67.1) 41.46,67.6 R189.2
  TOP w0.406: v1(12.48,18.66) 12.25,18.66 12,18.4 C438.1 ; v1(85.79,103.26) 85.79,102.51 C103.2
  TOP w0.457: v2(137.01,105.41) 137.01,105.4 C78.1 ; v1(134.68,53.83) 134.36,53.83 133.9,53.37 PC58.2 ; C32.2 43.87,111.37 v1(43.24,111.37) ; v1(142.55,50.1) 142.89,49.76 PC61.2 143.7,49.89 PC60.1 ; C79.1 140.21,105.4 v2(140.21,105.41) ; v1(121.09,95.31) 120.61,94.83 120.59,94.83 ; C15.2 137.74,116.68 v2(137.81,116.61) ; v2(35.88,120.53) 35.55,120.53 34.9,121.18 HE1.3
  TOP w0.508: v1(28.94,48.37) 29.52,48.37 C314.2 ; C37.1 55.75,111.49 v1(55.69,111.49) 56.19,111.99 C28.1 ; v1(29.78,68.69) 29.77,68.71 C220.2 C217.1 ; D20.2 18.6,12.31 20.13,10.78 v1(20.25,10.78) ; PC20.2 72.96,116.1 v1(72.96,116.52) ; v1(69.23,117.13) 69.18,117.08 C17.2 ; C345.2 v1(19.67,38.73) ; v1(29.8,71.36) 29.8,71.39 29.77,71.41 C214.2 ; v1(63.18,101.08) 63.18,100.57 63.06,100.45 C113.2 ; PC40.2 v1(23.18,89.14) ; v1(63.93,74.18) 63.93,75.02 R154.1 ; C193.2 48.84,82.13 v1(48.86,82.16) ; v1(196.66,32.83) 196.63,32.83 196.2,32.4 C367.1 ; v1(39.18,103.87) 39.18,103.5 39.48,103.2 C93.2 ; R496.1 15.82,6.17 16.04,6.39 v1(16.34,6.39) ; C238.2 51.12,64.5 51.37,64.76 v1(52.18,64.76) ; PR104.1 41.5,25.14 43.1,25.14 v1(43.78,24.47) ; PC105.2 22.66,23.49 22.92,23.23 22.92,22.82 v1(22.77,22.67) ; v1(29.98,77.48) 30.01,77.48 30.43,77.9 C199.2 ; C164.2 49.51,92.45 48.75,93.2 v1(48.75,93.36) 48.86,93.46 C161.2 ; v1(20.84,35.44) 20.84,35.74 C352.2 ; C441.2 v1(26.86,18.41) ; Y1.4 45.97,112.57 46.19,112.79 v1(46.32,112.79) ; v1(41.97,47.48) 42.22,47.73 R229.2 ; C330.1 52.89,45.08 v1(52.89,45.73) ; v1(44.11,31.28) 44.11,31.25 44.69,30.67 44.69,29.58 44.77,29.49 PC85.2 PC89.2 ; v1(16.44,45.1) 16.69,45.34 C328.2 ; Q30.1 v1(14.44,4.7) ; v1(121.75,95.34) 121.75,94.81 C157.1 ; v1(52.16,56.5) 51.24,56.5 50.62,57.13 C281.2 C274.1 ; PC98.2 18.57,27.16 17.97,27.16 17.71,27.42 v1(17.71,27.8) ; PC36.2 25.98,93.59 v1(26.35,93.59) 26.47,93.47 C162.2 ; C260.2 40.72,61.61 41.69,61.61 42.2,61.1 v1(42.2,60.83) ; C24.1 50.62,114.66 50.23,115.05 v1(50.1,115.05) ; C183.2 15.56,83.93 v1(15.94,84.31) ; PR73.2 29.48,33.98 v2(30.11,34.61) ; C192.1 45.52,80.5 v1(45.27,80.5) ; R209.1 29.23,52.95 28.94,52.65 v1(28.94,51.42) 29.67,51.42 C303.2 ; v1(44.26,48.88) 44,48.62 C321.2 ; R501.2 32.58,3.42 v1(32.95,3.42) ; C226.1 38.55,67.19 v1(38.62,67.12) ; C312.2 29.57,49.39 v1(28.94,49.39) ; C341.1 101.67,41.9 v1(103.24,41.9) 103.24,42.29 C337.1 ; v1(59.65,18.05) 59.65,18.42 C436.2 ; VC1.2 v1(13.65,85.97) ; PR45.1 139.86,65.26 v1(140.45,64.68) 140.23,64.46 PC48.2 ; PC103.2 22.46,25.05 v1(22.46,25.69) ; v1(40.51,47.42) 39.17,47.42 38.66,47.93 C320.2 ; v1(45.54,35.92) C357.1 ; C309.1 29.62,50.41 v1(28.94,50.41) ; D19.1 12.19,13.83 v1(12.63,13.83) ; C270.2 22.3,59.3 v2(22.92,59.3) ; v1(27.01,13.27) 27.48,13.74 C458.2 ; v2(100.56,112.43) 100.85,112.43 101.28,112 C35.2 ; PC38.2 21.14,89.24 v1(21.04,89.14) ; v1(17.08,84.77) 16.7,84.39 R102.2 ; v1(209.46,10.78) 209.36,10.78 209,11.14 C479.2 ; v1(24.27,89.14) 24.19,89.22 PC41.2 ; v2(24.17,51.88) 24.34,52.06 25.46,52.06 25.67,51.84 PR59.2 ; PR3.2 119.35,123.14 v1(119.7,122.8) ; C124.2 C123.2 39.17,99.56 38.47,100.26 v1(38.47,101.43) ; v1(22.92,97.65) 22.92,97.4 PC33.2 ; C169.2 25.97,89.39 v1(25.97,89.78) 26.47,90.27 C167.2 ; C119.2 32.42,99.56 32.45,99.59 ; v1(51.62,48.25) 50.86,47.48 C324.2 ; C336.1 106,43.21 v1(106.87,44.08) ; v1(9.43,12.35) 9.46,12.35 9.79,12.69 9.85,12.69 C462.1 ; v1(35.24,99.61) 35.29,99.56 C122.2 ; v1(41.85,35.92) R295.2 ; C464.2 v1(68.51,12.55) ; C492.1 v1(12.89,2.64) ; R105.2 21.91,84.44 22.11,84.64 22.11,85.38 v1(21.78,85.71) ; Y1.2 v1(43.22,113.67) ; v1(46.29,31.89) 46.28,31.88 C376.2 ; PR4.2 v1(126.77,123.01) ; PQ8.1 25.82,38.63 v1(25.71,38.52) ; C246.2 51.12,62.98 51.37,63.23 v1(52.23,63.23) ; C360.1 v1(32.95,33.51) ; v1(45.02,60.83) 45.02,61.21 C252.2 ; v1(45.62,14.87) 45.62,14.87 45.62,14.84 45.65,14.82 PQ13.1 ; v1(64.45,101.97) 64.45,100.35 C112.2 ; v1(34.28,26.99) 34.28,26.68 34.65,26.31 PC97.2 ; C280.2 21.87,56.87 v1(21.52,56.53) ; v1(89.48,104.13) C89.2 ; C335.1 103.6,43.21 104.25,42.56 104.81,42.56 105.14,42.23 v1(105.14,41.82) ; C97.2 30.41,101.85 v1(30.41,101.56) ; v1(34.1,62.34) 34.1,62.06 33.96,61.93 C257.2 ; 15.89,49.52 v1(15.3,49.52) ; HOLE5.1 215.74,32.97 216.77,31.94 v2(216.98,31.94) ; v1(46.88,115.32) C23.2 46.88,113.99 46.81,113.92 C25.1 ; v1(122.87,123.68) 123.11,123.45 PQ1.1 ; v1(28.33,12.94) 28.61,12.94 28.87,13.19 28.87,13.4 29.21,13.74 C459.2 30.22,13.74 31.84,15.35 v1(31.84,15.61) ; v1(88.73,100.98) 88.73,100.66 C114.2 ; C359.2 v1(31.94,33.51) ; 20.89,84.44 21.47,85.03 v1(21.47,85.08) ; v1(37.02,81.9) 37.26,81.66 C189.1 ; C186.1 23.95,82.15 v1(24.42,81.67) ; v1(25.87,91.93) 26.11,91.7 PC37.2 ; v1(24.06,53.57) C295.1 ; v1(40.19,67.09) 40.19,67.25 40.46,67.51 C227.2 ; C225.1 v1(35.87,67.14) ; v1(32.17,37.02) 31.71,36.56 31.54,36.56 31.29,36.31 30.28,36.31 29.77,36.82 C350.2 ; C258.1 35.74,62.21 36.26,62.72 v1(36.51,62.72) ; C452.1 15.56,16.66 v1(15.56,17.84) ; PR84.1 146.78,31.02 147.28,30.52 ; C319.2 37.66,47.73 38.82,46.57 v1(40.45,46.57) ; v1(39.99,82.23) 39.82,82.06 C190.1 ; v1(74.37,116.57) 74.23,116.72 74.23,117.71 74.61,118.1 PC17.2 ; C363.1 24.39,33.9 24.78,33.51 24.78,32.7 25.45,32.03 25.45,31.39 v1(25.41,31.36) ; v1(202.88,30.72) 203.57,30.03 C379.1 ; v1(22.11,89.14) 22.16,89.19 PC39.2 ; v1(36.05,48.8) 35.54,48.8 35.11,48.37 C318.1 ; v1(44.5,81.92) R114.2 ; v1(43.42,67.09) 43.42,67.42 43.23,67.61 R190.2 ; v1(83.08,71.17) 82.5,71.17 C215.1 ; C467.2 v1(62.8,12.56) ; PQ2.1 v1(122.28,120.72) ; PC92.2 18.93,27.8 v1(18.35,27.8) ; v1(31.05,33.51) 30.8,33.77 C358.2 ; v1(45.65,68.97) C228.2 ; v1(22.67,56.37) 22.91,56.13 C287.1 ; 32.45,99.59 32.47,99.56 C120.2 ; 32.45,99.59 v1(32.45,99.61) ; v1(41.6,81.91) C191.2 ; v1(26.35,94.22) 26.35,94.35 26.19,94.51 PC35.2 ; C426.1 10.38,19.39 v1(10.6,19.17) ; v1(29.82,74.42) R165.1 ; R99.1 28.89,84.95 28.21,85.63 v1(28.21,86.47) ; C346.2 29.65,38.34 29.14,38.85 v2(29.14,39.71) ; C22.2 v2(45.66,115.35) ; v1(37.77,35.9) 37.52,35.64 C355.2 ; C121.2 34,99.56 33.97,99.59 v1(33.97,99.61) ; v1(26.91,70.47) 26.23,70.47 25.72,69.96 C222.2 ; v1(42.98,35.92) C356.2 ; v1(23.56,97.65) PC34.2 ; v1(38.2,62.47) 38.3,62.37 C259.1 ; v1(46.55,48.88) C322.1
  BOTTOM w0.079: 90.93,33.58 90.93,33.38 91.16,33.15 91.16,33.12 91.18,33.05 91.18,32.86 91.09,32.67 91.09,32.38 91.37,32.09 91.37,31.74 ; v2(73.7,36.28) 73.8,36.38 74.29,36.38 74.43,36.52 75.04,36.52 U24.DM47 75.33,36.29 75.33,36.64 75.51,36.82 U24.DL47
  BOTTOM w0.102: U22.E17 107.59,96.23 v2(108,95.82) ; U24.DW48 75.27,32.15 75.27,30.42 75.55,30.14 75.55,29.37 75.25,29.07 74.94,29.07 74.77,29.24 R724.2 ; C651.1 92.13,28.57 92.31,28.38 92.31,27.21 92.09,26.99 91.68,26.99 91.12,27.55 90.49,27.55 90.29,27.74 90.29,30.14 90.46,30.32 90.46,32.12 90.61,32.27 90.61,33.26 90.93,33.58 U24.DU15 ; v2(99.63,36.16) 99.63,36.16 99.78,36.16 100.14,35.8 100.14,35.57 v2(100.95,34.76) 100.77,34.58 99.33,34.58 v2(98.87,35.04) ; 91.37,31.74 91.37,30.09 v2(91.5,29.96)
  BOTTOM w0.127: U24.AN49 74.63,64.98 72.22,64.98 v2(72.05,64.81)
  BOTTOM w0.152: v2(69.4,71.87) 69.53,71.74 70.93,71.74 72.7,69.97 74.62,69.97 U24.AC49 ; U24.AV49 74.62,62.46 73.94,62.46 73.81,62.33 v2(72.92,62.33) ; U24.CY45 76.6,41.96 v2(76.77,41.79) ; U24.BJ49 74.25,57.49 74.04,57.28 v2(73.85,57.28) ; v2(73.32,67.57) 73.39,67.57 73.44,67.52 74.62,67.52 U24.AH49 ; U24.BD49 74.62,59.96 73.65,59.96 73.31,59.61 v2(72.22,59.61) ; v2(72.57,75.24) 72.85,75.24 72.86,75.25 73.83,75.25 74.03,75.05 74.63,75.05 U24.N49 ; U24.BR49 74.62,54.96 73.71,54.96 v2(73.7,54.97) ; U24.DN19 88.93,36.07 88.66,35.8 v2(88.53,35.8) ; U24.BY49 73.49,52.48 v2(73.37,52.35) ; v2(73.42,40.88) 74.05,40.88 U24.DC49 ; v2(94.99,75.79) 95.02,75.79 95.05,75.77 95.99,75.77 U24.M5 ; U24.CU45 76.6,44.32 v2(76.85,44.58) 76.85,44.75 76.63,44.98 U24.CR45
  BOTTOM w0.178: v2(116.01,104.13) 116.01,104.03 115.84,103.85 115.05,103.85 U22.P26 ; v2(77.66,82.36) 77.66,82.33 78.1,81.89 78.16,81.83 78.16,81.04 U24.A42 ; PR219.2 136.95,45.45 v1(136.85,45.35) ; U24.CU47 U24.CU49 74.67,43.73 v2(73.71,43.73) ; PU12.36 133.02,28.71 PU12.22 ; U24.H49 73.54,77.64 72.96,78.22 v2(72.83,78.22) ; 7.73,18.53 7.61,18.65 CN14.A12 ; v2(73.85,78.42) 74.22,78.42 U24.G49 ; v2(80.91,82) 80.78,81.87 80.78,81.05 U24.A36 ; v2(79.49,81.97) 79.49,81.94 79.46,81.92 U24.A39
  BOTTOM w0.203: v1(16.7,26.45) 16.7,26.28 16.44,26.02 R774.1 ; v2(77.3,48.25) 77.3,48.21 76.6,47.5 U24.CK45 ; R691.2 197.84,36.49 v1(197.65,36.69) ; CN9.39 184.06,21.63 184.36,21.93 184.36,23.43 v2(184.39,23.46) 184.26,23.46 183.94,23.13 CN9.33 ; v1(113.26,63.75) 113.64,63.75 113.88,63.99 C580.2 ; CN9.51 184.69,18.63 185.08,18.25 v2(185.08,17.77) 184.75,17.77 184.11,17.13 CN9.57 ; v2(93.69,32.13) 93.69,32.18 93.55,32.32 U24.DW10 U24.DU10 U24.DT10 ; U24.CK9 94.08,47.06 94.4,46.73 v2(94.4,46.72) 94.4,46.72 94.08,46.4 U24.CM9 93.98,46.05 93.98,45.34 U24.CP9 94.08,45.21 v2(94.48,44.81) 94.08,44.41 U24.CT9 ; CN19.2 13.67,8.6 13.9,8.83 14.74,8.83 14.95,9.03 C722.2 ; v1(122.75,65.87) 122.75,66.14 122.49,66.41 PR162.1 ; R579.1 93.2,85.12 v1(93.03,84.95) ; v1(103.57,75.91) 103.54,75.93 R603.2 ; v2(76.08,34.91) 76.27,35.1 U24.DP45 ; C640.1 103.74,32.09 103.54,32.29 v1(103.54,32.57) ; R581.1 95.39,85.12 95.77,84.75 95.77,84.09 v1(95.83,84.02) 96.86,84.02 C725.1 ; v2(92.65,64.51) 93.09,64.51 U24.AR11 ; R685.1 68.26,38.85 v1(68.9,39.48) ; v2(82.95,39.62) 82.65,39.32 U24.DF33 ; U24.AL6 95.38,66.28 95.38,66.05 v2(95.68,65.75) 95.38,65.45 U24.AN6 ; U24.DE6 95.52,39.89 95.52,40.52 U24.DC6 ; C590.2 101.92,59.83 v1(101.79,59.7) ; U24.CR49 v2(73.65,44.98) ; D27.1 17.22,79.55 v2(17.16,79.49) 17.06,79.58 D26.1 ; v1(71.69,32.9) 71.54,32.9 71.28,32.65 R706.1 ; C582.2 v1(108.02,63.64) ; U34.3 20.1,22.34 v1(20.13,22.31) ; U24.E11 93.12,79.33 v2(93.12,78.35) 93.05,78.35 92.73,78.67 U24.F11 ; v2(78.62,35.11) 78.44,35.11 77.91,34.59 U24.DT42 ; U24.M10 93.4,75.45 v2(93.09,75.15) 92.75,74.8 U24.P11 ; U24.E6 v2(95.52,79.91) U24.C6 ; R656.2 61.51,44.9 v1(61.91,45.3) 62.31,44.9 R657.2 ; v2(109.71,43.22) 109.87,43.22 110.11,42.98 R670.1 ; U24.AR2 97.45,64.41 98.01,64.41 U24.AR1 98.25,64.46 98.47,64.68 98.48,64.68 v2(98.5,64.66) ; v1(91.83,85.58) 92.04,85.79 R572.1 ; v1(67.91,32.12) R708.2 ; v1(102.93,28.97) 103.14,28.97 C655.1 ; U24.DT32 83.07,34.15 v2(83.13,34.09) 83.07,34.03 U24.DU32 ; R700.2 192.01,33.51 v2(191.63,33.89) 191.81,34.07 192.14,34.07 R698.2 ; R672.2 66.51,41.54 66.87,41.18 v1(67.05,41.18) ; v2(73.75,37.27) 73.82,37.27 74.03,37.48 U24.DK49 U24.DL47 ; v2(73.8,72.6) 73.9,72.5 U24.V49 ; U24.BA2 U24.BA1 98.33,60.93 v2(98.47,60.93) ; U24.DW46 76.03,32.58 76.03,31.84 76.36,31.51 v2(76.69,31.51) ; U24.J6 95.36,77.4 v2(95.05,77.08) 94.71,76.75 U24.K8 ; U24.CG9 94.08,48.63 v2(94.31,48.4) 94.08,48.16 U24.CJ9 ; U24.CM45 76.56,46.18 v2(76.01,46.18) 75.37,46.18 U24.CM47 ; U24.CH3 96.61,48.38 v2(96.61,48.37) 96.58,48.37 96.58,48.38 U24.CH5 ; U24.CR32 82.94,44.98 83.15,44.78 v2(83.15,44.49) ; v2(17.97,19.01) 17.61,19.01 17.18,19.45 R817.1 ; v2(94.42,51.28) 94.42,51.03 U24.CC7 ; U24.DE45 76.62,39.99 76.62,40.75 76.6,40.78 76.6,41.22 U24.DB45 ; U24.CE49 73.68,49.98 73.37,49.67 72.84,49.67 72.71,49.54 v2(72.63,49.54) ; R728.1 88.55,29.98 88.85,30.28 v2(88.96,30.28) 89.13,30.28 89.5,29.91 R725.2 ; R662.2 64.23,43.65 64.5,43.37 v1(64.58,43.37) ; v2(92.83,62.2) 93.15,62.53 U24.AV11 ; U24.DN31 83.76,36.07 83.96,35.87 v2(83.96,35.85) ; C642.1 R713.2 71.57,31.13 72.83,32.4 v1(72.83,32.45) ; U24.DT15 v2(90.93,34.1) U24.DU15 ; C601.1 102.71,50.61 v1(102.32,50.23) 102.3,50.21 C726.1 R643.1 ; U24.BR45 77.02,54.98 77.07,54.93 v2(77.07,54.9) 77.1,54.9 77.13,54.88 77.13,54.61 U24.BT43 ; v2(95.03,71.4) 95.03,71.25 95.38,70.91 U24.AB6 95.45,70.92 U24.AB5 96.17,70.84 96.88,70.84 96.96,70.92 U24.AB3 ; R666.2 67.45,43.22 67.55,43.32 68.29,43.32 v1(68.39,43.22) ; U24.F8 94.81,78.7 v2(95.05,78.94) ; U24.DW27 U24.DU27 85.69,33.88 v2(85.89,34.09) 85.69,34.29 U24.DT27 ; U36.12 22.91,14.86 22.56,14.51 v1(22.46,14.51) ; R718.1 196.12,30.11 196.79,29.44 C648.1 ; U24.CJ42 78.08,47.73 78.4,47.4 v2(78.4,47.29) 78.4,47.21 U24.CL42 ; v2(181.82,16.22) 181.67,16.07 181.67,15.48 181.39,15.2 C707.2 181.39,14.36 181.62,14.13 CN9.69 ; U24.DG6 95.75,38.83 U24.DH5 96.35,38.74 v2(96.54,38.74) 96.83,38.74 U24.DH3 U24.DH1 97.99,38.48 v2(98.18,38.67) ; U24.CB37 79.95,51.64 U24.CA38 79.95,51.89 v2(79.75,52.1) ; D28.1 17.42,77.77 v2(17.13,78.07) 16.71,77.65 D29.1 ; CN12.4 v1(73.32,19.13) ; D30.1 17.07,75.87 v2(17.16,75.96) 17.52,76.32 D31.1 ; v2(36.38,123.05) 38.8,123.05 39.28,122.56 C498.2 ; U24.M5 U24.M3 ; U24.BD7 U24.BD6 ; C597.2 112.53,54.55 112.17,54.91 v1(111.86,54.91) ; U24.BP43 77.35,55.22 77.66,54.91 v2(77.66,54.9) 77.66,54.74 78,54.4 U24.BT42 ; v1(108.55,32.85) 108.56,32.83 108.56,32.57 108.77,32.36 C639.1 ; U24.D31 83.41,79.32 83.23,79.32 83.22,79.31 v2(82.98,79.06) 83.21,79.06 U24.F31 ; U24.DU37 80.32,33.74 80.32,34.02 v2(80.23,34.1) 80.32,34.19 80.32,34.45 U24.DT37 ; 94.73,64.46 94.72,64.45 U24.AR9 ; 94.73,64.46 95.02,64.75 95.02,64.81 v2(95.1,64.89) ; 94.73,64.46 U24.AR7 ; U24.A34 82.23,81.23 82.23,81.6 v2(82.47,81.84) 82.51,81.8 82.87,81.8 83.3,81.37 U24.A31 ; v2(93.11,77.06) 92.79,76.75 U24.K11 ; v2(96.91,52.13) 96.91,51.87 U24.CA3 96.96,51.35 96.96,50.97 U24.CC3 ; v2(101.51,73.14) 101.86,72.79 R610.2 ; U24.C31 83.5,80.07 83.17,79.74 v2(83,79.74) ; v2(95.57,29.41) 95.57,29.4 95.83,29.14 R736.2 ; v1(135.38,44.5) 135.38,43.21 135.65,42.94 PU10.14 137.13,42.94 v1(137.35,43.17) ; U24.DL13 91.62,36.72 91.31,36.42 91.26,36.42 90.91,36.07 U24.DN15 90.81,36.07 90.5,36.38 v2(90.37,36.38) ; PU11.8 144.6,33.28 144.48,33.4 144.42,33.4 v2(144.15,33.68) ; R785.1 20.35,23.81 v1(20.18,23.63) ; U24.B3 96.86,81.26 U24.A3 96.96,81.39 97.3,81.74 v2(97.3,81.9) ; v2(75.8,41.1) 75.46,41.1 U24.DB47 U24.DB49 ; R722.2 79.38,30.6 78.78,31.2 77.62,31.2 v2(77.31,31.52) 77.66,31.86 77.66,32.32 77.48,32.5 77.39,32.5 77.25,32.63 U24.DW44 U24.DV44 ; U24.BD42 78,59.71 78.3,59.41 v2(78.37,59.41) ; U24.BB7 94.73,61 v2(95.01,61.28) 94.73,61.55 U24.AY7 95.03,62.01 v2(95.03,62.09) ; U24.DN42 77.94,36.07 77.61,36.4 v2(77.61,36.42) 77.43,36.42 U24.DL44 ; C583.2 109.76,63.64 109.92,63.49 v1(110.15,63.49) ; JDIM1.44 57.51,40.2 57.43,40.28 56.78,40.28 56.45,39.95 v1(56.45,39.81) ; CN9.45 182.2,20.13 181.85,20.48 v2(181.85,20.86) ; v1(111.87,39.53) 112.2,39.86 R681.1 ; R716.2 66.31,30.59 65.87,31.02 v1(65.87,31.58) 65.92,31.63 66.49,31.63 R709.1 ; R593.2 101.91,79.62 v1(102.04,79.74) ; U24.DU20 88.31,33.96 v2(88.43,34.09) 88.31,34.21 U24.DT20 ; R600.2 101.08,77.43 100.85,77.66 v1(100.54,77.66) ; v2(73.66,32.4) 73.76,32.4 73.79,32.37 73.79,30.56 R724.2 ; U24.DB35 80.96,41.61 v2(80.96,41.74) ; R743.2 76.87,27.9 76.89,27.88 v1(76.89,27.85) ; v1(19.78,18.03) 20.01,18.03 20.33,18.35 R823.1 ; CN8.2 152.4,25.73 152.72,26.05 153.33,26.05 153.43,26.15 154.57,26.15 155.15,26.73 ; U24.DN24 85.97,35.75 v2(85.91,35.75) ; U24.CT37 80.61,44.07 80.93,44.39 v2(80.93,44.52) 80.93,44.66 80.6,44.98 U24.CR37 ; U24.CG39 79.3,48.92 79.04,49.18 v2(79.04,49.3) ; R789.1 78.07,23.4 v1(77.86,23.61) ; v2(95.63,73.2) 95.82,73.2 96.02,73.4 U24.U5 ; R665.2 62.67,43.27 v1(62.88,43.47) ; C654.1 93.2,28.74 v2(93.2,28.21) ; v2(94.1,75.23) 94.2,75.23 94.56,74.87 U24.P8 ; U24.G5 96.43,78.68 v2(96.59,78.68) 96.75,78.68 U24.G3 ; v2(93.21,79.86) 93.05,80.02 U24.C11 U24.A11 ; U24.B2 97.78,80.82 97.98,81.01 v2(98,81.01) ; U24.DW20 88.58,32.69 88.58,31.99 89.06,31.51 89.19,31.51 89.35,31.34 89.37,31.34 89.38,31.33 v2(89.39,31.33) ; U24.CN37 U24.CL37 80.31,47.1 v2(80.31,47.27) 80.31,47.44 U24.CJ37 U24.CG37 80.6,49.13 80.77,49.3 v2(80.77,49.35) 80.6,49.52 U24.CE37 ; U24.J10 93.32,77.72 v2(93.14,77.72) ; v1(116.51,34.5) PR240.2 ; v2(94.17,27.77) 94.03,27.91 R741.2 ; U24.DA10 93.62,42.03 U24.DA9 94.08,41.73 94.28,41.93 94.4,41.93 v2(94.42,41.95) ; D25.1 16.57,81.55 v1(16.93,81.9) ; C679.2 180.05,22.31 179.73,22 v2(179.73,21.79) ; U24.DC5 U24.DC3 ; 64.35,27.49 C665.1 C664.1 ; C720.2 13.65,10.81 13.5,10.65 v1(13.5,10.45) 13.5,10.27 13.68,10.1 C721.2 ; U24.CK49 74.65,47.37 74.32,47.05 U24.CL49 73.98,46.85 73.87,46.95 v2(73.85,46.95) ; v2(93.09,74.42) 93.09,74.39 92.78,74.08 U24.T11 U24.V11 ; v2(78.97,45.48) 78.97,45.57 79.3,45.9 U24.CN39 ; v2(95.06,64.08) 95.06,63.87 U24.AT7 U24.AV7 ; v1(76.16,24.83) R778.2 ; U24.CY49 73.88,42.47 73.72,42.31 v2(73.59,42.31) ; v2(73.49,34) 73.65,34 73.67,34.02 73.72,34.02 73.92,34.22 74.02,34.22 74.2,34.4 U24.DT49 ; U24.U3 97.06,73.4 96.9,73.55 v2(96.62,73.55) 96.6,73.58 96.6,73.91 U24.R3 ; JDIM1.48 57.5,41.2 57.14,40.84 56.51,40.84 v1(56.37,40.98) ; U24.DJ33 82.65,38.02 82.97,37.7 v2(82.97,37.69) 83.19,37.69 83.52,38.02 U24.DJ31 ; v2(83,80.44) 83.27,80.72 U24.B31 ; U24.AG9 U24.AG11 93.15,67.98 92.65,67.47 v2(92.62,67.47) ; U24.DR49 73.92,35.05 73.88,35 v2(73.85,35)
  BOTTOM w0.229: U17.25 211.52,15.51 R834.2 ; PU15.8 44.68,17.02 44.95,16.74 45.41,16.74 45.6,16.55 45.6,16.09 45.81,15.89 v1(46.52,15.89)
  BOTTOM w0.254: U24.DB38 79.95,41.35 79.52,41.78 v2(79.16,41.78) ; U24.AV45 76.77,62.65 77.31,62.65 U24.AV43 77.74,63.01 v2(77.74,63.03) ; v2(95.22,69.48) 95.22,69.48 95.22,69.45 95.38,69.3 U24.AE6 ; JDIM1.14 56.22,32.71 54.6,34.33 54.6,35.72 54.93,36.05 v1(55,36.05) ; v1(112.46,92.32) 112.64,92.5 112.64,93.67 U22.B23 ; U24.H21 88.08,77.52 v2(87.67,77.79) 88.08,78.09 U24.G21 87.68,78.41 87.68,78.43 87.68,78.43 v2(87.67,78.44) ; U24.BA45 76.07,61.24 v2(76,61.16) 75.92,61.24 U24.BA47 ; JDIM1.72 54.32,47.2 53.66,47.87 v1(53.66,48.25) ; U24.DL10 93.63,36.72 93.91,36.99 v2(94.12,36.99) 94.14,36.99 94.19,37.04 94.23,37.04 94.52,37.34 U24.DK8 ; v2(97.12,98.36) 97.12,98.36 U22.H5 ; v2(90.8,82.6) 90.7,82.5 90.14,82.5 89.92,82.28 U24.A17 U24.B17 ; U26.3 109.14,48.42 109.39,48.17 v1(109.76,48.17) ; JDIM1.40 57.44,39.2 57.42,39.18 56.75,39.18 56.45,39.48 v1(56.45,39.81) ; U24.AG39 79.3,68.28 v2(79.59,68.57) 79.95,68.21 U24.AG38 80.36,68.11 80.41,68.06 ; v2(87.62,81.04) 87.63,81.04 87.67,81.05 88.08,80.76 88.08,80.76 U24.B21 88.08,80.67 v2(87.67,80.38) 88.08,80.11 U24.C21 ; v2(79.7,71.3) 79.95,71.55 U24.Y38 ; v2(79.7,71.3) 79.3,70.9 U24.AB39 ; v2(79.7,71.3) 79.95,71.04 U24.AB38 ; CN15.18 128.35,18.04 128.76,18.45 129.15,18.45 129.22,18.38 ; v1(54.54,78.78) 54.54,78.73 55.07,78.2 JDIM1.188 ; U22.E2 95.08,96.23 93.51,96.23 v2(93.48,96.25) ; U24.DK3 U24.DK4 96.05,37.24 v2(95.95,37.35) 95.46,37.35 U24.DK6 ; U24.BM47 75.44,56.34 75.8,56.34 75.81,56.33 v2(75.91,56.33) 76,56.33 76.1,56.23 U24.BM45 76.6,56.41 v2(76.95,56.77) ; U24.DG47 75.76,38.71 v2(75.81,38.66) 75.81,38.62 76.27,38.15 U24.DH45 ; JDIM1.103 48.93,54.95 v1(48.7,54.72) ; v1(53.48,32.93) 53.48,32.45 52.77,31.74 51.5,31.74 51.22,31.45 JDIM1.9 ; v1(57.06,75.23) 57.08,75.2 JDIM1.176 ; 78.4,52.09 78.55,51.93 78.55,51.73 U24.CA41 ; 78.4,52.09 78.36,52.05 78.36,51.99 U24.CA42 ; 78.4,52.09 v2(78.4,52.11) ; v2(90.39,78.91) 90.39,78.94 U24.D17 U24.C17 ; PC185.2 140.2,62.24 v1(140.7,62.24) ; 129.22,18.38 v2(129.32,18.38) ; 129.22,18.38 128.85,18 CN15.17 ; U24.E34 v2(82.01,79.8) U24.C34 ; CN15.4 135.35,18.03 135.57,18.25 v2(135.57,18.32) ; U24.AV42 78.34,62.96 v2(78.34,63.03) ; D32.1 17.14,74.54 v2(16.98,74.38) ; JDIM1.167 51.37,72.95 51.88,72.45 v1(51.88,72) ; JDIM1.73 51.34,47.46 51.62,47.74 v1(51.62,48.25) 51.62,48.37 51.54,48.46 JDIM1.77 ; v1(51.55,90.84) 51.43,90.95 JDIM1.239 ; JDIM1.205 51.2,82.46 51.4,82.26 52.49,82.26 53.02,82.79 v1(53.02,83.02) ; v1(53.5,76.95) 53.5,77.48 52.53,78.46 JDIM1.189 ; v2(95.08,58.51) 94.73,58.15 U24.BG7 94.91,57.87 94.91,57.31 U24.BJ7 ; U24.C14 91.57,79.74 U24.D13 U24.C13 v2(91.81,81) ; U24.V45 76.6,72.87 v2(76.94,73.22) ; U22.E8 100.41,95.89 100.46,95.89 100.47,95.88 v2(100.47,95.85) ; v2(133.49,18.32) 133.51,18.32 133.85,17.99 CN15.7 ; v2(78.22,44.49) 78.22,44.36 78,44.14 U24.CT42 ; U24.T41 78.65,73.75 v2(78.93,74.03) 78.65,74.31 U24.P41 ; v2(112.11,100.83) 112.11,100.83 U22.L23 112.95,101.67 113.71,101.67 U22.L25 ; CN2.6 46.35,107.67 47.03,108.35 ; PC234.2 144.12,33.7 v2(144.15,33.68) ; U24.T43 77.35,73.65 v2(77.02,73.98) 76.77,74.23 76.77,74.86 U24.N45 ; U24.AB11 93.11,70.52 v2(93.11,70.49) ; U24.C16 U24.A16 90.57,81.72 90.82,81.96 v2(90.82,81.99) ; v1(52.31,38.24) 52.31,38.26 51.62,38.95 JDIM1.39 ; U24.J15 90.94,77.4 v2(91.28,77.06) 91.61,77.4 U24.J13 ; U24.T45 76.28,73.75 76.23,73.8 v2(76.03,73.8) 75.95,73.8 75.9,73.75 U24.T47 ; JDIM1.248 56.83,93.21 55.81,94.22 v1(55.81,94.42) ; JDIM1.172 56.75,74.2 56.53,73.98 56.53,73.72 56.45,73.65 v1(56.45,73.6) 56.45,73.39 56.75,73.09 57.29,73.09 57.41,73.2 JDIM1.168 ; v2(78.92,57.59) 78.65,57.86 U24.BG41 ; v2(78.92,57.59) 78.65,57.32 U24.BJ41 ; v2(78.92,57.59) v2(79.74,57.59) U24.BH37 ; v2(91.13,76.1) 90.93,76.3 90.93,76.45 U24.K15 90.62,76.76 90.62,76.76 U24.J16 90.27,77 89.92,77.36 U24.H17 ; JDIM1.192 57.24,79.21 57.09,79.36 56.48,79.36 v1(55.89,78.78) ; v2(85.83,81.02) 85.86,81.02 85.89,81 85.89,81 86.25,80.71 U24.B24 86.26,80.7 v2(85.84,80.38) 86.26,80.08 U24.C24 ; v2(94.38,43.86) 94.35,43.86 94.08,43.59 U24.CV9 ; v2(93.69,32.13) 93.69,31.96 95.08,30.57 95.62,30.57 96.4,29.78 96.79,29.78 97.82,28.74 v1(97.82,28.36) 97.82,27.96 C657.1 97.59,27.29 97.39,27.08 97.39,25.64 97.42,25.61 97.42,25.06 97.67,24.8 100.11,24.8 100.39,25.08 v1(100.39,26.28) ; JDIM1.78 57.42,48.71 56.96,48.25 v1(55.61,48.25) ; JDIM1.99 51.76,53.95 52.26,53.45 v1(52.26,53.15) ; 76.08,81.91 76.08,82 75.8,82.28 75.78,82.28 75.75,82.31 v2(75.75,82.33) ; 76.08,81.91 76.48,81.52 76.58,81.52 U24.A44 ; 76.08,81.91 U24.A46 ; JDIM1.214 57.5,84.7 57.26,84.95 v1(57.08,84.95) ; JDIM1.57 53.37,43.45 53.66,43.17 v1(53.66,41.95) ; JDIM1.56 57.47,43.2 57.43,43.17 56.37,43.17 55.71,43.83 v1(55.71,43.96) 55.71,44.08 56.14,44.51 56.99,44.51 57.29,44.2 JDIM1.60 ; JDIM1.193 51.18,79.46 51.55,79.82 52.08,79.82 52.44,79.46 v1(52.44,79.28) ; 78.97,63.03 78.97,62.87 78.72,62.62 U24.AV41 ; 78.97,63.03 v2(78.97,63.03) ; 78.97,63.03 79.3,62.7 U24.AV39 ; v1(51.73,87.24) 51.62,87.24 51.34,86.95 JDIM1.223 ; JDIM1.180 57.45,76.2 57.27,76.39 55.99,76.39 55.66,76.72 v1(55.66,76.97) 55.66,77.08 56.09,77.51 57.03,77.51 57.34,77.2 JDIM1.184 ; U24.DT6 95.17,34.26 U24.DT7 ; JDIM1.222 56.75,86.7 56.32,87.13 v1(56.32,87.16) ; v2(112.93,98.37) U22.H23 ; v1(111.86,54.91) 112.42,55.47 Q39.4 ; U24.BV11 92.92,53.71 92.8,53.71 92.77,53.73 v2(92.75,53.73) ; U24.BC37 79.95,59.87 U24.BD38 79.95,59.65 v2(79.74,59.44) 79.74,59.46 79.33,59.87 U24.BD39 79.3,59.9 79.21,59.99 78.77,59.99 U24.BD41 U24.BD42 U24.BD43 77.32,59.87 77.21,59.99 U24.BD45 ; JDIM1.238 57.37,90.7 57.16,90.92 v1(57.14,90.92) ; CN2.18 52.35,107.65 53.02,108.32 v2(53.02,108.44) 53.48,108.44 53.85,108.08 CN2.21 ; U24.G36 80.9,78.34 v2(81.24,78) ; v1(112.08,60.03) 112.08,60.06 112.57,60.55 Q38.4 ; v2(79.78,73.14) U24.U37 80.87,72.68 U24.V36 ; 80.41,68.06 U24.AF37 80.33,68.65 80.33,69.4 U24.AD37 ; 80.41,68.06 U24.AH37 U24.AK37 U24.AM37 80.41,65.83 v2(79.82,65.83) 79.95,65.7 U24.AN38 ; v1(51.62,45.73) 51.62,45.71 51.37,45.45 JDIM1.65 ; U24.AD34 82.19,69.55 v2(82.19,69.21) ; CN14.A1 8.31,13.15 v1(8.52,12.94) ; v1(55.05,87.18) 55.05,86.65 56,85.7 JDIM1.218 ; U24.AB42 U24.AB41 78.65,70.95 78.95,71.26 v2(78.95,71.36) ; PC260.2 168.71,22.18 168.83,22.06 169.93,22.06 PC259.2 ; JDIM1.5 52.4,30.45 v1(53.15,31.2) ; U22.H2 95.13,98.71 v2(94.73,98.31) ; v2(73.75,37.27) 73.04,37.27 72.71,36.94 68.24,36.94 68.01,37.17 v1(67.98,37.17) 67.98,37.21 67.73,37.46 C626.1 66.3,37.46 66.08,37.68 64.03,37.68 63.87,37.51 63.87,36.21 v1(64.27,35.8) 63.87,35.39 63.87,33.72 64.22,33.36 65.34,33.36 65.47,33.23 R701.1 66,33.58 66.36,33.94 v1(66.53,33.94) 66.61,33.94 66.64,33.96 67.19,33.96 C632.1 ; HD1.6 214.45,13.82 214.82,13.45 ; U24.R37 80.64,74.29 v2(80.9,74.29) 80.9,73.62 U24.T36 ; v1(55.18,51.8) 55.18,51.55 56.02,50.71 JDIM1.86 ; JDIM1.252 57.3,94.21 v1(57.08,94.42) ; U24.H24 v2(85.83,77.79) U24.G24 v2(85.83,78.44) ; U24.BU45 76.14,53.73 75.98,53.89 v2(75.95,53.89) 75.93,53.89 75.76,53.73 U24.BU47 ; Y4.4 99.55,27.03 100.15,27.64 C658.1 100.15,27.91 99.68,28.38 v1(99.38,28.38) 99.57,28.58 99.57,29.82 98.46,30.92 96.84,30.92 96.35,31.41 95.44,31.41 94.76,32.09 94.76,32.1 v2(94.78,32.13) ; v1(52.44,34.66) 52.44,34.45 51.94,33.95 JDIM1.19 ; v1(52.26,54.85) 52.26,55.23 51.54,55.95 JDIM1.107 ; JDIM1.227 51.2,87.95 51.35,88.11 51.99,88.11 52.94,89.06 v1(52.94,89.11) ; JDIM1.231 51.44,88.95 v1(51.62,89.14) ; JDIM1.15 51.55,32.95 v1(51.57,32.93) ; v2(92.62,57.26) 92.62,57.14 93.15,56.6 U24.BM11 ; 47.03,108.35 47.55,107.83 47.6,107.83 47.85,107.58 CN2.9 ; 47.03,108.35 v1(47.03,108.36) ; v2(97.97,100.83) 97.95,100.83 U22.L5 ; U25.3 110.28,50.85 109.74,50.3 v1(109.61,50.3) ; U24.AG42 78.29,68.4 78.29,68.54 78.32,68.57 v2(78.34,68.57) 78.34,68.41 U24.AG41 ; Q35.1 107.74,67.28 v1(107.5,67.04) ; U24.BB11 93.03,60.66 v2(93.03,60.34) ; JDIM1.251 51.25,93.95 51.33,93.88 51.97,93.88 52.21,93.64 v1(52.21,93.36) 52.21,93.18 51.8,92.77 51.4,92.77 51.21,92.95 JDIM1.247 ; U24.AT45 v2(75.94,63.74) U24.AT47 ; v2(80.43,36.36) 80.51,36.36 U24.DN36 ; U22.E25 113.74,96.67 v2(113.74,96.73) ; v2(79.75,52.1) U24.BY37 U24.BW37 ; U24.L43 U24.L42 78,76.4 v2(78.38,76.78) 78.38,76.61 U24.L41 U24.L39 79.3,76.32 v2(79.69,75.93) ; U24.L43 77.15,76.54 77.15,76.82 76.6,77.37 U24.H45 76.6,77.92 76.77,78.09 76.77,78.35 77.13,78.7 v2(77.13,78.98) 76.84,79.27 U24.D44 ; U24.L43 77.34,76.34 U24.L45 76.42,76.52 v2(76.16,76.52) 75.51,76.52 U24.L47 ; v2(105.45,96.65) U22.E14 ; v2(112.14,106.68) 112.53,106.29 U22.U23 ; JDIM1.6 57.5,30.71 57.39,30.59 56.96,30.59 56.58,30.97 56.58,31.1 v1(56.53,31.15) 56.53,31.45 56.78,31.71 JDIM1.10 ; JDIM1.230 57.41,88.7 56.52,89.6 56.02,89.6 55.68,89.26 v1(55.68,89.08) 55.68,88.77 56.2,88.25 56.45,88.25 57,87.7 JDIM1.226 ; U24.AN42 77.79,65.58 77.79,65.65 v2(77.68,65.76) 77.35,65.43 U24.AN43 77.25,65.46 76.85,65.46 76.6,65.2 U24.AN45 ; U24.AL45 76.55,66.19 75.94,66.19 v2(75.91,66.23) 75.87,66.19 75.38,66.19 U24.AL47 ; v1(72.2,80.6) 72.2,80.33 72.62,79.91 73.8,79.91 74.1,79.61 U24.D49 ; v2(136.61,18.32) 136.61,18.3 136.85,18.06 CN15.1 ; JDIM1.202 57.51,81.7 57.43,81.78 55.55,81.78 55.05,82.28 v1(55.05,83.02) ; v1(107.91,41.24) 108.05,41.1 Q40.4 108.53,40.63 108.78,40.37 109.41,40.37 109.83,39.95 Q40.1 ; v2(107.63,93.2) 107.63,93.71 U22.B17 ; JDIM1.93 51.22,52.46 51.37,52.31 52.89,52.31 53.53,51.68 v1(53.53,51.55) ; v1(56.37,40.98) 56.37,41.95 56.63,42.2 JDIM1.52 ; U22.E11 v2(102.92,95.86) ; v1(52.82,90.84) 52.82,90.46 52.31,89.95 JDIM1.235 ; JDIM1.85 51.5,50.46 v1(51.55,50.41) ; v1(55.02,37.66) 55.02,37.23 55.61,36.64 57.39,36.64 57.46,36.71 JDIM1.30 ; U24.CV5 v2(96.59,43.43) U24.CV3 ; U24.AD11 92.78,69.87 93.12,69.52 v2(93.12,69.5) 93.15,69.5 93.15,69.5 93.15,69.66 U24.AD10 ; CN6.20 212.52,38.4 212.13,38.01 v1(211.85,38.01) ; JDIM1.102 57.5,54.7 56.98,54.19 56.22,54.19 56.07,54.34 v1(56.07,54.72) 56.07,54.8 56.48,55.21 56.93,55.21 57.43,55.7 JDIM1.106 ; U24.AV38 79.63,62.94 79.63,63.02 v2(79.62,63.03) 79.67,63.08 U24.AU37 ; JDIM1.197 51.19,80.46 51.66,80.92 v1(51.66,81.16) 51.37,81.46 JDIM1.201 ; U22.B11 102.67,93.71 v2(102.67,93.31) ; v1(54.23,87.17) 52.77,85.71 51.5,85.71 51.24,85.45 JDIM1.217 ; U24.BF7 94.94,59.17 94.94,59.67 U24.BD7 95.01,60.15 v2(95.01,60.36) 94.73,60.64 U24.BB7 ; JDIM1.209 51.37,83.46 51.75,83.07 v1(51.75,83.01) ; U22.Y26 115.12,108.5 116.54,108.5 116.85,108.81 v2(116.85,108.96) ; JDIM1.90 56.67,51.71 55.69,52.69 55.48,52.69 55.05,53.12 v1(55.05,53.15) ; v2(76.95,56.77) 76.95,56.81 77.27,57.13 U24.BJ43 ; v2(76.95,56.77) 76.6,57.12 U24.BJ45 ; CN6.27 211.86,34.9 v1(211.72,35.04) ; v2(78.29,78.62) 78.29,78.73 78.15,78.87 U24.E42 ; JDIM1.243 52.28,91.95 53.48,93.15 v1(53.48,93.36) ; v1(55.74,90.87) 55.74,90.84 56.39,90.19 56.79,90.19 57.28,89.7 JDIM1.234 ; v2(80.91,42.75) 80.89,42.75 80.89,42.9 81.14,43.15 U24.CV35 81.3,43.2 81.85,43.2 U24.CV34 ; U24.DT3 96.78,34.65 v2(97.09,34.96) ; v2(97.98,96.68) U22.E5 ; v1(48.75,38.39) 48.86,38.39 49.29,37.95 JDIM1.35 ; JDIM1.1 51.62,29.45 51.75,29.32 51.75,29.22 v1(52.03,28.94) ; JDIM1.26 57.5,35.71 57.29,35.5 56.63,35.5 56.32,35.8 v1(56.32,36) ; U24.DD37 80.6,40.17 80.87,39.9 v2(80.92,39.9) 80.9,39.87 80.9,39.87 81.25,39.52 U24.DF35 ; v2(109.89,92.57) 109.99,92.67 U22.B20 ; v1(56.78,80.78) 57.36,80.21 JDIM1.196 ; U24.AH45 76.6,67.76 76.8,67.96 v2(76.8,68.31) 77,68.11 U24.AG43 ; U27.3 106.68,48.49 106.36,48.17 104.79,48.17 v1(104.07,48.88) ; v2(93.54,93.19) 93.55,93.19 94.19,93.83 U22.B1 ; U24.DF39 79.49,39.31 v2(79.49,38.95) ; U24.H36 81.19,77.38 v2(81.24,77.38) ; JDIM1.181 51.24,76.46 51.35,76.34 52.74,76.34 53.38,75.7 v1(53.38,75.5) ; U24.E36 80.85,79.09 v2(81.21,78.73) ; U22.B27 115.63,93.73 v2(115.63,93.31) ; JDIM1.31 49.22,36.95 49.08,36.82 49.08,36.56 48.7,36.18 48.7,35.62 v1(48.73,35.6) 48.73,35.55 49.32,34.95 JDIM1.23 ; CN9.63 182.28,15.63 182.12,15.8 182.12,15.93 v2(181.82,16.22) ; JDIM1.82 57.15,49.71 57.12,49.68 55.35,49.68 v1(54.54,50.48) ; v1(52.26,36.94) 52.26,36.69 51.53,35.95 JDIM1.27 ; U24.AA45 75.99,71.25 v2(75.88,71.36) 75.77,71.25 U24.AA47 ; U24.CE9 94.08,49.97 94.4,50.29 v2(94.4,50.37) ; v2(94.38,42.91) 94.38,42.87 94.08,42.57 U24.CY9 ; U24.CG47 75.38,48.78 v2(75.86,48.78) 75.91,48.73 U24.CG45 77.18,48.73 U24.CG43 ; v2(181.42,25.18) 181.39,25.21 181.39,25.61 182.41,26.63 CN9.19 ; JDIM1.18 56.64,33.71 55.89,34.45 v1(55.89,34.66) ; v2(97.61,92.87) 97.61,93.8 U22.B5 ; U24.H31 U24.G31 U24.F31 ; CN9.7 184.08,29.63 184.34,29.88 184.34,30.34 184.76,30.76 v2(184.76,31.23) 184.65,31.13 CN9.1 ; U24.DJ36 80.77,38.02 v2(80.44,37.69) ; CN2.3 44.85,106.37 v1(44.77,106.29) ; v1(57.16,34.71) JDIM1.22 ; JDIM1.81 52.07,49.46 52.89,48.63 v1(52.89,48.25) ; v1(55.71,84.95) 55.71,84.9 56.5,84.11 56.78,84.11 57.08,83.81 57.34,83.81 57.44,83.7 JDIM1.210 ; PU14.2 163.94,23.25 164.32,23.63 164.32,23.95 164.66,24.29 165.87,24.29 166.08,24.09 v2(166.08,23.91) ; v1(52.26,40.22) 52.18,40.14 52.18,40.06 51.88,39.75 51.41,39.75 51.2,39.95 JDIM1.43 ; U24.BF45 76.51,58.82 v2(75.93,58.82) 75.42,58.82 U24.BF47 ; v1(114.16,57.52) 114.02,57.38 Q39.1 ; v1(8.65,18.91) 8.65,18.91 8.65,18.88 8.29,18.53 7.73,18.53 ; v2(78.34,40.8) 78,40.46 U24.DD42 ; JDIM1.36 57.46,38.2 56.98,37.73 56.98,37.71 56.96,37.68 v1(56.93,37.68) ; U24.F47 76.02,78.89 v2(76.03,78.88) 76.04,78.87 U24.F45 ; PU9.19 v1(137.06,69.54) ; v2(79.79,44.51) 79.75,44.51 79.33,44.09 79.33,44.07 U24.CT39 ; JDIM1.68 57.47,46.2 57.42,46.26 55.98,46.26 55.69,45.96 v1(55.69,45.71) 55.69,45.58 56.06,45.2 JDIM1.64 ; Q35.4 110.21,68.58 110.02,68.77 110.02,69.63 v1(110.09,69.71) ; U24.DC6 95.62,40.9 v2(95.62,41.06) 95.62,41.07 95.65,41.1 95.95,41.1 U24.DC5 ; JDIM1.206 57.38,82.7 57.16,82.49 56.5,82.49 56.32,82.66 v1(56.32,83.04) ; CN2.15 50.85,108.23 v2(50.76,108.32) 50.05,108.32 49.38,107.64 49.38,107.15 CN2.12 ; JDIM1.94 56.77,52.71 v1(56.32,53.15) 56.63,53.15 56.68,53.2 56.96,53.2 57.46,53.7 JDIM1.98 ; U24.DE33 82.61,39.97 v2(82.95,39.62) ; v2(79.61,54.74) 79.56,54.69 79.56,54.65 U24.BT39 79.29,54.4 78.65,54.4 U24.BT41 ; v1(52.23,76.97) 52.23,77.07 51.82,77.49 51.28,77.49 51.24,77.46 JDIM1.185 ; v1(51.62,75.07) 51.51,74.95 JDIM1.175 ; v1(57.17,92.13) 57.24,92.21 JDIM1.244 ; v2(79.72,72.23) U24.W37 80.42,72.23 U24.Y36 ; v1(52.89,45.73) 52.89,45.96 52.39,46.47 51.27,46.47 51.25,46.45 JDIM1.69 ; U22.A2 95.13,92.95 94.89,92.71 v2(94.52,92.71) ; JDIM1.89 51.4,51.46 51.5,51.55 v1(51.55,51.55) ; v2(116.44,111.6) 116.26,111.41 115.16,111.41 U22.AC26 ; v1(109.74,34.81) 109.74,36 110.31,36.58 U29.3 ; U24.AN41 v2(79.09,65.8) 79.3,65.59 U24.AN39 ; v2(77.68,71.41) 77.68,71.43 U24.Y43 ; U24.AC45 76.73,70 77.02,70.29 v2(77.02,70.39) 77.02,70.76 77.12,70.85 U24.AB43 ; U24.CB47 75.81,51.23 v2(75.84,51.2) 75.89,51.2 75.91,51.23 U24.CB45 76.6,50.93 77.11,50.43 77.11,50.26 v2(77.13,50.23) 76.85,50.23 U24.CE45 ; HD1.9 214.82,12.32 ; v2(191.93,26.62) 191.84,26.62 191.59,26.88 CN9.18 ; U24.M36 81.02,75.74 v2(81.34,75.42) ; U24.L36 80.94,76.39 v2(81.24,76.69) 80.89,77.04 U24.J36 ; v2(55.64,29.2) 55.64,29.65 55.76,29.78 57.16,29.78 57.24,29.71 JDIM1.2 ; JDIM1.213 52.02,84.45 52.34,84.77 v1(52.34,84.95) ; v2(77.78,52.11) 77.75,52.09 77.75,52.08 77.72,52.05 77.72,51.93 77.43,51.64 U24.CA43 76.6,52.39 U24.BY45 ; J1.2 11.63,9.5 v1(11.87,9.26) ; v1(48.75,40.52) 48.8,40.52 49.24,40.95 JDIM1.47 ; v2(73.7,36.28) 73.44,36.28 72.76,35.6 69.07,35.6 68.32,34.85 67.93,34.45 v1(67.91,34.45) ; JDIM1.51 51.57,41.95 51.57,41.95 v1(51.62,41.95) ; U24.C39 v2(79.46,79.87) U24.E39 ; v1(52.31,73.44) 52.31,73.57 51.86,74.03 51.37,74.03 51.3,73.95 JDIM1.171 ; U24.CN3 96.97,45.79 v2(96.59,45.79) 96.21,45.79 U24.CN5 ; U24.AF45 75.96,68.74 v2(75.88,68.82) 75.81,68.74 U24.AF47 ; U24.H33 82.6,77.29 82.29,76.99 v2(82.29,76.96) 82.29,76.85 U24.K33 ; U24.V9 94.39,72.38 v2(94.39,72.19) 94.39,72.18 94.08,71.87 U24.Y9 ; v1(52.28,43.98) 52.28,44.28 52.06,44.51 51.44,44.51 51.39,44.45 JDIM1.61
  BOTTOM w0.305: v2(108.8,106.21) 109.03,106.44 U22.U18 ; v2(93.41,113.02) 93.72,113.02 U22.AF1 ; CN6.17 214.33,39.9 216.98,37.25 v2(216.98,32.63) ; v1(94.55,125.59) 95.06,125.08 95.06,124.83 95.55,124.33 U19.3 ; U22.K15 106.22,99.92 106.5,99.92 v2(106.52,99.95) 106.52,100.13 107.03,100.63 U22.L16 107.03,100.73 107.49,101.19 107.49,101.39 v2(107.52,101.42) 107.72,101.42 U22.M17 108.52,102.22 v2(108.82,102.22) 109.03,102.43 U22.N18 ; v2(97.12,109.1) U22.Y5 ; CN18.51 v1(27.35,8.24) 26.15,8.24 25.85,8.55 CN18.57 ; v2(75.8,41.1) 75.97,41.1 76.1,41.22 U24.DB45 ; U22.B14 105.02,93.83 v2(104.65,93.46) ; v1(30.35,8.11) CN18.39 ; VRAM1.U1 139.81,116.2 v2(140.21,116.61) ; U22.Y2 94.45,108.69 v2(94.42,108.72) ; v2(114.55,99.21) 114.53,99.19 114.53,99.17 U22.H25 ; U22.AD18 108.33,112.03 v2(107.93,111.63) ; v2(114.53,105.81) 114.53,105.83 114.91,106.21 U22.U26 ; v1(57.39,21.7) 57.26,21.7 56.66,22.31 EC6.1 ; HD1.12 213,10.82 v1(212.94,10.76) ; v2(104.61,111.63) 104.21,112.03 U22.AD13 ; EC7.2 59.44,21.65 58.45,20.66 CN13.5 ; v1(99.12,124.95) 99.5,125.34 C493.2 R503.1 ; v1(103.39,124.2) 103.06,124.53 R504.1 C495.1 ; v2(115.63,93.31) 115.35,93.31 115.08,93.03 U22.A26 ; v1(97.72,120.76) 97.82,120.86 C501.1 ; 183.22,12 CN9.75 ; v2(98.87,109.08) 98.87,109.17 U22.AA7 ; v2(105.41,113.23) 105.41,113.25 U22.AF14 ; CN18.9 37.85,8.06 37.15,7.35 37.15,6.55 ; U24.DJ42 78.1,38.02 78.43,37.69 v2(78.52,37.69) ; VRAM1.T5 138.61,113.4 v2(138.61,113.41) ; U22.V13 v2(103.48,107.18) U22.U12 102.9,106.73 v2(102.42,106.25) 102.03,105.86 U22.T11 102.02,105.73 v2(101.42,105.13) 101.03,104.74 U22.R10 ; CN17.1 46.95,10.35 46.75,10.15 v1(46.75,10.1) ; U22.K13 104.03,99.76 v2(104.58,100.32) 105,100.73 U22.L14 105.03,100.76 105.55,101.28 105.55,101.41 v2(105.57,101.43) 105.7,101.43 106,101.73 U22.M15 106.11,101.73 106.36,101.98 v2(106.36,102.22) 106.65,102.22 107.03,102.6 U22.N16 v2(107.59,103.29) U22.P17 108.33,104.03 108.45,104.03 108.65,104.23 v2(108.82,104.23) 108.82,104.53 U22.R18 ; v2(109.59,110.79) U22.AB20 ; U22.AB11 v2(102.97,110.81) ; R570.2 97.46,87.48 97.98,88 v1(98.36,88) R563.2 ; U22.AC8 v2(99.65,110.81) U22.AB7 ; v2(106.27,111.63) U22.AD16 ; v1(28.85,8.24) CN18.45 ; U22.L2 95.16,101.25 95.57,100.84 v2(95.57,100.83) ; U22.AG26 114.93,114.45 v2(115.34,114.86) ; v1(13.04,16.24) 12.13,16.24 12,16.12 RV1.3 ; v2(110.39,113.23) U22.AF20 ; CN6.14 212.24,41.4 211.62,40.78 v2(211.62,39.94) ; v2(97.12,105.8) 97.52,106.21 U22.U5 ; v2(102.95,113.22) 102.94,113.22 U22.AE11 ; v2(107.09,113.23) 107.09,113.23 107.1,113.23 107.5,113.63 U22.AF17 ; v1(34.85,8.24) CN18.21 ; CN9.13 184.47,28.13 184.9,27.7 184.9,26.88 v2(184.82,26.81) ; U22.AF11 102.94,114.02 v2(102.96,114.02) ; U24.CY41 78.7,42.24 v2(79.16,41.78) ; v2(107.87,110.77) 107.87,110.75 U22.AB17 ; U22.U10 101.5,107.2 v2(101.5,107.23) 101.53,107.23 U22.V11 ; VRAM2.B10 139.01,90.6 v2(138.61,90.21) ; v1(66.75,125.57) 66.75,125.39 PC126.1 ; v2(104.56,110.8) 104.97,110.39 U22.AB14 ; v1(97.32,115.07) 97.42,114.97 97.42,113.79 U22.AF5 ; HD1.13 217.53,17.43 217.36,17.26 v1(217.36,17.13) ; v2(138.61,84.61) 138.6,84.61 VRAM2.C3 ; RV1.8 v1(9.84,16.12) ; v2(94.75,115.02) 95.13,114.65 U22.AG2 ; U22.AE20 110.39,112.43 v2(110.41,112.43) ; v2(107.09,112.43) 107.11,112.43 U22.AE17 ; U22.U2 95.13,106.15 94.83,105.85 94.55,105.85 v2(94.5,105.9) ; v2(102.17,99.05) 102.03,99.19 U22.K11 v2(102.58,100.28) U22.L12 103.57,101.27 v2(103.57,101.29) 103.59,101.29 U22.M13 104.03,101.8 104.55,102.32 104.58,102.32 104.6,102.35 v2(104.63,102.35) 104.65,102.35 U22.N14 105.06,102.73 105.57,103.24 v2(105.6,103.24) 105.6,103.3 U22.P15 106.03,103.73 106.36,104.06 v2(106.36,104.25) 106.55,104.25 107.03,104.73 U22.R16 107.53,105.23 108.03,105.73 U22.T17 ; v2(103.8,112.42) 103.78,112.42 U22.AD12 ; CN18.33 31.85,8.41 v1(31.68,8.24) ; VRAM2.E1 136.22,83.01 v2(136.21,83.01) ; v2(97.18,111.58) U22.AC5 ; U22.B8 99.96,93.72 99.96,92.29 v2(100.06,92.19) ; v2(99.99,114.46) 99.99,114.26 99.93,114.2 99.93,113.77 U22.AF8 ; v2(112.11,103.31) U22.P23 ; U22.V17 107.47,107.17 107.45,107.17 v2(107.4,107.12) 107.38,107.1 107.38,107.08 U22.U16 106.59,106.29 v2(106.36,106.29) 106.36,106.06 U22.T15 106.03,105.73 105.78,105.48 v2(105.78,105.24) 105.54,105.24 105.03,104.73 U22.R14 104.63,104.33 v2(104.63,104.12) 104.4,104.12 104.03,103.75 U22.P13 104.03,103.73 v2(103.53,103.23) 103.53,103.23 U22.N12 102.81,102.73 102.42,102.35 v2(102.4,102.35) 102.4,102.2 102.03,101.83 U22.M11 101.81,101.73 101.38,101.31 101.36,101.31 101.31,101.26 101.28,101.26 101.26,101.23 v2(101.23,101.23) 101.23,101.15 101.03,100.95 U22.L10 100.61,100.73 v2(100.39,100.95) ; U22.N10 101.03,102.99 v2(101.31,103.26) 101.56,103.26 U22.P11 102.03,103.78 v2(102.4,104.15) 102.45,104.15 U22.R12 103.48,105.18 v2(103.48,105.23) 103.53,105.23 U22.T13 104.03,105.8 104.53,106.3 104.53,106.3 104.53,106.3 104.96,106.73 U22.U14 v2(105.53,107.23) U22.V15 ; v2(113.7,110.78) 113.7,110.75 113.33,110.38 U22.AB24 ; PC210.2 134.98,44.9 v1(135.38,44.5) ; v2(105.41,112.43) 105.41,112.45 U22.AE14 ; U22.AC2 94.82,111.49 v2(94.14,111.49) ; U22.L18 109.01,100.73 108.44,100.15 v2(108.39,100.15) 108.39,100.09 U22.K17 107.77,99.47 v2(107.77,99.22) ; v2(112.11,109.11) U22.Y23 ; v1(36.35,8.24) CN18.15 ; R508.2 95.92,119.24 v1(96.45,118.71) ; U22.AD19 109.17,112.03 v2(109.57,111.63) ; v2(111.26,111.61) U22.AC22 ; U22.AD22 v2(111.23,112.43) U22.AD21 ; v1(33.35,8.24) CN18.27 ; U24.DA33 82.82,41.32 U24.DB32 83.11,41.03 84.77,41.03 v2(84.8,41.01) ; v1(94.52,103.73) U22.P2 ; v2(97.13,103.33) U22.P5 ; v2(106.28,112.44) U22.AD15 ; v2(112.87,114.02) U22.AF23 ; PC125.1 64.78,125.11 v1(64.31,125.58)
  BOTTOM w0.33: VRAM2.C12 138.21,92.21 v2(137.81,92.61) ; v2(130.21,105.27) VRAM1.E14 ; VRAM2.J1 133.42,83.4 v2(133.81,83.01) 134.21,83.4 VRAM2.H1 ; v2(137.81,109.41) 137.41,109.01 VRAM1.P10 ; v2(140.21,84.61) 139.82,85 VRAM2.A3 ; VRAM1.L10 135.01,109.01 135.41,109.41 ; VRAM1.U12 140.21,107.8 v2(140.21,107.81) ; v2(129.82,94.19) VRAM2.N14 ; VRAM2.R11 128.61,91.4 129.01,91.81 ; VRAM1.C12 128.59,107.4 v2(128.21,107.78) 128.22,107.78 128.61,108.17 VRAM1.C11 ; VRAM1.C3 128.61,114.6 128.61,114.61 128.26,114.96 v2(128.21,114.96) ; v2(128.21,86.21) 127.82,86.6 VRAM2.T5 ; v2(137.81,105.41) 138.21,105.8 VRAM1.R14 ; VRAM2.R14 128.61,93.81 v2(128.21,94.21) ; VRAM1.U3 139.82,114.6 v2(140.21,114.21) ; VRAM2.N3 130.21,85 v2(130.61,85.41) ; VRAM1.N1 136.61,116.21 136.43,116.38 v2(136.43,116.85) ; v2(133.01,109.46) 133.01,109.41 133.41,109.01 VRAM1.J10 ; VRAM2.N12 130.21,92.21 129.82,92.6 v2(129.82,92.61) ; 135.41,109.41 v2(135.41,109.46) ; 135.41,109.41 135.81,109.01 VRAM1.M10 ; v2(134.61,94.21) 134.21,93.81 VRAM2.H14 ; v2(127.42,90.19) 127.81,90.59 VRAM2.T10 ; VRAM2.C14 138.21,93.81 v2(137.81,94.21) ; VRAM2.A14 139.81,93.8 v2(140.21,94.21) ; v2(129.01,115.83) 128.98,115.83 VRAM1.C1 ; v2(138.61,109.41) 139.01,109.01 VRAM1.T10 ; v2(126.62,114.96) 126.65,114.96 VRAM1.A3 ; VRAM2.A1 139.81,83.4 v2(139.41,83.01) ; v2(126.43,92.01) 126.62,92.2 VRAM2.U12 ; v2(127.39,85.38) VRAM2.U3 ; VRAM2.U1 v2(126.6,82.99) ; VRAM1.R1 138.21,116.21 v2(137.81,116.61) ; v2(137.81,91.81) 138.21,91.41 VRAM2.C11 ; VRAM1.R12 138.6,107.01 v2(138.61,107.01) ; VRAM2.M5 131.01,86.6 v2(131.41,87.01) 131.81,86.61 VRAM2.L5 ; VRAM2.E14 136.61,93.81 v2(136.21,94.21) ; v2(134.61,93.41) 134.21,93.01 VRAM2.H13 ; VRAM2.E3 136.62,85 v2(137.01,84.61) ; 129.01,91.81 v2(129.02,91.81) ; 129.01,91.81 128.62,92.2 VRAM2.R12 ; VRAM2.K14 132.61,93.81 v2(132.21,94.21) ; v2(137.01,91.01) 137.41,90.61 VRAM2.D10 ; v2(128.21,83.01) 128.61,83.4 VRAM2.R1 ; v2(137.01,105.41) 136.62,105.8 VRAM1.N14 ; VRAM1.C14 128.61,105.8 v2(128.21,105.41) ; v2(126.66,107.78) 126.66,107.75 VRAM1.A12 ; VRAM2.G5 135.01,86.61 135.41,87.01 v2(135.41,87.01) 135.41,87 135.81,86.61 VRAM2.F5 ; v2(136.21,91.81) 136.61,92.2 VRAM2.E12 ; VRAM2.L10 131.81,90.6 v2(131.41,90.21) 131.02,90.6 VRAM2.M10 ; VRAM2.K2 132.61,84.2 v2(132.21,83.81) 132.61,83.41 VRAM2.K1 ; v2(137.81,83.01) 138.21,83.4 VRAM2.C1 ; v2(129.79,82.47) 130.21,82.89 VRAM2.N1 ; v2(131.41,108.64) 131.06,109 VRAM1.F10 ; v2(131.26,109.46) 131.35,109.46 VRAM1.G10 ; v2(132.21,93.41) 132.61,93.01 VRAM2.K13 ; VRAM2.F10 135.81,90.6 v2(135.41,90.21) 135.02,90.6 VRAM2.G10 ; VRAM1.R11 138.22,108.2 v2(138.61,107.81) ; v2(132.21,116.61) 132.61,116.21 VRAM1.H1 ; VRAM1.K13 134.21,106.55 v2(133.81,106.16) 133.85,106.16 VRAM1.K14 ; VRAM1.M5 135.81,113 v2(135.41,112.61) 135.02,113 VRAM1.L5 ; VRAM1.H14 132.54,105.8 v2(132.19,106.16) 132.19,106.2 132.58,106.6 VRAM1.H13 ; VRAM1.K1 133.82,115.81 v2(133.81,115.81) 133.81,115.8 VRAM1.K2 ; VRAM1.J1 133.41,116.21 v2(133.01,116.61) ; VRAM1.F5 131.02,113 131.41,112.61 v2(131.41,112.61) 131.42,112.61 131.81,113 VRAM1.G5 ; v2(126.63,105.42) 127.01,105.8 VRAM1.A14 ; VRAM1.U14 139.82,105.8 v2(140.21,105.41) ; v2(129.81,114.96) 129.86,114.96 130.21,114.61 VRAM1.E3 ; v2(129.03,90.22) VRAM2.P10 ; VRAM1.N12 137.01,107 v2(137.01,106.97) ; VRAM2.H2 134.21,84.2 v2(133.81,83.81) ; VRAM1.D10 129.41,109.01 129.01,109.41 v2(129.01,109.46) ; VRAM1.A1 v2(126.57,116.64) ; VRAM2.A12 139.82,92.2 v2(140.21,91.81) ; VRAM2.R3 128.64,85 129,85.37 v2(129,85.38) 129,85.38 128.61,85.76 VRAM2.R4 ; VRAM2.U14 126.77,93.8 v2(126.5,93.53) ; VRAM1.B5 127.81,113 128.2,113.4 v2(128.21,113.4) 128.21,113.4 VRAM1.C4 ; VRAM1.R3 138.22,114.6 v2(138.61,114.21) 138.21,113.8 VRAM1.R4 ; v2(139.41,86.21) 139.02,86.6 VRAM2.B5 ; v2(129.82,116.59) VRAM1.E1
  BOTTOM w0.356: v2(112.07,95.84) 111.68,96.23 U22.E22 ; VRAM1.B10 127.84,109 128.2,108.64 v2(128.21,108.64) ; v2(138.61,85.41) 138.22,85.8 VRAM2.C4 ; v1(91.83,85.58) 91.11,85.58 Q32.1 ; VRAM1.H2 VRAM1.H1 ; v1(132.9,98.67) 132.9,97.84 R530.1 ; v2(76.26,103.64) 76.72,103.18 PQ18.1
  BOTTOM w0.381: v1(81.85,28) 81.85,28.1 82.1,28.36 R730.1 ; v1(104.48,117.82) R513.2 ; EC7.2 60.28,21.68 v1(60.46,21.68) ; v2(196.53,22.69) 196.53,22.15 Q44.1 ; v1(76.36,23.4) 76.49,23.28 C682.2 ; v1(143.22,40.37) 143.19,40.35 143.19,40.27 142.71,39.79 142.71,38.87 142.46,38.62 142.46,38.07 PC221.1 ; v1(211.31,33.41) 211.31,32.67 C637.2 ; Q38.1 113.87,59.54 v1(114.36,60.03) ; v2(74.2,98.87) 74.03,98.87 73.48,99.42 PR150.1 72.34,99.42 PC156.2 ; v1(109.61,50.3) 109.29,50.62 C600.1 ; R554.1 R553.1 105.86,90.02 105.47,90.41 104.84,90.41 v2(103.57,91.68) ; v2(185.41,33.21) 185.41,33.06 184.58,32.23 CN9.76 ; R630.1 63.79,53.61 v1(63.82,53.61) 63.79,53.59 63.78,53.59 R632.1 ; PR146.2 76.55,106.41 ; C659.2 203.5,26.45 203.33,26.45 203.28,26.4 v2(203.24,26.4) 203.21,26.38 202.88,26.38 202.42,26.83 C661.2 ; v1(116.01,118.61) 116.34,118.28 R511.1 ; v2(130.61,107.78) 130.23,107.4 VRAM1.E12 ; v2(158.3,24.64) 158.3,23.97 158.66,23.62 PC257.2 ; CN11.5 120.85,17.6 121.52,18.27 v2(121.79,18.27) ; C671.1 204.68,24.6 204.51,24.78 v2(204.51,25.46) 204.95,25.9 C667.1 ; EC9.2 180.48,19.21 180.2,18.93 v2(180.2,18.91) ; v1(130.69,78.62) 130.69,79.05 C565.1 ; C595.2 101.61,55.8 v1(102.23,55.8) ; v1(128.43,122.01) 127.88,122.01 127.52,121.65 C502.2 128.22,121.13 v1(128.43,121.35) ; v2(160.01,36.87) 160.01,36.64 160.61,36.04 PC226.2 ; R539.1 91.25,94.98 91.27,94.96 v2(93.48,94.96) ; PC234.2 144.12,34.83 144.45,35.16 PC227.2 ; v2(73.82,102.93) 73.82,103.42 PQ17.1 ; 131.51,102.85 132.01,102.35 R523.1 ; U22.E20 109.99,96.19 v2(110.39,95.79) ; v2(161.43,27.85) 161.43,27.47 160.89,26.94 U33.4 ; SW2.2 63.61,97.8 v1(64.15,97.27) ; v1(103.69,34.09) 103.69,34.07 103.26,33.64 C633.1 ; v1(211.67,29.27) 211.64,29.3 R355.2 ; v1(97.36,25.64) 97.99,25.64 Y4.2 ; C666.2 211.81,26.93 212.36,27.47 v1(212.43,27.47) ; C680.2 73.39,22.73 73.77,22.35 v1(73.77,22.34) 74.16,22.73 C681.2 ; FAN1.5 171.87,24.78 171.44,25.21 v1(171.44,25.89) ; C532.1 57.19,103.84 57.15,103.8 C542.1 ; v1(89.44,96.1) 89.5,96.1 89.52,96.13 R534.1 ; v2(40.32,15.86) 40.66,15.52 PC266.2 41.88,15.52 PC265.2 ; PC250.2 152.94,27.05 152.79,26.91 152.77,26.91 152.77,26.91 v2(152.77,26.83) ; 80.44,96.02 80.43,96.04 80.43,97.57 v1(80.58,97.73) 80.58,97.78 80.2,98.16 U23.2 ; C544.1 120.32,103.71 v1(120.23,103.62) 120.14,103.71 C543.1 ; C653.2 85.43,28.53 v1(85.43,27.88) ; v1(113.27,63.08) 113.27,63.05 112.97,62.76 C587.2 ; C634.2 108.14,33.25 v1(108.55,32.85) ; SW2.1 63,105.45 v1(62.8,105.65) ; FAN1.4 178.64,31.38 177.8,30.53 177.42,30.53 176.52,29.63 v2(176.52,28.66) ; C622.2 207.23,39.1 v1(207.45,39.1) ; Y2.4 100.48,86 v2(100.77,86.3) ; PC161.2 75.25,94.77 v1(75.17,94.86) 75.37,95.06 PC158.2 ; v2(197.75,19.18) 197.75,19.16 197.75,19.16 197.75,19.14 197.75,19.14 197.75,19.11 197.83,19.04 C705.1 ; v1(60.11,72.88) 60.12,72.88 R609.2 ; v1(60.31,18.07) 60.31,17.97 61.13,17.15 CN13.9 ; v2(65.64,58.69) 65.64,58.46 63.8,56.61 C594.2 ; R732.1 v1(84.14,27.88) ; v1(105.45,32.6) 106.11,32.6 106.67,32.04 U31.2 ; R640.1 63.57,51.07 63.95,51.45 v1(63.95,51.72) 63.64,52.03 R635.1 ; VRAM1.N3 136.61,114.6 v2(137.01,115.01) ; v1(17.21,58.15) 17.51,58.15 18.23,57.43 C593.1 ; C652.1 80.02,28.53 80.02,27.81 80.42,27.42 v1(80.58,27.42) ; PQ28.1 20.06,30.83 v1(20.81,31.58) ; C557.2 85.75,85.91 v1(84.69,85.91) 84.67,85.89 C556.2 ; PC269.2 36.48,14.65 v2(36.79,14.34) ; C641.2 211.27,31.57 211.87,32.17 v1(211.92,32.17) ; v1(211.92,30.39) C377.2 ; R543.1 89.92,94.14 89.38,94.14 v1(89.25,94.02) ; v1(48.58,8.5) 48.33,8.74 CN17.7 ; v1(102.2,53.17) 101.67,53.17 C598.1 ; PC141.2 C509.1 103.12,119.05 102.37,118.3 102.37,117.46 v1(102.12,117.21) ; CN11.6 115,18.55 114.44,19.11 v2(114.44,20.23) ; v2(133.79,91.05) 133.41,90.66 VRAM2.J10 ; v1(79.67,115.53) 79.87,115.53 80.28,115.95 PR133.2 ; v1(104.81,46.37) 104.81,45.67 C603.1 ; C632.1 67.49,34.01 67.91,34.43 v1(67.91,34.45) ; v1(65.57,29.75) 66.17,29.75 C649.2 ; PC187.2 PC186.2 140.75,61.49 v1(140.92,61.66) ; v2(101.28,45.58) 101.36,45.66 C602.1 ; C559.2 15.01,82.4 15.04,82.37 D24.1 15.99,82.37 v2(16.44,82.82) ; C542.1 56.7,103.24 56.51,103.43 C541.1 ; C542.1 57.15,102.56 v2(58.46,101.26) ; R653.1 63.44,46.59 63.21,46.82 v1(63.16,46.82) 63,46.98 62.64,46.98 R651.1 ; v1(43.13,14.56) 43.13,15.01 PC267.1 44.24,15.19 PR275.1 ; v2(91.5,29.96) 92.13,29.33 C651.1 ; v1(208.24,38.64) 208.24,38 C624.2 ; C689.1 C688.1 131.63,22.29 131.9,22.55 131.9,23.09 v1(131.89,23.1) ; v1(62.52,108.7) 64.12,110.3 CN2.42 ; C685.2 128.7,22.54 129.12,22.54 129.65,23.07 v1(129.65,23.1) ; v2(65.29,55.36) 65.29,55.19 64.91,54.8 64.37,54.8 64.12,55.05 C596.1 ; v1(131.33,78.57) 131.33,78.72 C566.1 ; R552.1 103.3,90.04 103.01,90.33 103.01,90.44 v2(102.73,90.71) ; 193.99,31.25 194.12,31.38 193.97,31.53 193.97,32.85 v1(194.12,33.01) ; R618.2 v1(114.11,63.41) ; R547.1 89.94,92.09 v1(89.33,92.09) ; C545.1 83.88,97.65 83.65,97.42 83.65,97.14 v1(83.55,97.04) ; C648.1 197.3,29.44 197.43,29.31 R720.2 198.22,29.12 198.56,29.12 v2(198.94,28.74) ; U20.3 100.38,120.47 v1(100.77,120.86) ; PU8.2 75.88,101.46 75.56,101.78 PC151.2 75.56,102.53 76.13,103.11 76.13,103.36 76.26,103.49 v2(76.26,103.64) ; C607.1 106.77,44.18 v1(106.87,44.08) ; C606.1 107.69,44.76 v1(107.33,45.12) ; v2(62.5,101.78) 62.35,101.63 SW2.5 ; v2(209,29.2) 209,28.99 209.13,28.87 C656.2 ; v2(136.61,18.32) 136.84,18.32 137.78,19.26 137.78,20.76 138.09,21.08 C699.2 ; CN10.29 177.76,18.5 179.26,17 179.26,16.45 v2(179.28,16.42) ; v1(100.11,90.13) 99.75,89.77 C554.2 ; v1(138.24,17.49) 138.24,18.46 138.74,18.96 C703.2 ; v1(110.22,45.48) 110.22,45.33 109.78,44.88 C605.1 ; R528.2 89.93,98.16 v1(89.42,97.65) 89.93,97.14 R532.1 ; C686.1 C687.1 130.62,22.08 131.25,22.72 v1(131.25,23.1) ; PU13.4 104.55,25.86 104.17,26.24 PC255.2 102.97,26.24 102.8,26.4 102.8,26.5 v2(102.55,26.76) ; v1(63.32,48.3) R648.1 63.32,49.85 R645.1 ; v1(112.13,69.73) 112.85,69.01 R612.2 ; v1(108.52,26.3) PR263.2 108.31,26.93 107.71,26.33 PU13.2 ; v2(141.87,16.83) 141.87,17.05 142.51,17.69 144.71,17.69 CN10.30 ; v1(16.93,81.9) 17.38,81.44 17.75,81.44 Q33.2 ; R526.1 119.43,98.53 120.71,99.81 v1(120.71,100.09) ; v1(143.22,41.03) 143.52,41.03 144,40.55 144,39.69 143.69,39.37 PR230.2 ; v1(103.54,32.57) 103.52,32.57 103.47,32.63 C636.1 ; C713.1 198.76,11.15 v2(199.32,11.72) ; v1(112.74,42.63) 111.98,42.63 PC212.2 ; C698.2 204.01,20.68 204.28,20.94 207.2,20.94 207.53,21.27 U35.2 208.49,21.27 208.95,21.73 v1(209.18,21.73) ; v1(89.24,92.95) R545.1 ; Y2.2 101.87,88.13 102.31,88.56 C555.2 102.31,89.13 101.87,89.57 v1(101.87,89.8) ; v1(77.86,23.61) 77.86,24.06 78.4,24.6 R783.1 ; C540.2 C539.1 60.39,102.14 59.83,101.59 59.83,101.36 v2(59.8,101.33)
  BOTTOM w0.406: C438.1 12,18.4 12.25,18.66 v1(12.48,18.66) ; RV3.3 10.88,10.8 10.51,10.43 9.43,10.43 v1(9.41,10.46)
  BOTTOM w0.457: 129.46,80.33 128.79,80.33 v1(128.46,80) ; v2(40.93,106.49) 40.93,106.19 C528.2
  BOTTOM w0.508: PC258.2 PC256.1 93.81,24.2 93.81,24.38 v1(94.87,25.44) ; C690.2 12.03,22.29 v1(12.03,22.32) ; C560.2 24.13,81.38 v1(24.42,81.67) ; C662.1 64.42,27.43 v1(64.32,27.52) ; PC271.1 46.28,14.21 v1(45.62,14.87) ; PQ25.1 20.44,35.84 v1(20.84,35.44) ; v1(100.49,59.85) 101.08,59.27 C591.2 ; CN12.10 68.86,17.55 69.02,17.39 v1(69.15,17.39) ; v2(196.61,30.97) 196.99,31.36 C643.2 ; v1(120.33,120.38) 120.28,120.43 C504.1 ; C610.2 22.77,43.98 22.31,44.44 v1(22.11,44.44) ; C708.2 30.14,13.55 v1(29.4,12.81) ; v1(33.21,15.73) 33.07,15.6 PC268.2 ; JDIM1.261 42.35,30.51 v1(43.57,31.74) ; CN8.30 125.89,23.2 C683.2 126.6,23.74 127.09,23.25 v1(128,23.25) ; EC8.2 11.2,22.23 10.35,21.37 v1(10.02,21.37) ; v2(128.21,34.18) 128.51,33.88 128.51,33.51 128.97,33.06 PC238.2 ; v2(199.32,11.72) 199.45,11.72 CN16.6 ; PC142.2 64.39,119.19 v1(64.02,118.82) ; PC254.1 129.98,26.71 130.37,26.33 130.38,26.33 v2(130.39,26.32) ; PQ15.1 71.66,106.41 71.66,106.46 v1(71.44,106.69) ; v2(111.52,14.85) 111.52,14.92 112.55,15.95 PJ11.9 ; 76.55,106.41 77.4,106.41 ; C710.2 27.48,13.74 v1(27.01,13.27) ; C589.1 102.73,61.53 v1(102.88,61.38) ; v1(35.24,104.38) 35.24,105.17 36.08,106.01 37.7,106.01 39.22,107.52 U21.25 ; v1(19.65,39.52) 20.37,39.52 PQ23.1 ; D22.1 40.54,120.93 D21.1 38.15,120.93 37.6,121.47 37.6,121.83 v1(37.15,122.29) 36.66,121.8 v2(36.66,121.78) ; CN6.42 216.25,27.76 v2(216.7,28.21) ; CN2.41 42.15,111.16 42.35,111.37 v1(43.24,111.37) ; v1(45.65,97.52) 45.56,97.52 44.67,96.63 JDIM1.262 ; v1(34.48,117.21) 33.9,116.63 CN1.1 ; v1(154.32,21.53) 154.34,21.53 155.87,23.06 CN8.29 ; v1(117.54,118.61) C514.1 ; PR136.1 69.74,115.87 69.23,116.38 v1(69.23,117.13) ; v2(208.21,25.64) 209.04,25.64 C670.2 209.1,26.15 208.88,26.37 C663.1 ; v1(14.31,6.08) 14.11,6.08 13.67,6.52 CN19.2 ; v1(19.06,6.11) 19.06,6.31 20.25,7.5 CN18.77 v1(20.25,10.78) ; C558.2 22.13,83.23 22.13,85.36 v1(21.78,85.71) ; v1(101.79,59.7) 102.22,59.27 C592.1 ; PJ11.10 92.35,17.43 v1(91.12,18.66) ; v1(13.95,22.33) 14.44,21.84 C692.2 ; C529.2 43.23,105.79 v1(43.62,105.4) ; C588.2 v1(100.47,61.53) ; v1(65.39,104.89) 66.4,105.9 C526.2 C527.2 ; C691.2 13.47,21.84 13.3,22.02 v1(13.3,22.47) ; v2(215.73,13.17) 215.1,13.17 214.82,13.45 ; 131.51,102.85 v1(131.51,103.8) ; v1(19.65,44.18) U28.2 ; C563.2 135.06,79.74 v1(135.7,79.11) ; 138.55,12.74 CN15.19 ; CN13.10 55.62,17.15 v1(56.81,15.96) ; 214.82,12.32 v2(215.71,12.32) ; v1(9.43,12.35) 9.46,12.35 9.79,12.69 9.85,12.69 C462.1 ; C500.1 119.7,121.91 v1(119.7,122.16) ; CN16.5 209.04,10.95 209.21,10.78 v1(209.46,10.78) ; v1(100.39,26.28) 100.18,26.48 Y4.4 ; C515.1 119.7,118.99 v1(119.7,119.24) ; HD1.14 v2(217.53,10.2) ; v1(72.83,17.79) 72.83,17.64 73.34,17.13 77.66,17.13 78.08,17.55 CN12.9 ; 126.65,12.72 CN15.20 ; C585.2 103.64,62.85 103.34,62.55 v1(103.31,62.55) ; D41.1 v1(12.63,13.83) ; D38.1 v1(10.6,19.17) ; v1(120.96,119.24) C516.1 ; C564.2 137.69,78.41 v1(137.58,78.29)
  vias: v1(0.51,105.17) v1(0.7,122.16) v1(0.82,26.53) v1(1.08,25.64) v1(1.71,122.16) v1(1.74,23) v1(1.79,26.88) v1(2.11,111.09) v1(2.11,109.82) v1(2.11,108.55) v1(2.11,107.28) v1(2.11,106.01) v1(2.11,65.09) v1(2.11,63.82) v1(2.11,62.55) v1(2.09,24.75) v1(2.58,21.16) v1(3.05,122.26) v1(2.96,61.75) v1(3.06,26.88) v1(3.25,46.93) v1(3.25,45.73) v1(3.25,44.46) v1(3.25,43.19) v1(3.85,21.63) v1(3.9,103.93) v1(4,88.25) v1(4.32,122.26) v1(4.3,120.71) v1(4.25,112.38) v1(4.33,26.88) v1(4.52,46.88) v1(4.68,87.49) v1(5.14,84.7) v1(5.14,67.68) v1(5.11,20.48) v1(5.11,19.21) v1(5.11,12.1) v1(5.07,10.83) v1(5.4,44.36) v1(5.52,120.71) v1(5.59,122.26) v1(5.6,112.41) v1(5.6,26.88) v1(5.79,46.88) v1(5.9,86.98) v1(6.03,84.66) v1(5.95,41.75) v1(6.13,67.74) v1(6.08,61.75) v1(6.06,45.55) v1(6.11,43.47) v1(6.18,105.27) v1(6.69,112.81) v1(6.86,122.26) v1(7.05,120.51) v1(7.02,84.7) v1(7.12,87.51) v1(7.2,67.5) v1(7.22,41.75) v1(7.35,61.75) v1(7.38,44.36) v1(7.55,88.25) v1(8.08,122.26) v1(8.14,85.33) v1(8.34,103.96) v1(8.32,88.38) v1(8.34,67.09) v1(8.42,62.19) v1(8.42,42.2) v1(8.82,14.9) v1(8.98,121.37) v1(8.96,119.92) v1(8.98,46.28) v1(8.98,26.41) v1(9.36,84.72) v1(9.38,67.68) v1(9.54,44.33) v1(9.61,82.1) v1(9.61,70.65) v1(9.59,62.6) v1(9.61,42.6) v1(10.25,120.77) v1(10.25,46.28) v1(10.25,26.41) v1(10.86,62.6) v1(10.88,42.6) v1(10.96,44.23) v1(11.34,46.11) v1(11.52,120.77) v1(11.47,26.07) v1(11.78,88.78) v1(11.77,42.86) v1(12,103.26) v1(11.97,62.83) v1(12.21,0.76) v1(12.48,46.34) v1(12.69,26.66) v1(12.79,120.77) v1(12.76,61.96) v1(12.76,59.55) v1(12.76,49.26) v1(12.76,41.97) v1(12.76,39.56) v1(12.76,29.32) v1(13.5,18.02) v1(13.48,0.76) v1(13.78,44.44) v1(13.83,43.75) v1(14.06,120.77) v1(14.41,119.75) v1(14.72,118.76) v1(14.75,0.76) v1(14.79,79.74) v1(14.79,77.71) v1(14.79,75.78) v1(15.56,113.02) v1(15.81,118.26) v1(15.94,112.51) v1(16.02,0.76) v1(16.06,61.23) v1(16.06,59.17) v1(16.32,113.14) v1(16.57,112.51) v1(17.08,118.26) v1(17.33,10.88) v1(17.33,10.25) v1(17.33,5.45) v1(17.29,0.76) v1(17.46,114.67) v1(17.97,55.49) v1(17.97,54.85) v1(18.1,22.34) v1(18.35,118.26) v1(18.56,0.76) v1(18.73,34.71) v1(18.73,34.07) v1(19.01,42.02) v1(19.01,41.39) v1(19.01,40.75) v1(19.24,97.9) v1(19.24,97.27) v1(19.24,96.63) v1(19.62,118.26) v1(19.62,49.14) v1(19.62,48.12) v1(19.7,114.87) v1(19.83,0.76) v1(20.23,13.04) v1(20.64,49.14) v1(20.64,48.12) v1(20.89,118.26) v1(20.93,10.78) v1(21.1,0.76) v1(21.5,93.59) v1(21.91,12.69) v1(22.08,26.91) v1(22.16,118.26) v1(22.37,0.76) v1(22.46,26.4) v1(22.54,12.81) v1(22.54,12.18) v1(22.59,93.59) v1(22.85,72.35) v1(23.07,20.13) v1(23.23,21.8) v1(23.18,6.51) v1(23.43,118.26) v1(23.35,93.59) v1(23.38,36.08) v1(23.46,5.37) v1(23.63,6.08) v1(23.64,0.76) v1(24.09,6.51) v1(24.29,85.81) v1(24.55,6.08) v1(24.7,118.26) v1(24.91,0.76) v1(25.33,85.97) v1(25.33,85.33) v1(25.71,36.56) v1(25.97,118.26) v1(26.2,86.09) v1(26.22,71.36) v1(26.18,0.76) v1(26.35,104.38) v1(26.55,72.38) v1(26.88,82.33) v1(26.88,71.84) v1(26.88,71.21) v1(27.24,118.26) v1(27.24,22.21) v1(27.24,21.55) v1(27.24,20.81) v1(27.45,0.76) v1(27.62,78.35) v1(27.62,76.44) v1(27.62,74.54) v1(28,83.81) v1(28.51,118.26) v1(28.57,104.4) v1(28.72,0.76) v1(28.94,21.78) v1(29.5,104.38) v1(29.78,118.26) v1(29.99,0.76) v1(31.05,118.26) v1(31.26,0.76) v1(31.56,104.38) v1(31.68,85.76) v1(32.19,87.51) v1(32.49,104.39) v1(32.6,0.77) v1(33.63,118.97) v1(33.84,122.69) v1(33.84,121.42) v1(33.84,120.15) v1(33.84,31.86) v1(33.79,6.41) v1(33.8,0.76) v1(34.43,6.41) v1(34.48,31.86) v1(35.11,31.86) v1(35.11,6.53) v1(35.07,0.76) v1(35.75,31.86) v1(35.85,22.34) v1(36,119.62) v1(36,118.86) v1(36,118.1) v1(36.08,11.8) v1(36.18,23.05) v1(36.34,0.76) v1(36.51,22.34) v1(36.61,124.29) v1(36.89,7.05) v1(37.27,12.94) v1(37.61,0.76) v1(38.37,124.32) v1(38.57,14.59) v1(38.87,26.96) v1(38.87,15.91) v1(38.88,0.76) v1(39.15,107) v1(39.64,124.32) v1(39.66,113.09) v1(40.15,0.76) v1(40.42,112.86) v1(40.4,101.51) v1(40.91,124.32) v1(41.06,112.86) v1(41.29,54.27) v1(41.36,3.29) v1(41.36,2.02) v1(41.42,0.75) v1(41.72,31.53) v1(42.15,67.09) v1(42.18,124.32) v1(42.43,21.7) v1(42.53,54.27) v1(42.78,67.09) v1(42.81,59.22) v1(43.14,101.21) v1(43.06,21.7) v1(43.45,124.32) v1(43.45,59.22) v1(43.62,104.63) v1(43.7,21.7) v1(44.01,60.83) v1(44.03,18.99) v1(44.05,67.09) v1(44.08,59.22) v1(44.64,105.4) v1(44.72,124.32) v1(44.69,67.09) v1(44.72,59.22) v1(44.89,54.34) v1(45.17,100.62) v1(45.32,67.09) v1(45.35,59.22) v1(45.5,104.68) v1(45.45,20.76) v1(45.63,21.37) v1(45.55,6.76) v1(45.78,60.84) v1(45.99,124.32) v1(46.09,54.88) v1(46.19,101.28) v1(46.44,97.52) v1(46.82,6.76) v1(47.08,97.52) v1(47.26,124.32) v1(47.44,122.48) v1(47.56,102.58) v1(48.1,122.48) v1(48.07,97.52) v1(48.09,6.76) v1(48.53,124.32) v1(48.96,97.52) v1(49.36,6.76) v1(49.49,126.76) v1(49.49,125.49) v1(49.62,12.53) v1(49.64,10.07) v1(49.64,8.8) v1(49.64,7.53) v1(50.25,127.36) v1(50.25,12.53) v1(50.43,103.14) v1(50.79,10.6) v1(50.89,12.53) v1(51.52,127.36) v1(52.06,10.6) v1(52.31,68.95) v1(52.26,58.56) v1(52.34,57.57) v1(52.5,69.95) v1(52.79,127.36) v1(53.33,10.6) v1(53.43,56.5) v1(53.64,67.09) v1(54.06,127.36) v1(54.16,70.47) v1(54.16,63.49) v1(54.42,124.45) v1(54.6,58.15) v1(54.6,10.6) v1(54.85,80.76) v1(54.93,63.49) v1(55.18,59.93) v1(55.33,127.36) v1(55.26,92.14) v1(55.94,124.45) v1(55.94,66.03) v1(55.87,10.6) v1(55.99,64.93) v1(56.07,60.97) v1(56.25,67.63) v1(56.45,70.01) v1(56.53,69.12) v1(56.5,58.15) v1(56.5,55.94) v1(56.6,127.36) v1(57.14,10.6) v1(57.58,124.61) v1(57.87,127.36) v1(58.41,10.6) v1(59.14,127.36) v1(59.7,108.34) v1(59.68,10.6) v1(60.41,127.36) v1(60.95,10.6) v1(61.14,123.01) v1(61.68,127.36) v1(61.79,123.01) v1(62.04,121.87) v1(62.22,10.6) v1(62.95,127.36) v1(63.49,10.6) v1(63.94,102.34) v1(63.92,66.97) v1(64.04,63.61) v1(64.07,69.63) v1(64.22,127.36) v1(64.43,67.37) v1(64.5,64.04) v1(64.76,10.6) v1(64.91,35.8) v1(65.49,127.36) v1(65.8,88.38) v1(66.03,10.6) v1(66.08,122.57) v1(66.43,88.38) v1(66.76,127.36) v1(67.3,10.6) v1(67.63,99.55) v1(68.03,127.36) v1(68.26,99.55) v1(68.57,10.6) v1(69.3,127.36) v1(69.84,10.6) v1(70.57,127.36) v1(71.11,10.6) v1(71.84,127.36) v1(72.38,10.6) v1(73.11,127.36) v1(73.09,111.62) v1(73.09,110.73) v1(73.11,109.84) v1(73.21,80.58) v1(73.65,10.6) v1(73.85,80.58) v1(73.98,111.62) v1(73.98,110.86) v1(73.98,109.84) v1(74.38,127.36) v1(74.92,10.6) v1(74.99,111.62) v1(74.99,110.73) v1(74.99,109.84) v1(75.65,127.36) v1(75.73,110.98) v1(76.21,125.21) v1(76.2,124.57) v1(76.2,123.94) v1(76.19,123.25) v1(76.19,10.6) v1(76.83,124.55) v1(76.83,123.91) v1(76.82,123.25) v1(76.92,127.36) v1(77.18,94.86) v1(77.48,123.99) v1(77.46,123.25) v1(77.46,10.6) v1(77.91,126.99) v1(78.14,123.25) v1(78.17,108.04) v1(78.73,10.6) v1(78.83,107.43) v1(79.01,123.15) v1(79.01,122.52) v1(79.23,125.26) v1(79.64,122.52) v1(79.56,9.64) v1(79.76,123.15) v1(79.82,101.43) v1(79.79,94.91) v1(79.92,108.09) v1(79.92,107.45) v1(79.92,106.81) v1(80.3,120.36) v1(80.33,8.88) v1(80.39,122.9) v1(80.39,122.26) v1(80.39,121.63) v1(80.38,120.99) v1(80.43,95.19) v1(80.5,125.26) v1(80.55,108.09) v1(80.55,107.45) v1(80.55,106.81) v1(81.04,122.92) v1(81.04,122.24) v1(81.04,121.6) v1(81.01,120.97) v1(81.19,108.09) v1(81.19,107.45) v1(81.19,106.81) v1(81.21,8.11) v1(81.37,101.43) v1(81.77,125.26) v1(81.82,108.09) v1(81.82,107.45) v1(81.82,106.81) v1(82,101.43) v1(82.36,7.48) v1(83.04,125.26) v1(83.63,6.97) v1(84.31,125.26) v1(84.39,105.75) v1(84.39,105.12) v1(84.9,6.72) v1(85.56,125.44) v1(86.07,105.35) v1(86.07,104.71) v1(86.09,104.08) v1(86.21,126.4) v1(86.4,103.49) v1(86.55,6.59) v1(86.7,127.36) v1(86.7,105.35) v1(86.7,104.71) v1(86.73,104.08) v1(86.75,102.96) v1(87.06,103.52) v1(87.34,104.71) v1(87.44,104.02) v1(87.54,103.06) v1(87.97,127.36) v1(88.07,6.84) v1(88.35,118.83) v1(89.42,118.55) v1(89.6,7.35) v1(91.12,8.11) v1(91.58,114.54) v1(91.57,113.73) v1(91.58,113.09) v1(91.58,112.41) v1(91.83,84.95) v1(92.21,114.54) v1(92.21,113.73) v1(92.24,113.09) v1(92.21,112.41) v1(92.39,9.13) v1(93.05,127.36) v1(93.41,10.27) v1(94.04,11.29) v1(94.32,127.36) v1(94.78,12.51) v1(95.59,127.36) v1(96.05,12.63) v1(96.86,127.36) v1(97.32,12.63) v1(97.78,118.6) v1(98.13,127.36) v1(98.08,116.93) v1(98.08,115.86) v1(98.11,26.63) v1(98.59,12.63) v1(99.4,127.36) v1(99.86,12.63) v1(100.14,16.34) v1(100.67,127.36) v1(101.13,16.32) v1(101.13,12.63) v1(101.69,15.99) v1(101.94,127.36) v1(102.4,12.63) v1(102.7,123.13) v1(103.21,127.36) v1(103.19,40.75) v1(103.19,39.66) v1(103.19,38.54) v1(103.21,37.1) v1(103.69,35.95) v1(103.67,12.63) v1(103.82,121.4) v1(104.48,127.36) v1(104.58,71.18) v1(104.58,51.55) v1(104.79,50.28) v1(104.94,12.63) v1(104.99,122.67) v1(105.09,39.66) v1(105.09,38.59) v1(105.12,37.1) v1(105.34,17.66) v1(105.34,17.03) v1(105.6,35.95) v1(105.6,34.1) v1(105.75,127.36) v1(105.98,17.66) v1(105.98,17.03) v1(106.21,12.63) v1(106.61,17.66) v1(106.61,17.03) v1(106.74,83.76) v1(106.89,82.79) v1(107.02,127.36) v1(107.25,17.66) v1(107.25,17.03) v1(107.5,83.76) v1(107.48,12.63) v1(107.78,85.25) v1(107.83,17.41) v1(107.86,118.17) v1(107.88,117.54) v1(108.14,83.76) v1(108.29,127.36) v1(108.75,12.63) v1(108.77,124.83) v1(108.77,123.05) v1(108.77,83.76) v1(109.54,124.83) v1(109.54,123.05) v1(109.56,127.36) v1(110.02,12.63) v1(110.83,127.36) v1(110.86,86.73) v1(111.29,12.63) v1(111.69,119.59) v1(111.87,37.37) v1(111.87,36.74) v1(111.9,34.66) v1(111.97,38.9) v1(112.1,127.36) v1(112.17,48.02) v1(112.33,119.59) v1(112.56,12.63) v1(112.66,34.73) v1(112.84,48.02) v1(112.96,119.62) v1(113.37,127.36) v1(113.83,12.63) v1(114.64,127.36) v1(115.1,12.63) v1(115.91,127.36) v1(116.39,23.61) v1(116.37,12.63) v1(117.03,23.61) v1(117.11,22.97) v1(117.18,127.36) v1(117.41,124.19) v1(117.54,124.83) v1(117.64,12.63) v1(117.66,123.58) v1(117.66,23.61) v1(117.87,125.51) v1(118.12,124.19) v1(118.17,124.83) v1(118.45,127.36) v1(118.91,12.63) v1(119.72,127.36) v1(120.18,12.63) v1(120.99,127.36) v1(121.45,12.63) v1(121.6,116.06) v1(121.6,115.05) v1(121.76,118.77) v1(122.14,119.32) v1(122.26,127.36) v1(122.3,79.9) v1(122.4,118.74) v1(122.49,95.34) v1(122.72,12.63) v1(122.78,119.32) v1(122.98,79.92) v1(123.53,127.36) v1(123.65,79.9) v1(123.79,28.69) v1(123.89,95.34) v1(124.01,126.35) v1(124.04,57.31) v1(123.99,12.63) v1(124.14,21.12) v1(124.29,79.91) v1(124.83,125.46) v1(125.03,19.86) v1(125.16,21.09) v1(125.26,12.63) v1(125.39,55.03) v1(125.49,28.99) v1(125.82,63.21) v1(125.83,61.89) v1(125.83,60.64) v1(126.05,19.85) v1(126.1,125.26) v1(126.14,62.55) v1(126.12,52.37) v1(126.12,51.05) v1(126.13,49.8) v1(126.18,61.25) v1(126.43,51.71) v1(126.5,79.97) v1(126.55,63.22) v1(126.47,50.41) v1(126.53,12.63) v1(126.55,61.89) v1(126.6,60.64) v1(126.73,29.7) v1(126.84,52.38) v1(126.85,51.05) v1(126.83,30.34) v1(126.94,62.56) v1(126.91,61.25) v1(126.9,49.8) v1(126.95,63.73) v1(127.16,79.98) v1(127.24,51.72) v1(127.21,50.41) v1(127.31,64.31) v1(127.34,63.21) v1(127.3,61.91) v1(127.37,125.26) v1(127.4,60.63) v1(127.37,29.7) v1(127.47,30.34) v1(127.63,61.28) v1(127.63,52.37) v1(127.59,51.07) v1(127.68,62.57) v1(127.7,49.79) v1(127.81,79.99) v1(127.8,12.63) v1(127.93,50.44) v1(127.97,51.73) v1(128,29.7) v1(128,29.07) v1(128.1,30.34) v1(128.64,125.26) v1(129.07,12.63) v1(129.45,47.34) v1(130.15,47.33) v1(130.34,12.63) v1(130.83,47.31) v1(131.18,42.73) v1(131.61,12.63) v1(132.68,53.95) v1(132.88,12.63) v1(133.31,42.84) v1(134.15,67.12) v1(134.1,47.31) v1(134.15,12.63) v1(134.3,66.51) v1(134.3,65.87) v1(134.3,65.24) v1(134.3,64.6) v1(134.78,67.12) v1(134.94,98.67) v1(134.94,66.51) v1(134.94,65.87) v1(134.94,65.24) v1(134.94,64.6) v1(135.42,12.63) v1(135.57,98.67) v1(135.7,96.63) v1(136.21,98.67) v1(136.46,96.63) v1(136.69,12.63) v1(137.35,42.02) v1(137.96,12.63) v1(138.16,72.91) v1(138.29,34.78) v1(138.36,54.85) v1(138.36,53.83) v1(138.36,52.95) v1(138.49,43.17) v1(138.49,42.02) v1(138.87,72.91) v1(138.87,53.35) v1(139.23,12.63) v1(139.33,32.9) v1(139.45,53.83) v1(139.46,54.53) v1(139.51,52.95) v1(139.58,72.91) v1(139.86,47.46) v1(140.3,72.91) v1(140.4,54.85) v1(140.4,53.83) v1(140.4,52.95) v1(140.47,30.69) v1(140.5,12.63) v1(141.01,72.91) v1(141.01,53.63) v1(141.67,72.71) v1(141.77,12.63) v1(141.9,28.59) v1(141.96,45.06) v1(143.04,12.63) v1(144.31,12.63) v1(144.36,116.72) v1(144.36,115.45) v1(144.36,114.18) v1(144.36,112.91) v1(144.36,111.64) v1(144.36,110.37) v1(144.36,109.1) v1(144.36,107.83) v1(144.36,106.56) v1(144.36,105.29) v1(144.36,104.02) v1(144.36,102.75) v1(144.36,101.48) v1(144.36,100.21) v1(144.36,98.94) v1(144.36,97.67) v1(144.36,96.4) v1(144.36,95.13) v1(144.36,93.86) v1(144.36,92.59) v1(144.36,91.32) v1(144.36,90.05) v1(144.36,88.78) v1(144.36,87.51) v1(144.36,86.24) v1(144.36,84.97) v1(144.36,83.7) v1(144.36,82.43) v1(144.36,79.89) v1(144.36,78.62) v1(144.36,77.35) v1(144.36,76.08) v1(144.36,74.81) v1(144.36,73.54) v1(144.36,72.27) v1(144.36,71) v1(144.36,69.73) v1(144.36,68.46) v1(144.51,67.19) v1(144.57,65.92) v1(144.7,64.65) v1(144.85,63.38) v1(145.08,62.11) v1(145.35,60.84) v1(145.58,12.63) v1(145.66,59.57) v1(145.78,43.04) v1(145.93,44.54) v1(146.04,58.3) v1(146.04,41.46) v1(146.47,57.03) v1(146.54,45.99) v1(146.59,40.22) v1(146.85,12.63) v1(146.98,55.76) v1(147.54,54.49) v1(147.46,47.18) v1(147.59,38.98) v1(148.15,53.22) v1(148.12,12.63) v1(148.66,48.14) v1(148.83,38.09) v1(148.86,51.95) v1(149.39,12.63) v1(149.62,50.68) v1(150,49.41) v1(150.13,37.6) v1(150.19,21.53) v1(150.66,12.63) v1(150.83,21.53) v1(151.04,22.19) v1(151.46,21.53) v1(151.62,37.43) v1(151.93,12.63) v1(152.94,37.6) v1(153.05,21.53) v1(153.2,12.63) v1(153.68,21.53) v1(154.06,38.04) v1(154.47,12.63) v1(155.15,38.72) v1(155.74,12.63) v1(156.2,39.51) v1(157.01,12.63) v1(157.29,40.22) v1(157.31,26.96) v1(158.3,21.2) v1(158.28,12.63) v1(158.58,39.58) v1(159.45,36.54) v1(159.55,12.63) v1(159.6,38.9) v1(160.67,38.24) v1(160.82,12.63) v1(161.66,37.65) v1(162.09,12.63) v1(162.7,37.1) v1(163.36,12.63) v1(163.89,36.51) v1(164.63,12.63) v1(165.16,35.95) v1(165.9,12.63) v1(166.41,35.44) v1(167.17,12.63) v1(167.91,34.91) v1(168.44,12.63) v1(169.35,34.68) v1(169.71,12.63) v1(170.57,18.86) v1(170.75,34.68) v1(170.98,12.63) v1(171.08,19.24) v1(171.61,19.77) v1(171.59,18.86) v1(172.15,34.53) v1(172.1,19.22) v1(172.25,12.63) v1(172.73,22.87) v1(173.52,12.63) v1(173.65,21.96) v1(174.79,12.63) v1(176.06,12.63) v1(177.13,34.61) v1(177.33,12.63) v1(178.4,34.61) v1(178.6,12.63) v1(179.77,34.4) v1(179.87,12.63) v1(180.94,34.59) v1(181.04,11.92) v1(182.21,34.64) v1(182.21,11.34) v1(182.94,9.64) v1(183.37,8.71) v1(183.48,34.75) v1(184.64,8.71) v1(184.75,34.87) v1(185.91,8.71) v1(186.02,35.05) v1(187.18,8.71) v1(187.29,35.28) v1(188.45,8.71) v1(188.56,35.56) v1(189.72,8.71) v1(189.83,35.86) v1(190.99,8.71) v1(191.1,36.22) v1(192.26,8.71) v1(192.37,36.63) v1(192.42,10.73) v1(193.53,8.71) v1(193.64,37.06) v1(194.8,8.71) v1(194.91,37.57) v1(196.07,8.71) v1(196.18,38.12) v1(197.34,8.71) v1(197.45,38.73) v1(198.61,8.71) v1(198.72,39.39) v1(199.88,8.71) v1(199.99,40.13) v1(201.15,8.71) v1(201.26,40.92) v1(202.42,8.71) v1(202.53,41.76) v1(202.75,32.63) v1(202.88,34.53) v1(203.69,8.71) v1(203.8,42.7) v1(204.38,30.72) v1(204.66,34.4) v1(204.66,32.63) v1(204.96,8.71) v1(205.07,43.71) v1(205.85,34.45) v1(206.23,8.71) v1(206.34,44.84) v1(206.34,16.45) v1(206.56,32.55) v1(207.5,8.71) v1(207.55,45.99) v1(208.55,16.19) v1(208.6,47.08) v1(208.77,8.71) v1(209.71,48.35) v1(210.04,8.71) v1(210.3,21.73) v1(210.65,49.54) v1(210.93,10.76) v1(210.98,21.73) v1(211.31,8.71) v1(211.47,50.66) v1(211.57,10.76) v1(212.2,51.8) v1(212.23,21.73) v1(212.58,8.71) v1(213.85,8.71) v1(214.31,11.9) v1(215.07,11.67) v1(215.12,8.71) v1(215.71,11.67) v1(216.39,8.71) v1(218.16,49.54) v1(218.16,48.27) v1(218.16,47) v1(218.16,45.73) v1(218.16,44.46) v1(218.16,43.19) v1(218.16,41.92) v1(218.16,31.76) v1(218.16,30.49) v1(218.16,29.22) v1(218.16,27.95) v1(218.16,26.68) v1(218.71,8.71) v1(219.16,18.4) v1(219.16,17.16) v1(219.16,15.89) v1(219.16,14.62) v1(219.16,13.35) v1(219.16,12.08) v1(219.16,10.81) v1(219.16,9.54) v2(14.55,17.89) v2(16.19,53.33) v2(16.42,43.17) v2(22.03,50.96) v2(22.54,52.54) v2(22.92,61.07) v2(23.89,11.54) v2(24.24,9.87) v2(25.31,9.38) v2(25.49,11.19) v2(32.09,12.84) v2(33.31,14.08) v2(33.51,11.49) v2(34.02,12.91) v2(35.57,14.16) v2(39.23,105.37) v2(42.2,107.38) v2(44.05,14.11) v2(56.86,17.89) v2(63.18,95.62) v2(63.82,95.62) v2(65.14,103.19) v2(65.72,101.08) v2(65.7,48.35) v2(66.03,59.78) v2(66.05,56.6) v2(66.58,51.04) v2(66.69,53.58) v2(67.07,55.36) v2(67.21,49.58) v2(67.34,59.45) v2(67.54,48.31) v2(68.08,51.56) v2(68.36,52.49) v2(68.38,50.72) v2(68.51,54.9) v2(68.51,53.59) v2(68.59,55.49) v2(68.72,60.72) v2(68.79,63.51) v2(69.02,59.04) v2(68.95,49.58) v2(69.28,51.57) v2(69.78,63.94) v2(70.11,52.49) v2(70.24,57.47) v2(70.33,64.98) v2(70.83,55.18) v2(70.88,60.26) v2(71,63.51) v2(71,61.1) v2(71.49,56.63) v2(71.72,55.71) v2(76.01,85.51) v2(76.39,84.44) v2(77.63,83.55) v2(77.71,85.29) v2(78.93,84.62) v2(78.93,83.45) v2(79.49,84.9) v2(79.49,83.73) v2(80.91,83.76) v2(82.43,84.75) v2(82.46,83.58) v2(83.02,49.41) v2(83.83,47.36) v2(83.86,60.11) v2(83.91,58.15) v2(83.88,56.63) v2(83.91,53.43) v2(83.91,51.9) v2(83.91,50.86) v2(83.91,49.85) v2(84.14,69.23) v2(84.24,68.34) v2(84.24,63.17) v2(84.24,60.95) v2(84.34,66.46) v2(84.31,65.75) v2(84.31,65.14) v2(84.44,40.55) v2(84.52,58.1) v2(84.47,56.63) v2(84.62,70.65) v2(84.62,70.06) v2(84.72,59.12) v2(86.4,40.37) v2(86.52,40.93) v2(86.8,65.52) v2(87.16,40.88) v2(87.16,40.31) v2(87.49,60.59) v2(88.33,60.59) v2(88.5,65.52) v2(88.5,57.06) v2(88.61,59.8) v2(88.65,58.56) v2(88.58,40.78) v2(88.68,55.82) v2(88.94,49.9) v2(88.94,49.31) v2(89.01,59.4) v2(89.17,53.43) v2(89.19,52.84) v2(89.19,52.26) v2(89.17,51.22) v2(89.17,50.63) v2(89.17,40.78) v2(89.27,55.82) v2(89.75,40.78) v2(89.98,65.54) v2(90.31,60.06) v2(90.31,58.71) v2(90.31,57.31) v2(90.59,83.63) v2(90.84,70.14) v2(90.87,68.72) v2(91.15,66.74) v2(91.15,66.1) v2(91.15,65.52) v2(91.29,39.67) v2(91.81,81.6) v2(92.61,66.89) v2(92.61,66.32) v2(92.61,65.71) v2(92.65,65.11) v2(94.96,53.92) v2(95.68,64.06) v2(96.44,62.17) v2(96.44,61.26) v2(96.42,58.57) v2(96.42,55.75) v2(96.39,53.01) v2(96.47,60.35) v2(96.62,68.35) v2(96.9,66.7) v2(96.9,65.81) v2(96.89,63.99) v2(98.44,32.75) v2(98.46,58.89) v2(98.46,57.01) v2(98.49,55.65) v2(98.49,54.41) v2(98.51,33.34) v2(98.56,45.09) v2(98.84,112.43) v2(99.03,46.07) v2(99.07,47.08) v2(99.1,33.36) v2(99.22,38.16) v2(99.73,74.13) v2(99.73,71.89) v2(99.73,70.88) v2(99.73,69.87) v2(99.73,68.85) v2(99.73,67.83) v2(99.73,65.8) v2(99.76,73.14) v2(99.76,67.04) v2(99.99,116.37) v2(100.32,47.18) v2(100.32,45.07) v2(100.78,46.05) v2(101.48,71.89) v2(101.48,69.87) v2(101.48,68.85) v2(101.48,67.83) v2(101.51,67.04) v2(101.48,65.8) v2(105.57,91.45) v2(106.51,91.22) v2(107.99,119.77) v2(108.14,119.19) v2(108.42,117.89) v2(108.47,118.71) v2(108.77,122.39) v2(109.49,122.39) v2(112,119.06) v2(112.18,33.62) v2(112.18,33.03) v2(112.38,118.6) v2(112.76,33.62) v2(112.76,33.03) v2(112.89,85.81) v2(113.47,85.81) v2(114.08,85.79) v2(114.74,85.79) v2(116.85,102.6) v2(117.16,110.22) v2(117.54,113.52) v2(117.66,111.62) v2(140.09,16.83) v2(140.63,29.7) v2(140.74,29.12) v2(141.53,29.12) v2(152.18,26.83) v2(156.22,37.71) v2(156.81,37.71) v2(156.86,27.6) v2(157.39,37.71) v2(157.92,37.93) v2(157.92,27.37) v2(158.56,27.37) v2(166.08,19.21) v2(167.83,19.2) v2(169.1,25.59) v2(179.67,25.18) v2(184,9.87) v2(185.58,21.27) v2(188.28,17.2) v2(189.95,34.15) v2(190.43,10.98) v2(191.02,10.98) v2(191.6,10.98) v2(205.7,15.25) v2(213.04,50.71) v4(44.13,21.14) v4(44.18,20.2) v4(44.33,21.96) v4(44.87,21.12) v4(44.92,20.26) v4(45.1,21.93) v4(66.81,122.51) v4(67.53,123.22) v4(67.59,122.47) v4(68.33,123.22) v4(68.4,122.47) v4(69.15,123.2) v4(69.22,122.46) v4(119.54,37.26) v4(122.44,57.65) v4(122.43,56.84) v4(123.22,57.65) v4(123.23,56.84) v4(124.7,58.36) v4(124.7,57.62) v4(124.7,56.88) v4(125.44,59.14) v4(125.44,58.41) v4(125.44,57.67) v4(125.44,56.88) v4(125.41,56.12) v4(126.15,56.15) v4(126.1,55.41) v4(126.17,59.14) v4(126.17,58.41) v4(126.17,57.67) v4(126.17,56.93) v4(126.83,57.33) v4(126.79,56.52) v4(126.76,55.72) v4(126.87,58.94) v4(126.86,58.14) v4(129.64,44.58) v4(129.65,45.4) v4(129.66,43.73) v4(130.46,45.51) v4(130.47,44.68) v4(130.47,43.9) v4(131.2,43.8) v4(131.25,45.27) v4(131.25,44.54) v4(131.53,46.71) v4(131.53,45.94) v4(132.01,44.81) v4(131.95,43.96) v4(132.21,46.37) v4(132.22,45.59) v4(132.82,45.07) v4(132.75,44.29) v4(132.9,46.77) v4(132.87,45.99) v4(133.51,45.48) v4(133.51,44.66) v4(133.49,43.9) v4(133.62,46.21) v4(134.17,45.07) v4(134.17,44.33)
