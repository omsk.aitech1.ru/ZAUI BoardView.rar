# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V3A_BOOT: length 2.7
  BOTTOM w0.508: PR239.2 146.65,34.84 146.65,33.91 147.06,33.49 147.06,32.43
V3A_BOOT_R: length 2.5
  BOTTOM w0.102: v1(148.14,36.89) 148.14,36.38 148.02,36.26 PC229.1
  BOTTOM w0.508: PC229.1 147.08,35.81 PR239.1
V3A_EN: length 5.4
  TOP w0.203: PC79.2 144.71,32.2 PR77.1 144.08,32.47 143.32,32.47 v1(142.96,32.12) ; PC79.2 PR83.2 ; PC79.2 145.39,31.8 v1(145.6,31.58)
  BOTTOM w0.203: v1(142.96,32.12) 143.01,32.12 143.16,31.97 PU11.6
V3A_PWRGD: length 1.9
  BOTTOM w0.203: PU11.7 143.97,33.03 143.75,33.03 v1(143.29,33.49) PR244.1
V3A_VBYP: length 7.6
  TOP w0.203: PR70.2 145.54,36.5 v2(145.48,36.56) v1(146.45,36.56)
  TOP w0.381: PR68.1 144.24,37.29 144.84,36.69 145.35,36.69 v2(145.48,36.56)
  BOTTOM w0.203: PU11.11 145.95,33.42 145.83,33.54 145.83,33.88 145.4,34.32 145.4,34.73 145.2,34.94 145.2,35.51 PC227.1
  BOTTOM w0.381: PC227.1 145.23,35.68 145.48,35.93 v2(145.48,36.56)
V3A_VOUT: length 21.6
  TOP w0.254: v2(145.27,33.72) 145.44,33.55 PR78.2 ; PC71.2 145.23,35.05 145.5,35.32 146.09,35.32 146.45,34.95 PR72.2
  TOP w0.381: v2(145.27,33.72) 145.23,33.76 PC71.2
  IN3 w0.203: v2(158.81,37.25) 158.02,36.46 156.92,36.46 155.78,35.32 153.49,35.32 153.12,35.69 149.15,35.69 149.05,35.6 145.76,35.6 145.35,35.19 145.35,33.9 145.38,33.87 145.38,33.74 145.35,33.72 v2(145.27,33.72)
  BOTTOM w0.203: v2(145.27,33.72) 145.5,33.49 PU11.10 ; PR236.2 158.97,37.09 v2(158.81,37.25)
V5P5A_BOOT: length 2.4
  TOP w0.102: v1(42.43,17.99) 42.15,18.27 v2(41.72,18.27)
  TOP w0.508: v2(41.72,18.27) 41.68,18.31 PR115.2
  BOTTOM w0.229: PU15.1 41.78,18.34 v2(41.72,18.27)
V5P5A_BOOT_R: length 2.4
  TOP w0.102: v1(38.29,18.52) PC116.1
  TOP w0.508: PR115.1 39.97,18.52 PC116.1
V5P5A_EN: length 6.7
  BOTTOM w0.102: PR279.2 47.31,13.7 47.06,13.96 PC271.2 47.06,14.35 47.13,14.42 PR276.1 47.13,15.31 47.18,15.35 47.18,16.22 46.57,16.82 v1(46.57,17.62) 46.57,17.9 46.13,18.34 PU15.6
V5P5A_PWRGD: length 1.3
  BOTTOM w0.229: PR273.1 46.04,17.13 45.71,17.46 PU15.7
V5P5A_VOUT: length 8.1
  BOTTOM w0.229: PU15.10 43.78,16.64 PR274.2 44.27,16.14 43.8,15.67 43,15.67 PC267.2 42.55,15.16 42.55,14.52 42.22,14.19 PR278.2 41.62,13.42 41.34,13.7 v1(40.73,13.7) PR277.1
VCC1P8A: length 3.6
  BOTTOM w0.254: v2(98.47,53.72) v2(98.47,53.03) 98.19,52.76 U24.BW1 U24.BW2 ; v2(94.37,56.6) 94.37,56.51 U24.BM9 ; U24.BG9 94.08,57.99 v2(94.45,57.62) 94.45,57.5 U24.BJ9
VCC_AUX_SENSE: length 42.1
  TOP w0.102: v2(94.4,58.56) 94.42,58.56 94.88,59.02 96.96,59.02 v1(97.85,58.13) 99.76,58.13 100.2,57.68 101.1,57.68 104.84,53.94 109.38,53.94 v1(109.41,53.91)
  IN3 w0.089: v1(115.2,34.5) 114.98,34.72 113.79,34.72 112.39,36.12 112.39,39.6 111.64,40.35 111.64,44.91 110.26,46.29 110.26,48.35 108.82,49.79 108.82,51.99 109.83,52.99 109.83,53.49 v1(109.41,53.91)
  BOTTOM w0.079: v2(94.4,58.56) 94.4,58.64 U24.BF9
  BOTTOM w0.102: PR243.2 114.7,34.75 114.92,34.53 115.17,34.53 v1(115.2,34.5)
VCCA_CLKLDO_1V8: length 5
  BOTTOM w0.203: U24.DW15 90.86,32.89 90.86,31.91
  BOTTOM w0.508: 90.86,31.91 90.93,31.84 90.93,29.28 C651.2 90.86,29.2 R748.1
VCCAUX_VID0: length 122.6
  TOP w0.102: U10.2 109.92,38.5 108.94,39.48 PD3.2 108.94,40.23 109.18,40.47 110.65,40.47 110.83,40.3 110.83,39.89 111.16,39.56 v1(111.19,39.56) 111.52,39.23 111.52,38.64 111.14,38.26 111.14,36.39 111.59,35.94 111.59,34.78 111.64,34.73 111.64,33.01 108.99,30.35 108.44,30.35 108.22,30.13 108.22,29.21 106.97,27.96 106.97,27.64 v1(104.23,24.9) 103.24,24.9 102.7,24.37 101.79,24.37 99.58,22.17 94.96,22.17 94.75,21.96 v1(94.75,21.7) ; v1(62.16,29.32) 62.16,29.65 61.73,30.09 61.73,39.21 R270.2
  IN1 w0.089: v1(111.19,39.56) 110.98,39.36 110.76,39.36 110.63,39.48 110.63,40.22 110.68,40.27 133.16,40.27 134.18,41.29 134.18,43.07 134.73,43.62 137.35,43.62 138.26,44.54 138.26,45.15 138.44,45.33 139.01,45.33 v1(139.03,45.35) ; v1(62.16,29.32) 61.71,28.87 61.71,28.68 62.75,27.64 62.75,26.91 63.58,26.08 63.58,24.98 64.62,23.94 67.04,23.94 68.31,22.67 70.34,22.67 72.8,20.21 76.38,20.21 77,19.59 80.05,19.59 82.5,22.05 88.9,22.05 90.7,20.24 94.26,20.24 94.75,20.74 v1(94.75,21.7)
  BOTTOM w0.102: v1(139.03,45.35) PR222.1 139.03,46.28 139.03,46.29 PR218.2 139.03,46.75 138.85,46.92 PR212.1
VCCAUX_VID0_R: length 22.5
  TOP w0.102: v2(79.63,46.47) 79.21,46.05 78.62,46.05 78.42,46.25 77.56,46.25 77.24,45.93 76.66,45.93 76.09,45.36 74.61,45.36 73.68,44.44 73.41,44.44 72.2,43.22 72.2,42.49 71.67,41.95 69.4,41.95 69.37,41.92 67.17,41.92 66.61,41.36 65.7,41.36 65.57,41.24 R266.2 65.44,40.93 65.37,41.01 65.37,41.14 65.01,41.49 63.95,41.49 63.85,41.39 63.34,41.39 62.04,40.09 62.04,39.96 R270.1
  BOTTOM w0.114: U24.CL38 79.68,46.54 79.68,46.49 79.65,46.47 79.63,46.47 v2(79.63,46.47)
VCCAUX_VID1: length 119.1
  TOP w0.102: U10.1 110.57,38.65 110.24,38.99 PD3.1 110.46,39.75 110.63,39.58 110.63,39.38 v1(111.09,38.92) 111.09,38.92 111.09,38.51 110.93,38.35 110.93,36.31 111.39,35.85 111.39,34.7 111.44,34.65 111.44,33.09 108.9,30.55 108.35,30.55 108.01,30.21 108.01,29.3 106.76,28.05 106.76,27.79 105.22,26.25 v1(104.3,26.25) 102.62,24.57 101.7,24.57 99.5,22.37 94.58,22.37 94.45,22.24 v1(94.37,22.24) ; v1(62.28,28.68) 62.28,28.78 62.6,29.09 62.6,29.53 61.94,30.19 61.94,38.65 R271.2
  IN1 w0.089: v1(111.09,38.92) 110.83,39.18 110.68,39.18 110.45,39.41 110.45,40.3 110.6,40.45 133.08,40.45 134,41.36 134,43.14 134.66,43.8 137.27,43.8 138.09,44.61 138.09,45.12 137.87,45.34 v1(137.48,45.34) ; v1(62.28,28.68) 62.28,28.36 62.93,27.71 62.93,26.99 63.76,26.15 63.76,25.05 64.7,24.12 67.12,24.12 68.39,22.85 70.42,22.85 72.87,20.39 76.48,20.39 77.02,19.85 79.97,19.85 82.35,22.22 89.02,22.22 90.83,20.42 94.18,20.42 94.58,20.81 94.58,21.3 94.35,21.53 94.35,21.96 94.37,21.98 v1(94.37,22.24)
  BOTTOM w0.102: v1(137.48,45.34) 137.58,45.44 PR221.1 137.58,46.24 137.59,46.28 PR217.2 137.24,46.28 PR219.1
VCCAUX_VID1_R: length 24.9
  TOP w0.102: v2(79.7,47.27) 79.7,46.97 80.07,46.6 80.07,46.34 79.72,45.99 79.41,45.99 79.29,45.86 78.54,45.86 78.34,46.06 77.64,46.06 77.32,45.74 76.8,45.74 76.13,45.08 74.65,45.08 73.75,44.18 73.49,44.18 72.45,43.13 72.45,42.41 71.73,41.69 69.83,41.69 68.77,40.63 68.13,40.63 67.81,40.3 66.28,40.3 65.72,39.74 65.24,39.74 64.99,39.99 R269.2 64.99,40.4 65.14,40.55 65.14,41.03 64.91,41.26 64.04,41.26 63.94,41.16 63.43,41.16 62.55,40.27 R271.1
  BOTTOM w0.102: U24.CJ38 79.7,47.48 v2(79.7,47.27)
VCCDSW_3P3: length 17
  TOP w0.254: R268.1 97.58,40.24 C342.2 96.57,40.25 95.82,40.25 95.31,39.74 92.51,39.74 92.1,40.14 90.75,40.14 90.66,40.23 88.34,40.23 86.63,38.52 84.8,38.52 83.94,39.38 83.94,40.17 83.68,40.42 83.5,40.42 v2(83.48,40.45)
  BOTTOM w0.305: v2(83.48,40.45) 83.48,40.07 U24.DE31
VCCPLL_OC_DIS1: length 5.9
  TOP w0.254: R387.2 R386.1 48.33,26.06 47.76,26.63 v1(47.17,26.63) 47.17,26.7 47.49,27.02 Q17.6 48.94,27.02 49.03,27.11 49.03,27.47 48.83,27.67 Q17.5
VCCPLL_OC_DIS2:
  vias: v1(51.15,28.93)
VCCPLL_OC_EN_1: length 10.1
  TOP w0.254: Q17.2 49.46,27.67 49.21,27.93 49.21,29.31 R352.1 48.08,29.45 C380.1 46.17,29.44 45.53,30.09 45.53,32.17 v1(45.65,32.29) 45.78,32.42 46.62,32.42 Q14.2
VCCPLL_OC_EN_2: length 135.4
  TOP w0.102: v1(58.91,14.01) 59.42,14.01 59.64,14.23 U18.4 ; R457.1 R456.1 55.69,18.17 55.61,18.25 v1(55.61,18.27) 55.61,18.48 54.8,19.29 54.8,21.86 v1(54.29,22.36) ; v1(48.96,30.26) 49.06,30.26 49.16,30.16 49.44,30.16 49.85,29.75 R352.2
  IN1 w0.089: v1(55.61,18.27) 56.48,17.41 57.61,17.41 57.69,17.32 57.69,15.94 58,15.63 58,14.92 v1(58.91,14.01)
  IN2 w0.089: v1(48.96,30.26) 49.76,30.26 50.19,29.82 61.75,29.82 61.83,29.91 62.69,29.91 62.94,30.16 63.94,30.16 64.17,29.93 64.81,29.93 65.61,30.74 67.6,30.74 68.43,31.56 68.43,32.37 68.2,32.6 68.2,33.09 69.32,34.21 70.47,34.21 71.12,33.56 74.19,33.56 74.92,32.82 77.64,32.82 78.21,32.25 83.57,32.25 85.1,30.72 88.2,30.72 88.3,30.82 89.6,30.82 90.1,31.32 90.95,31.32 91.33,31.71 92.92,31.71 93.23,31.41 94.37,31.41 95.25,30.53 97.52,30.53 97.8,30.81 102.4,30.81 103.46,31.86 108.82,31.86 v1(109.21,31.48)
  IN3 w0.089: v1(109.21,31.48) 109.84,32.12 109.84,32.83 109.19,33.48 109.19,35.11 109.49,35.42 109.49,37.02 108.63,37.89 108.63,41.44 108.05,42.02 107.79,42.02 105.85,43.96 105.85,45.02 106.41,45.57 106.41,46.96 106.07,47.29 106.07,49.51 106.33,49.77 106.33,51.45 107.88,53 107.88,55.1 110.15,57.36 110.15,62.44 110.58,62.88 110.58,65.37 v1(110.15,65.8)
  BOTTOM w0.102: v1(54.29,22.36) v1(52.78,22.36) 51.27,22.36 50.99,22.08 50.35,22.08 49.97,22.47 49.97,23.93 48.88,25.02 48.88,30.19 v1(48.96,30.26) ; R614.2 109.95,65.6 v1(110.15,65.8)
VCCSENSE: length 78.9
  TOP w0.102: v1(121.6,69.56) 121.6,70.01 121.5,70.12 121.19,70.12 120.15,71.16 117.1,71.16 116.2,72.05 113.87,72.05 112.99,72.93 112.99,75.26 108.33,79.92 106.44,79.92 104.48,81.88 98.17,81.88 97.74,82.31 94.9,82.31 v1(94.2,81.61) 92,79.41 90.19,79.41 89.98,79.2 89.98,78.22 90.08,78.12 90.2,78.12 v2(90.39,78.31)
  IN1 w0.089: v1(144.23,54.02) 144.23,53.86 144.03,53.66 143.85,53.66 143.73,53.78 143.73,54.95 142.76,55.92 142.76,58.92 142.16,59.52 142.16,60.15 141.32,60.98 139.3,60.98 137.44,62.85 134.66,62.85 133.15,64.36 133.15,67.18 129.75,70.57 122.37,70.57 121.93,70.14 121.93,69.89 v1(121.6,69.56)
  BOTTOM w0.102: PR184.2 144.23,54.31 v1(144.23,54.02) ; v1(121.6,69.56) 121.6,69.33 121.47,69.2 PR159.2 ; v2(90.39,78.31) 90.14,78.31 89.92,78.53 U24.F17
VCCSPI: length 20
  TOP w0.254: v2(81.53,41.73) 81.77,41.73 82.23,41.26 82.23,40.9 82.1,40.78 82.1,39.25 82.52,38.84 83.51,38.84 84.51,37.83 86.91,37.83 87.25,38.17 89.14,38.17 89.4,38.43 91.3,38.43 91.75,38.88 93.46,38.88 93.93,38.42 95.59,38.42 96.71,37.3 R283.2
  BOTTOM w0.254: U24.DB34 81.9,41.36 v2(81.53,41.73)
VCCST_EN: length 26.2
  TOP w0.254: PD3.3 111.23,41.45 v1(111.24,41.44) 111.85,40.83 112.96,40.83 113.24,41.11 113.24,43.4 D7.1 111.02,45.63 v1(111.02,46.69) 111.02,47.75 110.69,48.09 D6.1 110.69,49.75 v1(110.93,50)
  BOTTOM w0.203: R675.2 R680.2 ; R681.2 R676.1 R674.1 111.36,41.57 v1(111.24,41.44)
  BOTTOM w0.254: R681.2 R680.2 ; Q39.5 112.84,56.17 113.12,55.89 113.12,53.58 112.08,52.54 112.08,52.34 111.58,51.84 U25.1 111.58,50.45 111.14,50 v1(110.93,50) U25.2
VCCST_OR_TCSS: length 7
  TOP w0.203: D7.2 110.29,43.01 109.99,42.71 109.08,42.71 v1(108.98,42.81) 108.19,42.81 v2(108.11,42.73)
  BOTTOM w0.203: R669.2 R668.2 108.31,42.1 108.11,42.3 v2(108.11,42.73) ; R669.2 R670.2 ; R669.2 109.38,41.87 109.18,41.67 Q40.5
VCCST_OVERRIDE: length 20.4
  TOP w0.102: v1(109.46,43.8) 109.46,44.46 v1(108.9,45.02) 108.34,45.58 105.62,45.58 105.32,45.88 105.32,46.62 104.5,47.43 103.11,47.43 100.09,50.46 97.6,50.46 96.52,49.38 v2(95.71,49.38)
  BOTTOM w0.079: U24.CE4 95.95,49.61 95.83,49.49
  BOTTOM w0.102: R669.1 109.38,42.71 R661.2 109.01,43.22 109.46,43.67 v1(109.46,43.8) ; 95.83,49.49 v2(95.71,49.38)
VCCST_PWRGD: length 23.3
  IN2 w0.089: v1(109.76,47.48) 108.8,48.45 108.8,50.71 107.96,51.55 105.78,51.55 105.04,52.28 103.74,52.28 103.54,52.08 103.54,51.27 v1(103.57,51.24)
  BOTTOM w0.102: U26.4 109.14,46.11 C605.2 109.76,45.84 v1(109.76,47.48) 110.23,47.02 D43.2 ; R637.1 101.78,51.06 C601.2 102.8,51.08 R638.2 102.8,53.27 102.78,53.29 D33.2 103.29,54.09 103.54,53.83 103.54,52.92 103.34,52.72 103.34,51.75 103.57,51.52 v1(103.57,51.24)
VCCST_PWRGD_EN: length 5
  BOTTOM w0.102: v1(105.99,52.79) R636.1 105.99,51.3 105.73,51.05 R641.1 R642.2 106.03,50.21 U27.2
VCCST_PWRGD_EN_L: length 8.6
  BOTTOM w0.102: v1(107.51,51.74) R642.1 C600.2 108.49,50.89 U26.2 108.49,48.6 107.81,47.92 106.78,47.92 106.68,47.81 U27.4 106.68,45.6 C607.2
VCCST_PWRGD_TCSS: length 15.7
  TOP w0.102: v1(107.43,43.65) 107.43,44.28 107.12,44.59 105.62,44.59 v1(105,45.21) 104.38,45.83 104.38,46.49 103.85,47.03 102.94,47.03 100.1,49.87 v2(99.05,49.87)
  BOTTOM w0.079: v2(99.05,49.87) 98.72,49.87 98.38,49.53 97.17,49.53 U24.CE3
  BOTTOM w0.102: v1(107.43,43.65) 107.86,43.22 R660.2 108.21,43.22 108.66,42.77 R668.1
VCCSTG_EN2: length 8.7
  BOTTOM w0.254: C586.1 106.05,63.49 Q36.2 106.48,64.54 106.84,64.91 106.84,65.82 107.2,66.18 108.55,66.18 108.73,66.18 108.86,66.05 R614.1 109.82,66.66 109.82,67.73 109.61,67.93 Q35.2
VCCSTPLL_DIS1: length 12.1
  TOP w0.254: v1(110.15,55.23) 110.53,55.23 v1(111.54,56.25) 112.56,57.26 112.56,58.66 113.04,59.14 v1(113.04,61.81)
  BOTTOM w0.254: v1(110.15,55.23) 110.04,55.33 R624.2 ; Q38.6 113.87,61.16 114.11,61.4 R618.1 113.57,61.95 113.42,61.81 v1(113.04,61.81) 113.22,61.63 Q38.5
VDDQ_BOOT: length 2
  TOP w0.203: PU1.18 61.91,120.39 v1(61.83,120.31)
  BOTTOM w0.508: v1(61.83,120.31) 61.37,119.85 PR132.2
VDDQ_PG: length 1.7
  TOP w0.203: PU1.8 v1(66.39,121.04)
  BOTTOM w0.152: PR128.2 66.62,121.27
  BOTTOM w0.203: 66.62,121.27 v1(66.39,121.04)
VDDQ_SLP_S4: length 3.7
  TOP w0.203: PU1.11 65.02,122.78 v1(65.54,123.31)
  BOTTOM w0.152: PR126.2 65.53,124.33 65.62,124.42 PR124.2
  BOTTOM w0.178: PR126.2 65.53,123.32
  BOTTOM w0.305: PC125.2 64.78,124.07 v1(65.54,123.31)
VDDQ_SW:
  vias: v1(61,121.22) v4(60.34,122.27)
VDDQ_VDDQSNS: length 7.3
  TOP w0.203: PR7.2 60.49,118.15 61.05,117.59 63.05,117.59 63.37,117.28 64.55,117.28 65.18,117.9 65.18,118.74 65.02,118.9 PU1.5
VDDQ_VTT: length 2.2
  TOP w0.152: PR8.1 64.66,118.08 64.19,117.62 63.56,117.62 63.11,118.06 PC18.1 63.11,118.2
  vias: v4(63.23,118.81)
VDDQ_VTT_CNTL: length 3.8
  TOP w0.203: PU1.10 65.83,122.28 66.09,122.54 66.09,123.08 66.57,123.56 v1(66.74,123.56)
  BOTTOM w0.152: PC126.2 67.43,124.35 PR125.2
  BOTTOM w0.305: v1(66.74,123.56) 66.74,123.72 67.15,124.14 PC126.2
VDDQ_VTTREF: length 4.5
  TOP w0.203: PR9.1 67.34,117.79 66.34,117.79 PC15.2 66.18,118.65 66.18,119.42 65.8,119.8 PU1.6
VDDQ_VTTSNS: length 1.2
  TOP w0.152: PU1.4 64.52,118.76 PR8.2
VSS_AUX_SENSE: length 43.5
  TOP w0.102: v1(109.43,54.6) 109,54.16 104.94,54.16 101.2,57.91 100.3,57.91 99.85,58.36 98.44,58.36 97.55,59.25 v1(97.55,59.42) 97.37,59.24 94.55,59.24 v2(94.4,59.4)
  IN3 w0.089: v1(109.43,54.6) 110.02,54.01 110.02,52.91 109.02,51.91 109.02,49.87 110.45,48.43 110.45,46.37 111.83,44.99 111.83,40.43 112.58,39.68 112.58,36.2 113.87,34.91 115.45,34.91 v1(115.86,34.5)
  BOTTOM w0.079: U24.BD9 94.4,59.56 v2(94.4,59.4)
  BOTTOM w0.102: v1(115.86,34.5) 115.42,34.94 PR242.2
VSSSENSE: length 81.3
  TOP w0.102: v1(122.24,69.53) 122.24,69.69 121.61,70.32 121.28,70.32 120.24,71.36 117.18,71.36 116.28,72.26 113.95,72.26 113.19,73.02 113.19,75.35 108.42,80.12 106.59,80.12 104.63,82.08 98.26,82.08 97.83,82.51 94.35,82.51 v1(92.91,81.08) 91.45,79.62 90.1,79.62 89.77,79.28 89.77,78.13 89.99,77.91 90.12,77.91 v2(90.35,77.68)
  IN1 w0.089: v1(122.24,69.53) 122.11,69.66 122.11,70.06 122.44,70.39 129.68,70.39 132.97,67.11 132.97,64.29 134.59,62.67 137.37,62.67 139.23,60.81 141.25,60.81 141.98,60.08 141.98,59.41 142.58,58.8 142.58,55.85 143.55,54.88 143.55,53.71 143.78,53.48 144.23,53.48 v1(144.34,53.36)
  BOTTOM w0.102: v1(144.34,53.36) 144.27,53.36 143.8,53.83 143.8,54.03 PR185.2 ; PR162.2 122.49,67.51 122.55,67.57 122.55,69.22 v1(122.24,69.53) ; U24.G17 v2(90.35,77.68)
1.03_GFX_PGD: length 101.3
  IN1 w0.089: v1(109.82,81.7) 110.78,80.73 115.94,80.73 117.56,79.11 129.68,79.11 130.47,79.9 139.98,79.9 142.72,77.16 142.72,65.76 142.38,65.42 142.38,65.39 v1(142.38,65.39)
  IN2 w0.089: v1(109.82,81.7) 109.43,81.7 109.19,81.94 106.58,81.94 105.68,82.84 104.63,82.84 104.4,82.6 102.44,82.6 100.87,84.17 98.21,84.17 96.69,85.69 96.69,88.49 94.01,91.17 93.4,91.17 91.76,92.81 91.76,98.67 88.96,101.46 84.9,101.46 82.66,103.69 77.43,103.69 v1(75.88,105.24)
  BOTTOM w0.102: PR147.2 PR148.1 77.15,102.73 77.28,102.86 77.28,103.49 76.26,104.51 76.26,104.86 v1(75.88,105.24)
  BOTTOM w0.254: v1(142.38,65.39) 142.35,65.42 142.35,66.01 PR166.1
2ND_MBCLK: length 125.2
  TOP w0.102: v2(90.66,25.13) 90.66,26.13 R380.1 ; R315.1 190.71,31.57 v2(190.74,31.54) 190.74,31.44 190.05,30.74 U13.115 ; v2(172.71,28.96) 172.71,29.58 172.17,30.11 172.17,30.62 172.27,30.72 Q15.3
  IN1 w0.089: v2(172.71,28.96) 172.71,29.37 172.83,29.5 174.86,29.5 175.88,30.52 179.21,30.52 179.48,30.24 181.63,30.24 182.22,30.83 188.9,30.83 190,31.94 190.5,31.94 190.74,31.7 v2(190.74,31.54) 190.74,30.41 190.94,30.21 194.12,30.21 195.29,29.04 195.29,28.41 196.05,27.65 v2(196.48,27.65)
  IN2 w0.089: v2(90.66,25.13) 90.69,25.13 91.2,24.62 91.9,24.62 92.11,24.84 93.94,24.84 94.15,24.62 95.46,24.62 95.88,24.2 96.86,24.2 97.2,23.86 100.27,23.86 100.63,24.23 100.63,25.45 101.19,26.01 106.78,26.01 108.36,27.58 109.3,27.58 110.11,28.39 110.11,29.26 110.46,29.62 123.85,29.62 125.77,31.53 135.18,31.53 135.76,30.96 138.65,30.96 139,30.61 139.99,30.61 140.17,30.8 141.59,30.8 141.94,30.44 151.18,30.44 151.61,30.01 155.21,30.01 155.57,29.65 158.54,29.65 159,29.18 160.32,29.18 160.59,28.92 170.98,28.92 171.3,28.6 172.36,28.6 172.71,28.94 v2(172.71,28.96)
  BOTTOM w0.102: R746.2 198.13,28.08 197.99,28.22 197.05,28.22 v2(196.48,27.65)
2ND_MBDATA: length 131.7
  TOP w0.102: v2(91.25,25.13) 91.25,25.87 91.37,26 R381.1 ; v2(174.46,29.04) 174.89,29.48 174.89,30.51 175.32,30.95 175.32,32.09 175.03,32.39 Q15.6 ; R314.1 189.98,31.72 v2(190.16,31.54) 189.65,31.03 U13.116
  IN1 w0.089: v2(174.46,29.04) 175.04,29.04 176.1,30.1 178.92,30.1 179.11,29.9 181.77,29.9 182.35,30.48 189.07,30.48 190.13,31.54 v2(190.16,31.54) 190.16,30.36 190.69,29.83 193.99,29.83 194.93,28.89 194.93,28.28 195.11,28.1 195.11,27.16 195.64,26.63 196.86,26.63 197.9,25.59 200.21,25.59 200.29,25.51 v2(201.38,25.51)
  IN2 w0.089: v2(91.25,25.13) 91.41,24.97 91.76,24.97 91.97,25.18 94.08,25.18 94.3,24.97 95.6,24.97 96.02,24.55 97,24.55 97.34,24.2 100.13,24.2 100.29,24.37 100.29,25.59 101.05,26.35 103.01,26.35 103.29,26.63 106.92,26.63 108.22,27.93 109.15,27.93 109.76,28.54 109.76,29.41 110.32,29.96 123.63,29.96 125.58,31.9 136.45,31.9 136.92,31.43 137.22,31.43 137.35,31.3 138.93,31.3 139.28,30.95 139.85,30.95 140.03,31.14 141.73,31.14 142.05,30.82 151.29,30.82 151.75,30.35 155.35,30.35 155.71,29.99 158.68,29.99 159.09,29.58 160.42,29.58 160.67,29.33 171.05,29.33 171.44,28.94 172.15,28.94 172.63,29.42 174.08,29.42 v2(174.46,29.04)
  BOTTOM w0.102: v2(201.38,25.51) 201.38,25.54 201.26,25.67 R754.2
17SZ_EN2: length 9.5
  TOP w0.102: U18.2 58.99,11.97 58.89,11.87 v1(58.69,11.87) 58.5,11.87 58.34,12.03 U18.1 57.86,12.94 C463.1 57.34,13.83 57.56,14.05 R473.2 57.56,14.47 57.21,14.82 R467.2 55.71,15 55.56,15.15 Q24.5 55.56,16.17 55.74,16.34 56.01,16.34 R457.2
27M_XTAL_IN: length 9.7
  BOTTOM w0.102: Y2.3 101,86.88 101,88.36 C555.1 101.43,88.98 101.43,90.27 102.2,91.03 102.2,92.64 102.26,92.71 102.26,93.65 102.21,93.7 102.21,94.29 U22.C11
27M_XTAL_OUT: length 8.6
  BOTTOM w0.102: Y2.1 100.33,87.7 100.52,87.9 100.52,88.88 C554.1 100.77,88.89 100.93,89.04 100.93,89.36 100.82,89.46 100.57,89.46 100.47,89.56 100.47,89.87 100.57,89.97 100.82,89.97 100.93,90.07 100.93,90.45 101.66,91.18 101.66,92.44 102.05,92.83 102.05,93.57 102,93.62 102,93.78 101.95,93.83 U22.B10
80PORT_CLK: length 167.5
  TOP w0.102: U13.31 184,16.18 184.16,16.34 185.23,16.34 185.84,16.95 185.84,17.64 v2(185.66,17.82)
  IN2 w0.089: v1(46.62,8.88) 46.62,8.95 47.39,9.72 47.39,11.93 48.4,12.95 51.33,12.95 51.8,12.48 60.34,12.48 61.15,11.67 71.81,11.67 72.39,12.25 73.93,12.25 74.62,11.57 80.1,11.57 82.56,9.1 82.79,9.1 83.3,8.6 88.77,8.6 93.87,13.69 112.11,13.69 114.71,16.29 122.61,16.29 123.12,16.8 125.13,16.8 125.65,16.29 154.81,16.29 155.46,16.93 155.46,17.31 155.59,17.44 156.53,17.44 157.04,16.92 172.14,16.92 173.04,17.82 174.06,17.82 174.35,17.53 177.42,17.53 178.02,18.13 180.71,18.13 180.91,18.33 185.15,18.33 v2(185.66,17.82) 185.66,17.66 186.22,17.11 187.64,17.11 187.79,16.95 187.79,16.43 188.43,15.79 190.64,15.79 191.05,15.38 192.02,15.38 192.85,16.22 193.51,16.22 193.69,16.39 v2(193.69,16.41)
  BOTTOM w0.102: R831.1 193.51,16.22 193.69,16.39 v2(193.69,16.41) ; CN17.3 45.95,10.82 45.5,10.37 45.5,9.66 45.63,9.54 46.07,9.54 46.33,9.28 46.33,9.16 v1(46.62,8.88)
80PORT_DAT: length 176.9
  TOP w0.102: v2(197.75,22.06) 197.95,22.26 197.95,22.83 198.1,22.98 U13.83
  IN2 w0.089: v1(45.99,8.88) 45.99,9.08 46.29,9.38 46.78,9.38 47.2,9.8 47.2,12.01 48.32,13.14 51.41,13.14 51.88,12.67 60.48,12.67 61.29,11.86 71.73,11.86 72.32,12.44 74.09,12.44 74.78,11.76 80.45,11.76 83.06,9.16 83.29,9.16 83.53,8.91 88.82,8.91 93.79,13.88 111.92,13.88 114.52,16.48 122.53,16.48 123.05,16.99 125.21,16.99 125.72,16.48 138.58,16.48 139.33,17.23 142.18,17.23 142.93,16.48 154.73,16.48 155.27,17.01 155.27,17.39 155.51,17.63 156.61,17.63 157.12,17.11 171.8,17.11 172.74,18.05 174.12,18.05 174.35,18.28 177.89,18.28 177.93,18.32 180.63,18.32 180.83,18.52 185.71,18.52 186.37,17.86 187.23,17.86 187.48,17.61 188.43,17.61 188.65,17.84 189.25,17.84 189.37,17.72 190.74,17.72 191.24,17.21 193.9,17.21 v2(193.97,17.14)
  IN3 w0.089: v2(193.97,17.14) 194.31,17.14 194.7,16.75 194.7,16.37 196.16,14.91 196.47,14.91 197.42,15.86 197.42,18.68 197.34,18.76 197.34,19.9 197.93,20.49 197.93,21.63 197.75,21.81 v2(197.75,22.06)
  BOTTOM w0.102: CN17.4 45.45,10.83 45.27,10.65 45.27,9.57 45.54,9.31 45.98,9.31 46.1,9.18 46.1,8.99 v1(45.99,8.88) ; v2(193.97,17.14) 193.95,17.14 193.76,16.95 R830.1
5213EN_1.8V: length 3.3
  TOP w0.102: PU5.7 39.61,29.38 39.43,29.2 39.43,28.43 38.95,27.95 PC94.1 PR94.1
5213FB_1.8V: length 5.5
  TOP w0.254: PU5.1 42.01,28.88 40.98,27.85 v1(40.98,27.34) 40.98,26.86 41.11,26.73 PR104.2 40.31,26.31 PR103.2 39.34,26.14 PC100.2
5213FB_1.8V_S: length 4.8
  TOP w0.254: PR103.1 39.74,25.69 39.58,25.53 PC100.1 38.54,25.53 37.8,26.28 36.97,26.28 v1(36.74,26.5) 36.26,26.99 PR95.1
5213LX_1.8V:
  vias: v1(39.74,31.71)
5213PG_1.8V: length 2.9
  TOP w0.102: PU5.2 42.81,29.38 43.01,29.17 43.01,28 v1(42.94,27.93) 42.91,27.9 PR91.2
5447_CC1_CON: length 25.7
  TOP w0.102: C438.2 10.98,18.87 11.36,19.26 v1(11.36,19.32)
  TOP w0.508: C438.2 10.98,18.27 10.55,17.84 v1(10.48,17.84)
  IN1 w0.508: v1(12,12.56) 12.51,12.05 15.05,12.05 15.61,12.61 16.72,12.61 18.45,14.34 21.14,14.34 21.62,13.86 v1(22.49,13.86)
  IN3 w0.508: v1(10.48,17.84) 10.48,15.73 9.59,14.85 9.59,14.62 9.25,14.28 v1(9.03,14.28) 9.61,13.7 10.86,13.7 v1(12,12.56)
  BOTTOM w0.203: v1(22.49,13.86) 22.55,13.86 23.04,14.36 U36.11 ; v1(9.03,14.28) 8.89,14.41 8.49,14.41 7.76,15.15 CN14.A5
  BOTTOM w0.508: v1(10.48,17.84) 10.48,17.88 D38.2
5447_CC2_CON: length 32.5
  IN1 w0.508: v1(22.49,15.15) 17.76,15.15 16.72,14.11 15.45,14.11 15.11,13.77 15.11,13.26 14.67,12.81 12.76,12.81 11.75,13.83 11.75,14.21 v1(11.49,14.46)
  IN2 w0.102: CN14.B5 5.66,17.18 5.66,17.42 6.07,17.83
  IN2 w0.127: 6.07,17.83 6.67,18.43 9.03,18.43 v2(9.21,18.6)
  IN3 w0.102: CN14.B5 5.66,17.18 5.66,17.42 6.07,17.83
  IN3 w0.127: 6.27,18.03 6.07,17.83
  IN3 w0.508: v1(11.49,14.46) 11.09,14.87 11.09,18.17 10.73,18.53 10.26,18.53 10.18,18.6 v2(9.21,18.6) 9.21,18.34 8.9,18.03 6.27,18.03
  BOTTOM w0.203: U36.13 22.7,15.36 v1(22.49,15.15)
  BOTTOM w0.254: D41.2 v1(11.23,12.97)
  BOTTOM w0.508: C711.2 11.22,13.84 D41.2 11.23,14.2 v1(11.49,14.46)
8813BOOT1:
  vias: v1(76.52,113.47)
8813BOOT2:
  vias: v1(76.57,108.34)
8813EN: length 6.9
  TOP w0.254: PR11.1 74.99,116.94 74.99,116.57 75.49,116.07 PD1.2 74.87,115.04 PR17.2 PC20.1 74.04,114.24 v1(74.1,114.24) 74.23,114.11 PU2.3
8813ILIM: length 4.3
  TOP w0.254: v1(71.55,108.61) 71.51,108.64 71.51,109.41 71.63,109.53 PU2.12
  BOTTOM w0.254: v1(71.55,108.61) 71.68,108.47 72.68,108.47 72.92,108.23 PC147.1 74.31,108.23 PR144.1
8813ISEN1: length 4.5
  TOP w0.203: PC29.2 72.08,107.06 73.01,106.12 PR31.2 73.62,106.66 73.62,107.58 v1(73.47,107.73) 73.73,107.99 PU2.15
8813ISEN2: length 3
  TOP w0.203: PR30.2 71.15,107.5 71.51,107.86 v1(71.92,107.86) 72.22,108.16 72.99,108.16 73.23,108.39 PU2.14
8813LGAT1: length 6
  BOTTOM w0.559: v4(77.28,111.85) 77.28,112.51 75.98,113.8 v1(75.98,116.14) PQ14.8
8813LGAT2: length 6.6
  TOP w0.508: v4(83.68,109.97) 83.55,109.84 v1(82.15,109.84) 77.15,109.84 77.15,109.84
8813PG: length 3.2
  TOP w0.203: PR32.2 73.87,105.91 73.87,106.44 74.13,106.69 ; PU2.16 74.23,107.96 74.13,107.86 PR29.2 74.13,106.69 ; 74.13,106.69 v1(74.24,106.69)
8813PHASE1: length 6.8
  TOP w0.635: PR10.2 79.03,117.97 v4(79.23,117.77) 79.23,117.44 78.8,117 v1(78.8,114.31) 78.8,113.91 77.85,112.95 77.61,112.95
8813PHASE2: length 10.3
  TOP w0.635: 77.91,109.04 79.47,109.04 79.51,109.08 v1(80.28,109.08) 80.31,109.04 PR27.2 84.02,109.04 v4(84.44,109.46)
  BOTTOM w0.508: v4(84.44,109.46) 84.44,110.68 83.63,111.49 82.38,111.49
  vias: v1(79.69,112.23)
8813PSI: length 7.1
  TOP w0.102: PR14.2 71.31,117.11 v1(71.49,117.28)
  TOP w0.254: PR13.2 70.54,116.25 70.64,116.15 PR14.2 71.45,116.15 72.17,115.43 72.21,115.43 PR15.2 72.41,115.37 72.71,115.07 72.71,114.72 73.73,113.7 PU2.4
8813PVCC: length 6.3
  TOP w0.254: PC25.1 78.55,110.49 77,110.49 76.94,110.55 76.65,110.55 76.62,110.53 PU2.21
  TOP w0.381: PC25.1 v1(79.21,110.52)
  BOTTOM w0.508: v1(79.21,110.52) 78.43,110.52 v1(77.84,109.93) PR143.2
8813REFADJ: length 2.3
  TOP w0.254: v1(72.02,112.81) 72.15,112.81 72.2,112.76 PU2.6
  BOTTOM w0.254: PR139.2 72.64,113.05 72.4,112.81 v1(72.02,112.81)
8813REFIN: length 6.4
  TOP w0.254: PC22.1 71.05,112.81 v1(71.39,112.81) 71.39,112.3 71.66,112.03 PU2.7
  BOTTOM w0.102: v1(69.07,113.3) 69.12,113.34 PR138.1
  BOTTOM w0.254: PR138.1 70.33,113.42 70.88,113.42 71.31,112.99 71.31,112.89 v1(71.39,112.81) 71.49,112.91 71.49,113.84 PR137.2
8813RGN: length 3.5
  TOP w0.203: PR24.1 69.45,111.5 69.62,111.33 PC24.1
  TOP w0.254: PU2.10 71.38,110.53 71.07,110.84 PC26.2 70.18,110.84 70.09,110.93 PC24.1
8813TON: length 6.3
  TOP w0.178: PU2.9 71.51,111.03 70.85,111.7 70.47,111.7 69.71,112.46 69.71,112.84 68.67,113.88 v1(68.29,113.88) 67.33,113.88 PR21.1
8813UGATE1: length 0.5
  TOP w0.559: 74.84,113.93 v4(74.84,114.39)
  vias: v1(74.26,114.92)
8813UGATE1_1:
  vias: v1(70.22,116.75)
8813UGATE2:
  vias: v1(76.62,106.23)
8813UGATE2_1: length 6.4
  TOP w0.508: PR33.2 83.3,105.9 v1(83.75,105.45) 83.75,104.84 84.19,104.41 84.31,104.41 v4(84.34,104.38)
9336ADJ: length 6.1
  BOTTOM w0.254: PU8.5 75.88,98.16 75.45,98.59 75.45,99.05 75.17,99.33 74.33,99.33 73.46,100.2 PR150.2 72.85,100.2 v1(72.48,100.57) 72.48,100.82 72.68,101.03 PR149.2
9336DRV: length 5.8
  BOTTOM w0.254: PQ19.4 v1(71.92,95.02) 72.16,95.02 72.21,94.97 PD7.1 73.09,95.49 73.86,96.26 PR152.1 74.36,96.51 74.93,97.08 PU8.6
24780_ACDET: length 7.3
  TOP w0.102: v2(136.97,34.99) 136.97,35.14 137.26,35.43 PQ9.3 v1(138.8,35.43)
  BOTTOM w0.102: v2(136.97,34.99) 136.36,34.99 136.16,34.78 136.16,34.13 PR246.2
  BOTTOM w0.178: 135.02,32.41 PU12.6
  BOTTOM w0.203: PR246.2 PR245.2 135.67,33.06 135.02,32.41
24780_ACDRV: length 1.9
  BOTTOM w0.178: 134.22,32.6 PU12.4
  BOTTOM w0.203: PR247.2 134.39,33.45 134.16,33.23 134.16,32.66 134.22,32.6
24780_ACN: length 146.5
  TOP w0.203: PC74.1 131.62,33.43 v2(131.62,34) ; PR19.2 52.49,114.16 52.77,114.16 53.02,113.91 v1(53.02,113.65)
  IN3 w0.203: v1(53.02,113.65) 53.19,113.65 53.22,113.68 54.65,113.68 55.09,113.23 55.09,111.4 55.71,110.78 61.02,110.78 62.09,109.71 64.2,109.71 64.7,109.21 67.5,109.21 67.75,109.46 69.4,109.46 70.75,108.11 71.99,108.11 72.71,108.83 75.05,108.83 77.49,106.39 79.39,106.39 79.52,106.26 82.66,106.26 83.37,106.97 88.33,106.97 91.68,103.62 91.68,101.33 93.07,99.93 93.07,98.69 93.49,98.27 94.11,98.27 94.55,97.83 94.79,97.83 95.76,96.85 95.76,95.41 97.54,93.64 97.93,93.64 98.82,92.75 99.15,92.75 99.6,92.29 99.6,91.65 99.99,91.27 100.82,91.27 101.41,90.68 102.11,90.68 102.53,90.26 103.4,90.26 105.98,87.68 105.98,82.92 113.35,75.55 113.35,65.09 112.58,64.32 112.58,61.3 113.12,60.77 113.12,58.64 112.63,58.15 112.63,54.47 114.74,52.36 114.74,49.76 116.31,48.2 120.87,48.2 122.78,46.29 122.78,37.54 126.91,33.41 131.24,33.41 131.62,33.79 v2(131.62,34)
  BOTTOM w0.178: 132.82,32.5 133.02,32.3 PU12.1
  BOTTOM w0.203: v2(131.62,34) 131.62,33.97 131.59,33.93 131.59,33.22 PC237.2 132.31,32.5 132.82,32.5
24780_ACP: length 149.2
  TOP w0.203: PC76.2 133.07,32.75 132.18,33.64 132.18,33.97 v2(132.21,34) ; v1(52.39,113.65) 52.24,113.65 PR18.2
  IN3 w0.203: v1(52.39,113.65) 52.39,113.52 52.77,113.14 53.4,113.14 53.63,113.37 54.44,113.37 54.74,113.08 54.74,111.3 55.56,110.48 60.89,110.48 61.96,109.41 63.99,109.41 64.5,108.9 67.63,108.9 67.88,109.16 69.26,109.16 70.62,107.8 72.13,107.8 72.84,108.51 74.94,108.51 77.36,106.09 79.26,106.09 79.41,105.94 82.78,105.94 83.5,106.67 88.2,106.67 91.37,103.5 91.37,101.2 92.77,99.81 92.77,98.56 93.36,97.96 93.98,97.96 94.42,97.52 94.66,97.52 95.46,96.72 95.46,95.29 97.41,93.33 97.8,93.33 98.69,92.44 99.02,92.44 99.3,92.16 99.3,91.53 99.86,90.97 100.69,90.97 101.29,90.37 101.98,90.37 102.4,89.95 103.27,89.95 105.68,87.55 105.68,82.79 113.04,75.43 113.04,65.21 112.28,64.45 112.28,61.17 112.81,60.64 112.81,58.76 112.33,58.28 112.33,54.34 114.44,52.23 114.44,49.62 116.17,47.89 120.75,47.89 122.46,46.17 122.46,37.35 126.71,33.11 131.76,33.11 132.21,33.55 v2(132.21,34)
  BOTTOM w0.178: PU12.2 133.42,32.51
  BOTTOM w0.203: v2(132.21,34) 132.18,33.97 132.18,33.41 PC237.1 132.63,32.96 132.98,32.96 133.42,32.51
24780_BATDRV: length 5.1
  TOP w0.508: PR99.2 131.47,26.34 v1(131.28,26.15) 132.01,26.15 v1(132.22,26.35)
  BOTTOM w0.178: 134.22,27.4 PU12.18
  BOTTOM w0.203: 134.22,27.4 133.08,26.26 132.31,26.26 v1(132.22,26.35)
24780_BATSRC: length 5.1
  TOP w0.508: v1(134.3,26.4) 134.3,26.27 v1(133.16,25.13) PR108.2
  BOTTOM w0.178: PU12.17 134.62,27.33
  BOTTOM w0.203: v1(134.3,26.4) 134.3,27.01 134.62,27.33
24780_BM#: length 3.6
  BOTTOM w0.178: PU12.16 135.02,27.08 v1(135.27,26.83) 135.52,27.09 135.52,27.19 135.96,27.62 136.84,27.62 136.91,27.55 PR264.1
24780_CMPIN: length 3.6
  TOP w0.178: PR85.1 137.55,30.4 v1(137.55,29.7) v1(137.55,28.74)
  BOTTOM w0.178: v1(137.55,28.74) 137.53,28.74 137.5,28.76 137.19,28.76 136.85,29.11 PU12.13
24780_CMPOUT: length 2.5
  BOTTOM w0.178: PR265.1 137.61,28.18 137.32,28.18 136.8,28.71 PU12.14
24780_CMSRC: length 1.6
  BOTTOM w0.178: 133.82,32.72 PU12.3
  BOTTOM w0.203: 133.82,32.72 133.62,32.93 PR248.2
24780_DH: length 10.2
  IN3 w0.508: v1(122.73,31.9) 122.73,31.69 123.26,31.16 128.45,31.16 129.25,30.36 v1(131.23,30.36)
  BOTTOM w0.508: v1(122.73,31.9) 122.73,31.7 122.98,31.45 PQ26.4
24780_DL: length 5.6
  IN3 w0.508: v1(126.73,27.97) 127.89,27.97 128.1,28.18 130.67,28.18 131.25,28.76 131.25,28.79 v1(131.28,28.82)
  BOTTOM w0.508: PQ27.4 v1(126.73,27.97)
24780_ILIM: length 5
  TOP w0.102: v1(131.89,28.13) 132.14,27.88 132.14,27.29 132.53,26.9 PR97.1 PC96.2 134.07,27.29 PR98.1
  BOTTOM w0.178: v1(131.89,28.13) 132.35,28.13 132.57,27.91 PU12.21
24780_LX: length 5.7
  BOTTOM w0.508: 130.38,31.36 129.61,32.13 126.54,32.13 125.87,31.45 PQ26.1
24780_SRN: length 12.5
  BOTTOM w0.152: PR271.1 120.87,24.59 121.44,24.59 121.74,24.89 124.85,24.89 125.96,26 127.55,26 128.58,27.04 128.83,27.04 PC253.1 129.8,27.63 PC254.2 130.41,27.63 130.67,27.37 130.67,26.91 130.87,26.71 PR267.2
24780_SRP: length 12.9
  BOTTOM w0.152: PR270.1 120.92,24.87 121.32,24.87 121.62,25.17 124.74,25.17 125.85,26.28 127.43,26.28 128.47,27.32 128.7,27.32 PC253.2 129.74,28.35 PC248.2 130.09,28.23 v1(130.8,28.23) 131,28.02 PR261.2
24780_VCC: length 4.7
  TOP w0.381: v1(129.12,28.43) 129.4,28.71 PR81.1
  TOP w0.406: v1(131.08,32.32) 131.08,32.09 129.4,30.42 PR81.1
25810_AUO#: length 3
  BOTTOM w0.203: U36.17 23.95,18.9 23.94,18.91 v1(23.94,18.93) 23.86,19.01 R821.2
25810_DBG#: length 3
  BOTTOM w0.102: R829.2 21.93,17.9 22.22,18.2 v1(22.9,18.2)
  BOTTOM w0.203: R829.2 22.16,17.48 22.57,17.48 23.2,16.86 U36.16
25810_FAULT#: length 2
  BOTTOM w0.203: U36.1 26.2,16.86 v1(26.94,17.59) 27.54,17.59 R826.2
25810_LD_DET#: length 3.4
  BOTTOM w0.203: U36.20 25.45,18.08 25.87,18.5 v1(26,18.5) 26.1,18.5 26.5,18.91 27.02,18.91 27.52,19.41 R815.2
25810_POL#: length 8.9
  TOP w0.102: v2(20.74,19.65) 21.25,19.65 21.98,18.91 24.7,18.91 v1(24.95,19.16)
  BOTTOM w0.102: R808.2 24.99,19.95 R809.2 25.16,19.37 v1(24.95,19.16) 24.45,18.66 U36.18 ; R813.1 20.59,19.8 v2(20.74,19.65)
25810_REF: length 1.6
  BOTTOM w0.102: R839.1 23.28,12.74 23.95,13.41 U36.10
25810_REF_RTN: length 2.3
  BOTTOM w0.102: R839.2 23.37,11.9 23.79,12.32 23.79,12.61 24.45,13.27 U36.9
25810_UFP#: length 79.3
  TOP w0.102: R499.1 13.41,2.77 v1(13.65,2.53)
  TOP w0.254: Q22.2 21.22,14.03 20.89,13.7 20.89,12.79 v1(20.69,12.58) ; v1(7.05,23.1) 7.75,22.4 7.75,21.78 8.72,20.81 11.06,20.81 12.2,19.67 16.7,19.67 17.73,20.7 18.59,20.7 20.71,18.58 23.46,18.58 23.89,18.15 24.62,18.15 v1(24.95,18.47) ; v1(12.89,4.05) 13.02,4.05 13.41,3.66 R499.1
  IN1 w0.254: v1(20.69,12.58) 20.61,12.58 20.51,12.48 17.31,12.48 16.93,12.1 15.81,12.1 15.25,11.54 12.41,11.54 12.13,11.26 12.13,10.27 12.79,9.61 12.79,4.15 v1(12.89,4.05)
  IN2 w0.254: v1(7.05,23.1) 7.55,23.1 11.11,19.54 16.19,19.54 17.33,18.4 17.33,11.97 16.8,11.44 16.8,9.77 17.05,9.51 17.05,7.99 16.09,7.02 11.9,7.02 10.91,6.03 10.91,4.71 11.57,4.05 v1(12.89,4.05)
  BOTTOM w0.203: U36.19 v1(24.95,18.47) 25.25,18.47 26.19,19.41 R814.2
  BOTTOM w0.254: Q42.3 7.17,23.23 v1(7.05,23.1)
+1.03_GFX: length 37.4
  TOP w0.305: C48.1 109.79,108.83 v2(109.54,109.08) ; v2(112.14,110.72) 112.06,110.72 111.53,110.19 C38.1
  IN1 w1.016: 71.44,117.97 72.2,118.73 80.07,118.73 81.8,120.47 84.66,120.47 86.85,118.27 86.85,117.74 87.41,117.18 89.3,117.18 91.48,119.37 91.98,119.37 95.18,122.57 95.18,124.19
  BOTTOM w0.305: v2(109.54,109.08) 111.24,109.08 U22.AA22 ; v2(112.96,111.62) 113.33,111.25 U22.AC24 ; U22.AB23 v2(112.14,110.72) ; U22.AE26 114.93,112.85 v2(115.34,113.26) 115.73,112.87 U22.AE27 ; U22.AD25 v2(114.54,112.44)
  vias: v1(71.8,105.32) v1(72.43,105.32) v1(72.45,103.21) v1(118.38,123.07) v1(118.4,119.88) v1(118.4,119.25) v1(118.53,122.21)
+601_VCC:
  vias: v1(204.07,18.45) v1(207.33,11.8) v1(207.5,12.51) v1(214.31,17.64) v1(214.69,17.11)
+AZA_VDD: length 21
  TOP w0.203: v1(210.42,27.19) 210.75,27.52 v1(210.98,27.52) 210.88,27.62 R364.2
  IN1 w0.508: v1(207.4,35.67) 207.38,35.67 206.49,34.78 206.49,33.54 207.2,32.83 207.2,31.86 208.6,30.47 209.84,30.47 210.22,30.08 210.22,28 210.42,27.8 v1(210.42,27.19)
  BOTTOM w0.203: U30.36 206.86,36.09 207,36.23 207.2,36.23 207.36,36.4 ; U30.1 207.81,29.52 208.62,28.71 208.62,28.3 C656.1
  BOTTOM w0.381: 207.36,36.4 207.62,36.65 C624.1 208.09,36.36 v1(207.4,35.67)
  BOTTOM w0.508: 210.4,26.55 210.02,26.55 209.59,26.99 209.59,27.11 209.13,27.57 C656.1
+FB_PLLAVDD: length 79
  TOP w0.254: C139.2 106.94,97.22 v2(107.31,97.59) ; v1(90.33,103.97) 90.1,103.75 v1(90.1,103.36)
  TOP w0.305: v2(112.11,98.37) 112.02,98.28 C136.2
  TOP w0.381: C95.2 110.42,102.72 v2(110.42,103.24)
  TOP w0.508: v1(90.1,103.36) 90.1,102.21 L3.2 90.24,101.95 L4.2 C114.1
  IN1 w0.508: v1(90.1,103.36) 89.24,103.36 88.83,103.77 88.83,108.06 89.34,108.57 89.34,108.93 90.82,110.41 90.82,115.36 93.36,117.89 v1(93.36,118.48)
  IN2 w0.508: v1(93.36,118.48) 94.88,120 98.03,120 98.41,119.62 103.36,119.62 107.86,124.12 112.18,124.12 113.65,122.64 113.65,116.98 110.68,114.01 110.27,114.01 108.9,112.64 108.9,108.44 108.95,108.39 108.95,107.76 110.17,106.54 110.17,103.49 v2(110.42,103.24) 109.56,102.37 109.56,98.77
  BOTTOM w0.305: U22.H22 111.71,98.77 v2(112.11,98.37) ; v2(110.42,103.24) 110.55,103.36 111.22,103.36 111.58,103.73 U22.P22
  BOTTOM w0.381: v2(107.31,97.59) 107.26,97.54 107.23,97.54 106.76,97.07 U22.F16
+G_SEN_PW: length 42
  TOP w0.203: 65.19,11.8 65.47,12.08 R483.1 ; U16.1 61.91,15.48 60.49,16.91 C447.1 59.88,16.42 60.01,16.29 ; R468.1 69.58,14.97 69.71,15.1 69.71,17.28 v1(69.78,17.36)
  TOP w0.254: C436.1 60.77,18.79 60.77,18.53 61.79,17.5 U16.14 ; U16.8 68.35,17.5 68.74,17.89 69.53,17.89 69.78,17.64 v1(69.78,17.36)
  TOP w0.508: C436.1 59.89,19.67 R431.2 58.87,18.14 v1(58.99,18.02) 58.99,17.59 59.19,17.39 59.19,16.62 59.52,16.29 60.01,16.29 62.01,14.29 62.01,12.31 v1(62.27,12.05) 62.52,11.8 65.19,11.8
  IN3 w0.254: v1(58.99,18.02) 58.99,17.94 59.43,17.51 60.5,17.51 61.1,18.1 69.3,18.1 69.78,17.61 v1(69.78,17.36)
+SMDDR_VREF_DIMM: length 13.4
  TOP w0.203: v1(54.93,75.22) 54.93,74.91 C208.1 v1(56.48,74.63) 58.06,74.63 C209.1
  TOP w0.508: R159.2 60.72,74.88 R149.2 59.97,75.36 59.28,74.67 R158.1 C209.1
  BOTTOM w0.254: JDIM1.164 56.98,72.2
  BOTTOM w0.508: v1(54.93,75.22) 54.93,74.76 55.81,73.87 55.81,72.53 56.14,72.2 56.98,72.2
+SMDDR_VREF_DQ1_M1: length 109.9
  TOP w0.356: 37.83,79.28 37.83,78.86 37.75,78.78 37.75,78.01 U4.M1 ; U2.M1 38.5,92.06 40.57,92.06 ; 37.47,46.44 U8.M1 ; U6.M1 37.47,59.59
  TOP w0.508: 28.41,61.45 28.41,54.49 28.31,54.39 v1(28.31,53.55) 28.31,47.23 28.75,46.79 32.49,46.79 32.83,47.13 35.15,47.13 35.88,47.87 C318.2 C319.1 36.88,47.37 37.47,46.78 37.47,46.44 ; 28.41,61.45 28.87,61.91 31.61,61.91 32.95,60.57 36.16,60.57 36.52,60.93 C258.2 C259.2 37.52,59.63 37.47,59.59 ; 28.41,61.45 28.41,63 28.33,63.08 28.33,72.58 29.2,73.44 29.2,76.95 29.3,77.05 29.3,78.75 29.75,79.21 v1(29.81,79.21) 29.96,79.36 31.3,79.36 31.53,79.59 32.83,79.59 33.62,80.38 37.4,80.38 38.04,81.02 C189.2 C190.2 39.04,80.5 37.83,79.28 ; v1(43.98,93.97) 43.98,93.05 43.75,92.82 42.1,92.82 41.34,92.06 40.57,92.06
  IN1 w0.508: v1(43.98,93.97) 32.36,93.97 29.81,91.41 v1(29.81,79.21)
+TYPEC_VBUS: length 1.5
  TOP w0.508: C426.2 9.6,19.69 v2(9.28,19.37) ; C462.2 10.22,14.39 v1(10.35,14.51)
  vias: v1(12.76,11.01) v1(12.86,10.37) v1(13.14,12.81) v1(13.24,14.18) v1(13.22,13.54) v1(13.88,14.18) v1(13.85,13.54) v1(14.51,14.18) v1(14.49,13.54) v1(14.59,16.09)
+TYPEC_VBUS_C:
  vias: v1(17.33,17) v1(17.87,18.06) v1(18.19,17.5) v1(18.51,18.06) v1(18.83,17.5) v1(19.14,18.06) v1(19.46,17.5) v1(20.25,17.13)
+USBPWR0: length 0.8
  TOP w0.203: v1(19.62,54.72) 19.38,54.49 U5.2
  vias: v1(18.1,51.68) v1(18.1,50.91) v1(18.6,52.06) v1(18.6,51.29) v1(19.16,51.7) v1(20.2,51.17)
+USBPWR1: length 8
  TOP w0.203: U11.2 20.25,33.78 v1(20.36,33.9)
  IN3 w0.508: v1(20.36,33.9) 20.36,34.43 18.73,36.05 18.73,39.1 v1(17.71,40.12)
  vias: v1(15.3,47.08) v1(15.3,46.44) v1(15.71,47.59) v1(16.7,47.1)
+VGPU_CORE: length 70.1
  TOP w0.356: v2(107.5,100.06) 107.77,100.32 C108.2 ; C107.2 105.21,100.32 v2(105.34,100.19) ; v2(103.55,100.2) 103.96,100.6 C109.2
  TOP w0.381: v2(101.23,100.23) 101.28,100.18 C110.2 ; v2(70.93,108.76) 70.93,108.54 70.61,108.22 PR28.1
  IN3 w0.381: v4(83.55,112.76) 83.3,112.51 72.99,112.51 72.04,111.56 72.04,110.57 70.93,109.46 v2(70.93,108.76)
  BOTTOM w0.254: U22.M16 106.89,101.73 106.59,101.43 v2(106.59,101.35) ; v2(101.51,108.06) 101.18,107.73 U22.V10 ; U22.T16 107.03,105.65 106.65,105.27 v2(106.36,105.27) 106.36,105.06 U22.R15 106.03,104.73 105.78,104.48 v2(105.78,104.25) 105.55,104.25 105.03,103.73 U22.P14 104.58,103.28 v2(104.58,103.23) 104.53,103.23 104.03,102.73 U22.N13 103.85,102.73 v2(103.47,102.35) 103.03,101.91 U22.M12 102.95,101.73 102.47,101.26 v2(102.47,101.21) 102.42,101.21 102.03,100.81 U22.L11 101.77,100.73 101.31,100.27 101.29,100.27 101.25,100.23 v2(101.23,100.23)
  BOTTOM w0.305: U22.K16 107.17,99.73 v2(107.5,100.06) 107.5,100.2 U22.L17 v2(108.64,101.34) U22.M18 ; U22.K14 105.03,99.87 v2(105.34,100.19) 105.89,100.73 U22.L15 106.59,101.29 v2(106.59,101.35) ; U22.U17 108.03,106.46 v2(107.55,105.98) ; v2(108.37,108.16) 108.62,108.16 109.03,107.76 U22.V18 ; U22.P10 101.03,104.03 v2(101.23,104.23) 101.73,104.73 U22.R11 102.03,104.83 v2(102.43,105.23) 102.53,105.23 U22.T12 103.14,105.73 103.44,106.03 v2(103.44,106.28) 103.69,106.29 104.03,106.62 U22.U13 v2(104.53,107.23) U22.V14 105.03,107.74 v2(104.58,108.19) ; U22.V12 v2(102.53,107.23) U22.U11 101.76,106.73 v2(101.3,106.26) 101.3,106 U22.T10 100.11,105.73 v2(100.04,105.8) ; v2(108.39,99.3) 108.82,99.73 U22.K18 ; U22.P18 108.82,103.53 v2(108.82,103.24) 108.54,103.24 U22.N17 108.03,102.62 107.66,102.25 v2(107.61,102.25) 107.09,101.73 U22.M16 ; U22.K12 103.06,99.73 103.53,100.2 v2(103.55,100.2) 103.55,100.23 104.03,100.7 U22.L13 104.59,101.29 v2(104.59,101.43) 104.89,101.73 U22.M14 105.52,102.22 v2(105.78,102.22) 105.78,102.48 U22.N15 106.49,103.19 v2(106.49,103.24) 106.54,103.24 107.03,103.73 U22.P16 107.36,104.06 v2(107.56,104.06) 107.56,104.26 U22.R17 108.27,104.97 108.27,104.97 108.52,105.23 v2(108.82,105.23) 108.82,105.53 U22.T18 ; v2(107.12,108.44) 107.03,108.35 U22.V16 v2(106.6,107.3) U22.U15 105.78,106.48 v2(105.78,106.23) 105.27,105.73 U22.T14 104.63,105.33 v2(104.63,105.13) 104.43,105.13 U22.R13 103.49,104.19 v2(103.49,104.18) 103.48,104.18 U22.P12 103.03,103.73 102.53,103.23 v2(102.48,103.23) 102.48,103.18 102.03,102.73 U22.N11 101.74,102.73 v2(101.26,102.25) 101.03,102.02 U22.M10
  BOTTOM w0.356: U22.K10 101.03,100.02 v2(101.23,100.23)
  vias: v1(86.55,118.58) v1(100.04,105.09) v1(105.22,119.37) v1(105.22,118.73) v1(105.22,118.1) v1(105.5,116.06) v1(105.5,115.3) v1(106.26,116.06) v1(106.26,115.3) v1(106.89,116.06) v1(106.89,115.3) v1(107.53,116.06) v1(107.53,115.3) v1(108.29,116.06) v1(108.27,115.35) v1(108.93,116.06) v1(108.9,115.35) v1(111.11,122.8) v1(111.11,122.03) v1(111.75,122.8) v1(111.75,122.03) v1(114.69,119.7) v4(81.34,117.84) v4(81.47,117.08) v4(81.59,115.68) v4(82.13,118.3) v4(82.08,117.56) v4(82.26,119.09) v4(82.35,115.64) v4(82.79,117.16) v4(82.92,119.48) v4(82.89,118.68) v4(82.92,117.89) v4(83.12,115.68) v4(83.25,114.92) v4(83.53,117.18) v4(83.53,114.24) v4(83.55,113.5) v4(83.65,117.92) v4(83.88,115.68) v4(84.01,114.92) v4(84.26,117.18) v4(84.26,114.21) v4(84.29,113.47) v4(84.29,112.74) v4(84.29,112) v4(84.39,117.92) v4(84.64,115.68) v4(84.77,114.92) v4(85,117.18) v4(85,114.21) v4(85.02,113.47) v4(85.02,112.74) v4(85.02,112) v4(85.13,117.92) v4(85.23,111.24) v4(85.41,115.68) v4(85.53,114.92) v4(85.74,114.21) v4(85.76,117.18) v4(85.76,113.47) v4(85.76,112.74) v4(85.76,112) v4(85.91,117.92) v4(85.96,111.26) v4(86.04,110.48) v4(86.17,115.68) v4(86.56,119.9) v4(86.8,110.93) v4(86.8,110.2) v4(86.93,116.17) v4(86.93,115.4) v4(87.54,110.2) v4(87.56,110.93) v4(87.67,116.17) v4(87.67,115.4) v4(88.33,110.93) v4(88.33,110.2) v4(88.4,116.17) v4(88.4,115.4) v4(88.83,114.59) v4(88.83,113.8) v4(88.83,113.04) v4(88.83,112.28) v4(88.83,111.52) v4(89.2,110.86) v4(89.59,114.57) v4(89.59,113.78) v4(89.59,113.02) v4(89.59,112.25) v4(89.59,111.49)
+VNN_EXT: length 1.8
  TOP w0.254: R255.1 81.72,42.87 v2(81.58,42.72)
  BOTTOM w0.33: v2(81.58,42.72) 81.58,42.7 81.9,42.37 U24.CY34
+VREF06_RT3612: length 20.5
  TOP w0.203: PR57.1 144.3,52.57 144.08,52.79 143.17,52.79 142.3,53.66 PU4.12
  TOP w0.457: v1(145.22,53.17) 145.2,53.17 144.97,52.95 144.97,52.7 PR57.1
  IN3 w0.457: v1(145.22,53.17) 144.49,52.44 140.9,52.44 139.07,50.6 v1(139.07,50.14)
  BOTTOM w0.178: PR199.1 138.71,50.5 v1(139.07,50.14) 139.07,50.14 139.56,49.65 PR201.1 PR208.1
  BOTTOM w0.203: PR178.1 143.55,56.11 v1(145.22,54.44) v1(145.22,53.17)
  BOTTOM w0.457: PR190.1 143.73,52.41 144.68,52.41 PR57.1 145.22,52.95 v1(145.22,53.17)
AC_PRESENT_EC: length 173.8
  TOP w0.102: U13.84 197.8,23.38 197.67,23.51 197.42,23.51 v2(196.96,23.96) ; v1(62.67,24.29) 62.98,24.6 62.98,24.67 63.84,25.54 63.84,27.66 64.83,28.65 64.83,28.87 65.1,29.13 65.1,29.97 66.05,30.92 R330.2 66.13,30.97 66.13,31.25 66.29,31.41 66.29,31.81 66.13,31.97 R317.2 66.13,32.37 67.56,33.8 68.04,33.8 70.5,36.26 70.5,38.14 71.97,39.61 72.2,39.61 v2(72.32,39.74)
  IN2 w0.089: v1(62.67,24.29) 62.02,24.29 61.72,23.99 61.72,23.2 62.43,22.49 62.98,22.49 63.89,21.58 65.92,21.58 66.2,21.86 66.74,21.86 67.24,21.35 67.24,21.17 68.11,20.3 73.7,20.3 74.26,19.73 76.19,19.73 76.99,18.93 79.51,18.93 83.64,23.06 89.25,23.06 91.13,21.18 92.45,21.18 93.3,20.33 96.42,20.33 97.28,21.2 111.73,21.2 112.82,22.29 115.57,22.29 116.15,22.87 118.08,22.87 119.19,23.99 121.38,23.99 121.76,23.61 126.28,23.61 127.53,24.85 134.73,24.85 134.92,25.04 137.34,25.04 137.78,24.6 141.91,24.6 143.59,22.92 155.97,22.92 156.25,23.19 164.62,23.19 165.47,22.34 170.08,22.34 170.45,22.72 175.16,22.72 175.7,22.18 176.62,22.18 176.95,22.52 179.09,22.52 179.33,22.76 182.2,22.76 182.9,22.05 186.44,22.05 186.9,22.51 188.89,22.51 189.1,22.31 190.49,22.31 191.33,23.14 193.1,23.14 194.14,24.18 196.74,24.18 v2(196.96,23.96)
  BOTTOM w0.079: v2(72.32,39.74) 72.96,39.74 73.15,39.93 73.53,39.93 73.72,39.74 75.63,39.74 75.86,39.97 U24.DE46
ACCEL_INT2: length 160.1
  TOP w0.102: D15.1 66.36,21.32 v1(66.58,21.32)
  IN1 w0.089: v2(194.93,21.07) 195.61,21.07 196.28,20.41 196.28,19.16 197.42,18.02 199.86,18.02 v2(200.06,17.82)
  IN2 w0.089: v2(194.93,21.07) 194.44,21.07 193.98,21.53 193.44,21.53 193.05,21.14 191.46,21.14 190.71,21.88 189.31,21.88 188.66,21.23 186.5,21.23 185.87,21.86 182.82,21.86 182.12,22.57 179.41,22.57 179.16,22.33 177.03,22.33 176.7,21.99 175.62,21.99 175.08,22.53 170.53,22.53 170.16,22.15 165.39,22.15 164.59,22.95 156.59,22.95 156.36,22.72 143.88,22.72 143.87,22.73 143.51,22.73 141.83,24.41 137.7,24.41 137.26,24.85 135,24.85 134.81,24.66 127.61,24.66 126.36,23.42 121.68,23.42 121.32,23.79 119.26,23.79 118.14,22.67 116.22,22.67 115.65,22.1 112.9,22.1 111.8,20.99 98.11,20.99 97.17,20.05 93.31,20.05 92.37,20.99 91.05,20.99 89.17,22.87 83.75,22.87 79.54,18.66 75.07,18.66 73.62,20.11 67.8,20.11 v1(66.58,21.32)
  BOTTOM w0.102: R835.2 211.34,14.21 210.75,14.79 210.75,15.81 210.35,16.22 209.97,16.22 208.47,17.72 203.64,17.72 203.03,17.11 200.77,17.11 v2(200.06,17.82)
ACCEL_INT2_R: length 4.2
  TOP w0.102: D15.2 63.55,21.7 v1(64.76,20.49) 65.7,19.55 U16.9
ACCEL_INTA: length 55
  TOP w0.102: v2(55.81,24.52) 55.81,23.35 v1(55.85,23.32) 56.96,22.21 58.23,22.21 58.45,21.99 C395.2 D14.1
  IN2 w0.089: v2(55.81,24.52) 55.81,25.79 55.72,25.89 55.72,26.99 56.22,27.49 56.22,28.28 56.04,28.46 56.04,29.3 56.38,29.63 60.38,29.63 61.76,28.26 62.44,28.26 63.32,29.13 64.56,29.13 64.75,29.32 65.72,29.32 66.76,30.36 67.76,30.36 68.81,31.4 68.81,31.99 69.4,32.59 69.4,33.39 69.85,33.83 69.98,33.83 71.89,31.91 73.42,31.91 74.33,31 78.67,31 78.98,31.3 83.04,31.3 84.75,29.6 87.11,29.6 v2(87.59,30.09)
  BOTTOM w0.079: U24.DP21 88.12,34.83 87.95,34.66 87.95,34.28 88.08,34.15 88.08,33.81 88.03,33.7 88.03,33.52 88.08,33.41 88.08,33.18 88.05,33.11 88.05,32.86 88.2,32.48 88.2,32.24
  BOTTOM w0.102: R733.1 87.31,29.81 v2(87.59,30.09) 87.59,30.49 88.2,31.1 88.2,32.24
ACCEL_INTA_R: length 4.7
  TOP w0.102: D14.2 62.05,21.3 v1(62.98,20.36) 63.52,20.36 64.7,19.17 U16.11
ACIN: length 79.9
  TOP w0.102: v2(190.43,25.34) 190.43,24.7 190.87,24.27 193.05,24.27 195.69,21.63 195.69,19.77 196.63,18.83 196.96,18.83 197.32,18.47 198.06,18.47 198.18,18.58 U13.72 ; v2(133.01,33.46) 133.06,33.51 133.41,33.51 133.45,33.48 PR74.1
  TOP w0.178: v1(135.55,33.84) 135.44,33.74 135.27,33.74 135,33.48 PR75.2
  TOP w0.203: PR80.1 134.55,32.24 134.15,32.65 134.15,33.07 PR74.1 PR75.2
  IN2 w0.089: v2(133.01,33.46) 133.08,33.46 133.69,34.07 135.49,34.07 135.8,33.77 140.73,33.77 141.16,34.2 143.06,34.2 144.87,32.39 151.94,32.39 152.36,31.96 155.97,31.96 156.3,31.63 159.29,31.63 159.59,31.33 161.24,31.33 161.7,30.87 162.74,30.87 163.3,30.31 164.1,30.31 164.32,30.09 174.78,30.09 175.47,29.4 175.47,28.35 175.69,28.13 177.32,28.13 177.51,27.94 178.67,27.94 179.82,26.8 182.47,26.8 183.6,25.66 185.2,25.66 185.67,26.14 189.79,26.14 190.43,25.49 v2(190.43,25.34)
ACZ_BCLK: length 12.6
  BOTTOM w0.079: 72.48,40.98 73.09,41.6 75.29,41.6 75.36,41.53 75.77,41.53 75.95,41.71 U24.CY46
  BOTTOM w0.102: R687.2 66.89,38.11 67.22,38.44 68.49,38.44 69.65,39.61 71.1,39.61 72.48,40.98
ACZ_RST#: length 10.8
  BOTTOM w0.079: U24.DA47 75.43,41.84 75.2,42.07 74.15,42.07 73.85,41.77 72.99,41.77 72.56,41.33
  BOTTOM w0.102: R684.2 R685.2 66.89,39 67.12,39.23 68.01,39.23 68.77,39.99 71.21,39.99 72.56,41.33
ACZ_SDOUT: length 12.8
  BOTTOM w0.079: U24.CY47 74.9,42.87 74.78,42.87 74.61,43.04 74.61,43.21 74.48,43.34 74.15,43.34 73.68,42.87 73.17,42.87 72.45,42.15
  BOTTOM w0.102: R683.2 R679.2 65.69,40.25 R677.2 66.07,40.27 66.13,40.22 68.03,40.22 68.58,40.77 71.08,40.77 72.45,42.15
ACZ_SPKR: length 192.3
  TOP w0.102: v1(61.35,43.32) 60.92,43.32 60.77,43.17 60.77,29.16 61.78,28.14 v1(61.78,26.39) 61.78,25.13 61.66,25.01 v1(61.58,25.01)
  IN2 w0.089: v1(61.58,25.01) 61.53,24.95 61.53,23.13 62.36,22.3 62.7,22.3 65.08,19.92 73.54,19.92 74.99,18.46 79.62,18.46 83.83,22.68 89.09,22.68 90.97,20.8 92.29,20.8 93.23,19.86 97.52,19.86 98.42,20.76 111.84,20.76 112.98,21.91 115.72,21.91 116.26,22.44 118.58,22.44 119.61,23.47 121.36,23.47 121.64,23.19 126.4,23.19 127.69,24.47 135.39,24.47 135.52,24.6 137.24,24.6 137.75,24.09 141.76,24.09 143.32,22.53 156.44,22.53 156.66,22.74 164.53,22.74 165.31,21.96 170.24,21.96 170.61,22.34 173.54,22.34 174.12,21.76 176.74,21.76 177.11,22.13 179.24,22.13 179.48,22.38 182.04,22.38 182.74,21.67 185.79,21.67 186.42,21.04 189.11,21.04 v2(189.5,21.42)
  BOTTOM w0.079: U24.CH47 75.39,47.87 74.5,47.87 74.26,47.75 73.92,47.75 73.63,47.46 73.06,47.46 72.81,47.2 72.5,47.2 71.44,46.14 70.9,46.14
  BOTTOM w0.102: D34.2 192.47,32.26 192.19,32.55 191.4,32.55 191.22,32.37 190.07,32.37 189.52,31.83 189.52,28.38 188.97,27.83 188.97,26.15 189.44,25.68 189.44,24.88 189.95,24.37 189.95,23.84 189.5,23.38 v2(189.5,21.42) ; R664.2 61.35,43.27 61.38,43.29 61.38,43.3 v1(61.35,43.32) 61.4,43.32 61.45,43.27 R665.1 61.94,42.88 62.22,42.61 62.83,42.61 63.31,43.08 63.31,43.93 63.52,44.14 68.9,44.14 70.9,46.14
ACZ_SYNC: length 9.4
  BOTTOM w0.079: U24.CV49 73.92,42.7 73.39,42.7 72.04,41.35
  BOTTOM w0.102: 72.04,41.35 71.23,40.55 68.68,40.55 68.12,39.99 66.71,39.99 66.33,39.61 R682.2
ADOGND: length 37.7
  TOP w0.254: v1(209.54,37.32) 209.54,36.63 R289.1
  TOP w0.381: R345.1 201.57,29.93 v2(201.1,29.93) ; C323.1 215.99,47.53 v2(216.44,47.08) ; C332.1 216.49,43.44 v1(216.6,43.55) ; v1(216.42,41.9) 216.23,41.71 C340.1 ; R224.2 215.21,49.18 214.77,49.62 v2(214.08,49.62) ; v1(216.42,45.1) 216.29,45.22 R249.2 ; v1(209.54,37.32) 209.99,37.32 210.24,37.57 R281.1 ; R275.1 209.82,38.85 v1(209.41,39.25) ; v1(198.54,31.63) 198.66,31.76 199.27,31.76 199.58,32.07 C366.2 ; C343.1 v1(209.61,39.86) ; v2(216.47,46.19) C327.1
  TOP w0.508: C375.1 198.44,30.87 v1(198.41,30.85)
  BOTTOM w0.203: U30.38 208.3,34.43 208.85,34.98 v2(208.85,34.99) ; v1(201.18,35.83) 201.28,35.73 U30.25 ; v1(198.61,37.1) 198.61,36.76 198.62,36.76 R691.1
  BOTTOM w0.254: v2(216.44,47.08) 216.06,47.46 215.23,47.46 214.67,46.9 CN6.3 ; CN6.1 214.24,47.9 v2(214.59,48.25) ; CN6.12 214.24,42.4 214.74,41.9 v1(216.42,41.9)
  BOTTOM w0.305: CN6.5 212.34,45.9 211.77,46.47 v1(211.77,46.62) 211.77,47.33 v1(212.13,47.69)
  BOTTOM w0.381: C643.1 198.19,31.63 v1(198.54,31.63) ; v1(209.54,37.32) 209.51,37.3 C629.1 ; R720.1 198.17,29.96 v1(198.69,29.96) ; C616.1 203.19,40.15 v1(202.48,39.44) R686.1 ; v1(201.23,38.81) 202.02,38.81 C620.2 ; C623.2 200.1,38.09 v1(199.96,37.96) 199.68,37.96 199.24,37.52 C627.2 ; v1(198.08,33.39) 198.11,33.41 C635.2
  BOTTOM w0.508: v1(209.41,39.25) 209.61,39.05 209.71,39.05 209.93,38.83 C619.2
