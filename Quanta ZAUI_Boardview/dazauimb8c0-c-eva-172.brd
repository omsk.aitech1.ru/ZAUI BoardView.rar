# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Nets (continued)
PEDET: CN18.69 Q27.2 R491.2 R492.2
PEG_RXN5: C40.1 U24.DA6
PEG_RXN5_C: C40.2 U22.AB9
PEG_RXN6: C9.1 U24.CY7
PEG_RXN6_C: C9.2 U22.AC10
PEG_RXN7: C4.1 U24.CV7
PEG_RXN7_C: C4.2 U22.AC11
PEG_RXN8: C12.1 U24.CT6
PEG_RXN8_C: C12.2 U22.AB12
PEG_RXP5: C36.1 U24.DA7
PEG_RXP5_C: C36.2 U22.AC9
PEG_RXP6: C10.1 U24.CY6
PEG_RXP6_C: C10.2 U22.AB10
PEG_RXP7: C3.1 U24.CV6
PEG_RXP7_C: C3.2 U22.AD11
PEG_RXP8: C11.1 U24.CT7
PEG_RXP8_C: C11.2 U22.AC12
PEG_TXN5: C630.1 U22.AG7
PEG_TXN5_C: C630.2 U24.DE4
PEG_TXN6: C625.1 U22.AE7
PEG_TXN6_C: C625.2 U24.DD1
PEG_TXN7: C621.2 U22.AF9
PEG_TXN7_C: C621.1 U24.DD3
PEG_TXN8: C614.2 U22.AG10
PEG_TXN8_C: C614.1 U24.DA3
PEG_TXP5: C631.1 U22.AG6
PEG_TXP5_C: C631.2 U24.DE3
PEG_TXP6: C628.1 U22.AF7
PEG_TXP6_C: C628.2 U24.DD2
PEG_TXP7: C618.2 U22.AE9
PEG_TXP7_C: C618.1 U24.DD5
PEG_TXP8: C617.2 U22.AG9
PEG_TXP8_C: C617.1 U24.DA5
PEGX_RST#: R1.2 R502.1 R503.2 R506.1
PEGX_RST#_C: R506.2 U19.4
PEX_CLKREQ#: Q31.1(S) R537.1 R542.2 U22.AC6
PEX_TERMP: R511.2 U22.AF25
PEX_TSTCLK: R512.2 U22.AF22
PEX_TSTCLK#: R512.1 U22.AE22
PINSET_TSEN: PR47.1 PR177.1 PR181.2
PIRQA#: R400.1 R671.2 U24.CT49
PLTRST#: CN17.2 R398.1 R497.2 R662.1 R819.2 R832.1 U1.19 U19.2 U24.CM49
PLTRST#_EC: C437.1 R441.2 U13.22
PM_EXTTS#0: JDIM1.134 R615.2
PM_THRMTRIP#: Q11.1(EMITTER) R196.1 R584.1 U24.E3
PMON: PC77.2 PR76.1 PR195.1 PR251.1
PP: R423.2 U15.4
PROCHOT#_CPU: R583.2 U24.C3
PROCHOT_EC: C440.2 Q20.2 R440.2 U13.17
PROCPWRGD: C726.2 R643.2 U24.CF1
PS_FB_CLAMP: R528.1 U22.F3
PTP_PWR_EN#: TP35.1 U13.125
PULSAR_38P4M_REFCLK: CN9.64 TP99.1
PWM-VID: PR22.1 R551.1
PWR_GATE#: R473.1 R776.2
PWRLED#: CN6.22 U13.24
R_SPK+: R445.1 U30.45
R_SPK+_1: C399.1 CN11.1 R445.2
R_SPK-: R444.1 U30.44
R_SPK-_1: C398.1 CN11.2 R444.2
RAM_ID0: R730.2 R763.1 U24.DK34
RAM_ID1: R385.2 R392.1 U24.DL34
RAM_ID2: R731.1 R732.2 U24.DN33
RAM_ID3: R376.2 R389.1 U24.DL33
REGN6V: PC80.1 PR75.1 PU12.24
REQ_WLAN#: CN9.53 Q18.1(S) R816.2
RF_EN: CN9.56 R487.2 R828.1
RING2: C332.2 CN6.6 CN6.7 CN6.8 R257.2 U30.17
ROM_CS: TP6.1 U22.D12
ROM_SCLK: R552.2 R565.1 U22.C12
ROM_SI: R553.2 R566.1 U22.B12
ROM_SO: R554.2 R567.1 U22.A12
RSET: R6.2 U1.31
RSMRST#: Q32.3 R573.1 R704.2 R709.2 R711.2 U13.112 U24.DG49
RT3612_ALERT#: PR61.2 PU4.3
RT3612_BOOT1: PC55.2 PU4.25
RT3612_BOOT2: PC59.2 PU4.1
RT3612_COMP: PC56.2 PR56.1 PU4.15
RT3612_FB: PC53.2 PC56.1 PR54.1 PR56.2 PU4.16
RT3612_IMON: PR58.2 PU4.11
RT3612_ISEN1N: PR49.2 PU4.19
RT3612_ISEN1P: PC51.2 PR48.1 PR174.1 PU4.20
RT3612_ISEN2N: PR50.2 PU4.18
RT3612_ISEN2P: PC49.2 PR51.1 PR176.1 PU4.17
RT3612_LG1: PQ20.8 PU4.28
RT3612_LG2: PQ21.8 PU4.30
RT3612_PHASE1: PC55.1 PL7.1 PQ20.5 PQ20.6 PQ20.7 PR165.1 PR173.2 PU4.27
RT3612_PHASE2: PC59.1 PL8.1 PQ21.5 PQ21.6 PQ21.7 PR179.2 PR183.1 PU4.31
RT3612_PSYS: PC199.2 PR188.1 PR195.2 PU4.9
RT3612_PVCC: PC58.1 PR186.1 PU4.29
RT3612_RGND: PC57.2 PC198.1 PR185.1 PU4.13
RT3612_SET1: PR196.2 PR209.2 PU4.8
RT3612_SET2: PR198.2 PR202.2 PU4.7
RT3612_SET3: PR194.2 PR197.1 PU4.6
RT3612_TSEN: PR52.1 PR160.1 PU4.21
RT3612_UG1: PR170.1 PU4.26
RT3612_UG1_R: PQ20.1 PR170.2
RT3612_UG2: PR187.1 PU4.32
RT3612_UG2_R: PQ21.1 PR187.2
RT3612_VCC: PC61.1 PR207.1 PU4.10
RT3612_VCLK: PR63.2 PU4.5
RT3612_VDIO: PR62.2 PU4.4
RT3612_VIN: PC191.2 PR172.2 PU4.22
RT3612_VR_READY: PR53.2 PU4.24
RT3612_VRHOT: PR60.2 PU4.2(V\R\H\O\T\)
RT3612_VRON: PC192.2 PR46.2 PU4.23
RT3612_VSEN: PC53.1 PC57.1 PC195.1 PR54.2 PR184.1 PU4.14
RT6543_BOOT: PC214.2 PU10.10
RT6543_COMP: PC213.1 PC217.1 PU10.5
RT6543_CS_DSI: PR224.2 PU10.1
RT6543_EN: PC209.2 PR213.2 PR214.2 PR215.2 PU10.19
RT6543_FB: PC217.2 PC220.1 PR229.2 PR231.1 PU10.6
RT6543_FSWSEL: PR65.2 PR66.2 PU10.9
RT6543_ISN: PR226.2 PU10.3
RT6543_ISP: PR226.1 PU10.2
RT6543_LG: PQ22.4 PU10.13
RT6543_PG: PR225.2 PR227.2 PU10.4
RT6543_PH: PC214.1 PL9.1 PQ22.5 PQ24.1 PQ24.2 PQ24.3(S3) PR210.2 PU10.12
RT6543_RGND: PR240.1 PR242.1 PU10.7
RT6543_UG: PR228.1 PU10.11
RT6543_VCC: PC210.1 PR216.1 PU10.15 PU10.16
RT6543_VID0: PR222.2 PU10.18
RT6543_VID1: PR221.2 PU10.17
RT6543_VOUT: PR233.2 PU10.8
RT6543_VSYS: PC211.2 PR220.1 PR223.1 PU10.20(VSYS)
RTC_RST#: C721.1 J1.1 Q28.3 R854.2 U24.DT47
RTC_X1: R689.1 U24.DL48
RTC_X1_R: C626.2 R689.2 R693.1 Y3.1
RTC_X2: R692.1 U24.DL49
RTC_X2_R: C632.2 R692.2 R693.2 R696.1
S5_ON: PR94.2 PR100.1 PR257.2 R333.1 U13.100
SATA_LED#: TP91.1 U24.DU16
SATA_RXN0_C: C473.2 R426.2
SATA_RXN0_CN: C469.1 C473.1 HD1.8
SATA_RXN0_HDD: C429.2 R426.1 U24.CK7
SATA_RXN0_IN: C429.1 U17.4
SATA_RXN1A_C: C697.1 CN15.5
SATA_RXN1A_ODD: C697.2 U24.CJ6
SATA_RXN_OUT: C469.2 U17.12
SATA_RXP0_C: C472.2 R425.2
SATA_RXP0_CN: C468.1 C472.1 HD1.7
SATA_RXP0_HDD: C428.2 R425.1 U24.CK6
SATA_RXP0_IN: C428.1 U17.5
SATA_RXP1A_C: C696.1 CN15.6
SATA_RXP1A_ODD: C696.2 U24.CJ7
SATA_RXP_OUT: C468.2 U17.11
SATA_TXN0_C: C474.2 R427.2
SATA_TXN0_CN: C470.1 C474.1 HD1.10
SATA_TXN0_HDD: C430.2 R427.1 U24.CW2
SATA_TXN0_IN: C430.1 U17.2
SATA_TXN1A_C: C694.1 CN15.2
SATA_TXN1A_ODD: C694.2 U24.CW5
SATA_TXN_OUT: C470.2 U17.14
SATA_TXP0_C: C475.2 R428.2
SATA_TXP0_CN: C471.1 C475.1 HD1.11
SATA_TXP0_HDD: C431.2 R428.1 U24.CW1
SATA_TXP0_IN: C431.1 U17.1
SATA_TXP1A_C: C693.1 CN15.3
SATA_TXP1A_ODD: C693.2 U24.CW3
SATA_TXP_OUT: C471.2 U17.15
SATAGP0: R741.1 U24.DW12
SATAGP1: R250.1 U24.CR42
SD3_RCOMP: R226.1 U24.CJ43
SDVO_CLK: R106.2 R195.1 U3.7 U24.DL40
SDVO_DATA: R107.2 R194.1 U3.6 U24.DP42
SEL: R813.2 R822.1 R823.2 U34.6
SENSEA: R360.1 R715.1 R734.1 U30.13
SERIRQ: TP42.1 U13.5
SET1_1: PR208.2 PR209.1
SET1_2: PR189.2 PR196.1
SET2_1: PR201.2 PR202.1
SET2_2: PR193.1 PR198.1
SET3_1: PR194.1 PR199.2
SET3_2: PR192.1 PR197.2
SIO_EXT_SCI#: R764.2 R765.1 U13.23
SKTOCC#: R578.1 U24.C5
SLEEVE: C340.2 CN6.9 CN6.10 CN6.11 R260.2 U30.18
SLP_S5#: TP31.1 U24.DF45
SM_VREF: C211.1 R159.1 U24.C44
SMB_ML0_CLK: R361.1 U24.DK24
SMB_ML0_DAT: R367.1 U24.DJ24
SMB_ML1_CLK: R356.1 R379.2 R380.2 U24.DN22
SMB_ML1_DAT: R357.1 R381.2 U24.DL22
SMB_PCH_CLK: Q41.6 R792.1 R801.1 U24.DK27
SMB_PCH_DAT: Q41.3 R779.1 R790.1 U24.DP24
SMB_RUN_CLK: JDIM1.253 Q41.1(S) R450.2 R484.1 R788.1 R792.2
SMB_RUN_DAT: JDIM1.254 Q41.4 R437.2 R475.1 R790.2 R800.1
SMDDR_VREF_DQ1_M3: C125.1 R51.1 U24.B45
SN_VCORE1: PC188.2 PR173.1
SN_VCORE2: PC194.2 PR179.1
SNDW_RCOMP: R259.1 U24.CV38
SP_PLLVDD: C59.1 C90.2 C96.2 C103.1 L1.2 R42.2 U22.M6
SPI_TPM_CS#: R411.1 R412.1 U24.DB41
SRTC_RST#: C720.1 Q29.3 R853.2 U24.DK46
STRAP0: R533.1 R534.2 U22.D1
STRAP1: R538.1 R539.2 U22.D2
STRAP2: R544.1 R545.2 U22.E4
STRAP3: R529.1 R532.2 U22.E3
STRAP4: R546.1 R547.2 U22.D3
STRAP5: R540.1 R543.2 U22.C1
SUSB#: C724.2 D43.1(CATHODE) R339.2 U13.119 U24.DF47 U27.1
SUSC#: C723.2 D6.2 R291.2 R467.1 U13.18 U24.DC48
SUSCLK_32K: R802.2 U24.DF49
SUSCLK_32KHZ: CN9.50 R802.1
SUSLED#: CN6.21 U13.28
SUSON: C639.2 PR126.1 PR213.1 R265.1 R348.1 R676.2 R714.2 U13.120 U31.3
SYS_HWPG: D9.1(CATHODE) PR237.2 PR273.2 U13.124
SYS_PWROK: R372.2 U24.DP19
SYS_RESET#: R299.2 U24.DK19
SYS_SHDN#: PR70.1 PR77.2 PR269.2 PR276.2 Q11.3 U13.85
TBT_FORCE_PWR: TP25.1 U24.CR39
TBTA_HPD: TP26.1 U24.CV39
TBTB_HPD: TP28.1 U24.CY43
TCRCOMP_DN: R617.2 U24.AY1
TCRCOMP_DP: R617.1 U24.AY2
TEMP_MBAT#: PR88.1 PR90.1 PR113.2 U13.73
TESTMODE: R513.1 U22.AD9
THERM+: TP5.1 U22.F12(THERMDP)
THERM-: TP11.1 U22.E12
TP_A47: TP60.1 U24.A47
TP_AT1: TP73.1 U24.AT1
TP_AT2: TP72.1 U24.AT2
TP_AU1: TP75.1 U24.AU1
TP_AU2: TP74.1 U24.AU2
TP_AV1: TP76.1 U24.AV1
TP_AV2: TP77.1 U24.AV2
TP_B47: TP58.1 U24.B47
TP_BW11: TP19.1 U24.BW11
TP_C1: TP62.1 U24.C1
TP_CA11: TP20.1 U24.CA11
TP_CM33: TP21.1 U24.CM33
TP_CT32: TP23.1 U24.CT32
TP_CV32: TP27.1 U24.CV32
TP_DB10: TP30.1 U24.DB10
TP_DH49: TP79.1 U24.DH49
TP_DL8: TP33.1 U24.DL8
TP_DP1: TP80.1 U24.DP1
TP_DP2: TP81.1 U24.DP2
TP_DV3: TP84.1 U24.DV3
TP_DV4: TP87.1 U24.DV4
TP_DV6: TP93.1 U24.DV6
TP_DV47: TP97.1 U24.DV47
TP_DW3: TP85.1 U24.DW3
TP_DW4: TP88.1 U24.DW4
TP_DW6: TP89.1 U24.DW6
TP_DW47: TP95.1 U24.DW47
TP_E1: TP65.1 U24.E1
TP_F15: TP61.1 U24.F15
TP_G15: TP63.1 U24.G15
TP_I2C_CLK: R434.1 R449.1 U24.DT23
TP_I2C_DATA: R424.1 R433.1 U24.DT24
TP_INTH#_L: CN12.7 Q43.1(S) R797.1 R798.2
TP_L34: TP7.1 U24.L34
TP_M34: TP8.1 U24.M34
TP_PWR_C: C62.2 C67.2 CN2.30 CN2.31 R39.2 R41.2
TP_R1: TP71.1 U24.R1
TP_SMB_CLK: C460.1 CN12.6 Q21.3 R469.1
TP_SMB_DATA: C439.1 CN12.5 Q21.6 R429.1
TPCLK: L16.1 R787.2 U13.89
TPCLK-1: C681.1 CN12.2 L16.2
TPD_EN: R318.2 R795.1 R796.2
TPD_INT#: R378.1 R820.1 U24.DL21
TPD_INT#_EC: R309.1 R310.2 R807.1
TPDAT-1: C680.1 CN12.3 L15.2
TPDATA: L15.1 R784.2 U13.90
TPM_LRESET#: R398.2 U15.17
TRA_V_DAC: C97.1 U21.1 U21.4 U21.7 U21.10
TS_EN: R33.2 R410.1
TS_EN_C: C390.1 R410.2 U13.81
TS_EN_R: CN2.28 R33.1
TSEN_1: PR178.2 PR181.1
TSEN_2: PR177.2 PR180.1
TYPEC_SBU1: CN14.A8 D19.2 TP45.1
TYPEC_SBU2: CN14.B8 D39.2 TP98.1
TYPEC_STRAP: R407.1 R421.2 U13.77
U42_L_U43E_Z: R580.1 R581.2 U24.D4
UART2_RXD: R758.1 TP90.1 U24.DT22
UART2_TXD: R757.1 TP86.1 U24.DW22
UFS_RESET#: TP18.1 U24.CD3
ULT_EDP_HPD: C91.2 R32.1 R327.1 R343.2 U24.DW11
ULT_EDP_HPD_R: CN2.25 R32.2
USB2_COMP: R285.1 U24.DN5
USB3_SS0RX+: C700.1 U34.5
USB3_SS0RX-: C695.1 U34.4
USB3_SS0TX+: C684.1 U34.2
USB3_SS0TX-: C675.1 U34.1
USB30_RX1+: C287.2 R202.2 U24.DJ6
USB30_RX1+_C: CN5.6 R202.1 U5.10
USB30_RX1-: C295.2 R204.2 U24.DJ8
USB30_RX1-_C: CN5.5 R204.1 U5.1
USB30_RX2+: C363.2 R305.2 U24.DG7
USB30_RX2+_C: CN7.6 R305.1 U11.10
USB30_RX2-: C368.2 R316.2 U24.DG9
USB30_RX2-_C: CN7.5 R316.1 U11.1
USB30_RX3+: C700.2 U24.DE9
USB30_RX3-: C695.2 U24.DE7
USB30_RX+_TYPEC1: CN14.B11 RV1.1 RV1.10(NC#4) U34.7
USB30_RX+_TYPEC2: CN14.A11 RV2.1 RV2.10(NC#4) U34.14
USB30_RX-_TYPEC1: CN14.B10 RV1.2 RV1.9 U34.8
USB30_RX-_TYPEC2: CN14.A10 RV2.2 RV2.9 U34.13
USB30_RX_N4: R263.1 U24.DC7
USB30_RX_P4: R263.2 U24.DC9
USB30_TX1+: C272.1 U24.DJ1
USB30_TX1+_C: C272.2 R198.2
USB30_TX1+_C_R: C270.1 CN5.9 R198.1 U5.6
USB30_TX1-: C277.1 U24.DJ2
USB30_TX1-_C: C277.2 R200.2
USB30_TX1-_C_R: C280.1 CN5.8 R200.1 U5.5
USB30_TX2+: C349.1 U24.DJ5
USB30_TX2+_C: C349.2 R280.2
USB30_TX2+_C_R: C345.1 CN7.9 R280.1 U11.6
USB30_TX2-: C351.1 U24.DJ3
USB30_TX2-_C: C351.2 R284.2
USB30_TX2-_C_R: C352.1 CN7.8 R284.1 U11.5
USB30_TX3+: C684.2 U24.DF5
USB30_TX3-: C675.2 U24.DF3
USB30_TX+_TYPEC1: C702.1 CN14.A2 RV2.5 RV2.6
USB30_TX+_TYPEC1_C: C702.2 U34.10
USB30_TX+_TYPEC2: C669.1 CN14.B2 RV1.5 RV1.6
USB30_TX+_TYPEC2_C: C669.2 U34.17
USB30_TX-_TYPEC1: C701.1 CN14.A3 RV2.4 RV2.7
USB30_TX-_TYPEC1_C: C701.2 U34.11
USB30_TX-_TYPEC2: C668.1 CN14.B3 RV1.4 RV1.7
USB30_TX-_TYPEC2_C: C668.2 U34.16
USB30_TX_N4: R273.1 U24.DF2
USB30_TX_P4: R273.2 U24.DF1
USB_BC_ON: U7.4 U13.97
USB_CHARGE_ON: R234.1 U7.5 U13.96
USB_CLT1: U7.6 U13.79
USB_ID: R286.2 U24.DL6
USB_OC0#: C654.2 R768.2 U7.13 U24.DW14
USB_OC1#: C329.2 R678.2 U24.CR41 U28.3
USB_OC2#: C344.2 R276.2 U24.CT41 U35.3
USB_OC3#: R272.2 TP32.1 U24.CT43
USB_VBUSSENSE: R287.2 U24.DL11
USBON#: U13.99 U28.4 U35.4
USBP1+: R247.1 R252.1 U24.DP8
USBP1+_C: R217.1 U7.10
USBP1+_C_R: R218.1 R252.2
USBP1+_C_R_N: CN5.3 R217.2 R218.2 U5.7
USBP1+_U14: R247.2 U7.3
USBP1-: R246.1 R251.1 U24.DN8
USBP1-_C: R210.1 U7.11
USBP1-_C_R: R211.1 R251.2
USBP1-_C_R_N: CN5.2 R210.2 R211.2 U5.4
USBP1-_U14: R246.2 U7.2
USBP2+: R298.2 U24.DJ11
USBP2+_C: CN7.3 R298.1 U11.7
USBP2-: R293.2 U24.DK11
USBP2-_C: CN7.2 R293.1 U11.4
USBP3+_TPC: R486.2 U24.DN13
USBP3-_TPC: R489.2 U24.DP13
USBP4+_DB: CN6.16 U24.DJ10
USBP4-_DB: CN6.15 U24.DK10
USBP5+_CAM: R522.2 U24.DL3
USBP5+_CAM_C: CN2.8 R522.1
USBP5-_CAM: R521.2 U24.DL5
USBP5-_CAM_C: CN2.7 R521.1
USBP6+_CR: CN6.19 U24.DN11
USBP6-_CR: CN6.18 U24.DP11
USBP7+_FP: CN13.7 EC6.2 U24.DJ13
USBP7-_FP: CN13.6 EC7.1 U24.DK13
USBP8+_TS: R520.2 U24.DP6
USBP8-_TS: R519.2 U24.DN6
USBP8_TS+_C: CN2.5 R520.1
USBP8_TS-_C: CN2.4 R519.1
USBP10+_BT: CN9.3 U24.DN10
USBP10-_BT: CN9.5 U24.DP10
USBP_TYPC+_C: CN14.A6 CN14.B6 R486.1 RV3.1
USBP_TYPC-_C: CN14.A7 CN14.B7 R489.1 RV3.2
USBPWRD2: C670.1 C671.2 C672.2 C673.2 C674.2 CN6.36 CN6.37 CN6.38 CN6.39 CN6.40 U35.1(OUT)
VA: PC8.1 PC14.1 PC143.1 PC145.1 PD2.1 PD4.2 PJ6.1 PQ3.5 PR71.1 PR245.1
VA2: PC6.1 PQ3.1 PQ3.2 PQ3.3(S3) PQ4.1 PQ4.2 PQ4.3(S3) PR248.1
VADJ1: C61.1 CN2.27 R26.2 R27.1
VGA_OVT#: Q1.1(S) R564.1 U22.A6
VGA_RST#: C493.1 R502.2 U22.AC7
VGA_VCCSENSE: PR26.2 PR28.2 U22.F2
VGA_VSSSENSE: PR23.2 PR24.2 U22.F1
VL: PR117.2 PR262.1
VMA_CLK0: R531.2 U22.D24 VRAM2.J12
VMA_CLK0#: R531.1 U22.D25 VRAM2.J11
VMA_CLK1: R524.2 U22.N22 VRAM1.J12
VMA_CLK1#: R524.1 U22.M22 VRAM1.J11
VMA_DQ0: U22.E18 VRAM2.E2
VMA_DQ1: U22.F18 VRAM2.F2
VMA_DQ2: U22.E16 VRAM2.A2
VMA_DQ3: U22.F17 VRAM2.B2
VMA_DQ4: U22.D20 VRAM2.F4
VMA_DQ5: U22.D21 VRAM2.B4
VMA_DQ6: U22.F20 VRAM2.E4
VMA_DQ7: U22.E21 VRAM2.A4
VMA_DQ8: U22.E15 VRAM2.B11
VMA_DQ9: U22.D15 VRAM2.E13
VMA_DQ10: U22.F15 VRAM2.A13
VMA_DQ11: U22.F13 VRAM2.A11
VMA_DQ12: U22.C13 VRAM2.E11
VMA_DQ13: U22.B13 VRAM2.F11
VMA_DQ14: U22.E13 VRAM2.B13
VMA_DQ15: U22.D13 VRAM2.F13
VMA_DQ16: U22.B15 VRAM2.N11
VMA_DQ17: U22.C16 VRAM2.U11
VMA_DQ18: U22.A13 VRAM2.M11
VMA_DQ19: U22.A15 VRAM2.T11
VMA_DQ20: U22.B18 VRAM2.U13
VMA_DQ21: U22.A18 VRAM2.T13
VMA_DQ22: U22.A19 VRAM2.N13
VMA_DQ23: U22.C19 VRAM2.M13
VMA_DQ24: U22.B24 VRAM2.N4
VMA_DQ25: U22.C23 VRAM2.U4
VMA_DQ26: U22.A25 VRAM2.M4
VMA_DQ27: U22.A24 VRAM2.T4
VMA_DQ28: U22.A21 VRAM2.T2
VMA_DQ29: U22.B21 VRAM2.U2
VMA_DQ30: U22.C20 VRAM2.M2
VMA_DQ31: U22.C21 VRAM2.N2
VMA_DQ32: U22.R22 VRAM1.U11
VMA_DQ33: U22.R24 VRAM1.N11
VMA_DQ34: U22.T22 VRAM1.U13
VMA_DQ35: U22.R23 VRAM1.M11
VMA_DQ36: U22.N25 VRAM1.N13
VMA_DQ37: U22.N26 VRAM1.M13
VMA_DQ38: U22.N23 VRAM1.T11
VMA_DQ39: U22.N24 VRAM1.T13
VMA_DQ40: U22.V23 VRAM1.M4
VMA_DQ41: U22.V22 VRAM1.N4
VMA_DQ42: U22.T23 VRAM1.U4
VMA_DQ43: U22.U22 VRAM1.T4
VMA_DQ44: U22.Y24 VRAM1.N2
VMA_DQ45: U22.AA24 VRAM1.T2
VMA_DQ46: U22.Y22 VRAM1.M2
VMA_DQ47: U22.AA23 VRAM1.U2
VMA_DQ48: U22.AD27 VRAM1.F2
VMA_DQ49: U22.AB25 VRAM1.B2
VMA_DQ50: U22.AD26 VRAM1.E2
VMA_DQ51: U22.AC25 VRAM1.A2
VMA_DQ52: U22.AA27 VRAM1.B4
VMA_DQ53: U22.AA26 VRAM1.A4
VMA_DQ54: U22.W26 VRAM1.E4
VMA_DQ55: U22.Y25 VRAM1.F4
VMA_DQ56: U22.R26 VRAM1.B13
VMA_DQ57: U22.T25 VRAM1.A13
VMA_DQ58: U22.N27 VRAM1.F13
VMA_DQ59: U22.R27 VRAM1.E13
VMA_DQ60: U22.V26 VRAM1.A11
VMA_DQ61: U22.V27 VRAM1.B11
VMA_DQ62: U22.W27 VRAM1.F11
VMA_DQ63: U22.W25 VRAM1.E11
VMA_WCK01: U22.D18 VRAM2.D4
VMA_WCK01#: U22.C18 VRAM2.D5
VMA_WCK23: U22.D17 VRAM2.P4
VMA_WCK23#: U22.D16 VRAM2.P5
VMA_WCK45: U22.T24 VRAM1.P4
VMA_WCK45#: U22.U24 VRAM1.P5
VMA_WCK67: U22.V24 VRAM1.D4
VMA_WCK67#: U22.V25 VRAM1.D5
VQQD_VPPSNS: PR123.2 PU1.12
VR_SVID_ALERT#: PR61.1 PR204.2 R587.2 R588.1
VR_SVID_CLK: PR63.1 PR206.2 R590.2
VR_SVID_DATA: PR62.1 PR205.2 R585.1 R586.2
VRALERT#: D23.1(CATHODE) R241.1 R571.1 U24.CN38
VREF_RC: PC60.2 PR57.2
VRON: PR46.1 R459.1 U13.69
VSTBY_FSPI: R331.2 R344.2 U13.106
WIGIG_LED: CN9.6 TP83.1
WLAN_RST#: CN9.52 R819.1
WLANPWR#: TP48.1 U13.35
WRST#: C435.1 D13.2 R399.1 U13.14(WRST#)
XDP_PCH_SPI0_IO2: R723.2 R743.1 R753.1 TP92.1
XDP_PCH_SPI0_SI: R755.2 R771.1 R778.1 TP96.1
XDP_RSMRST#: R704.1 TP82.1
XDP_TCK: R603.1 R604.2 TP69.1 U24.P3
XDP_TDI_CPU: R592.2 TP66.1 U24.K5
XDP_TDO_CPU: R598.2 R599.1 TP67.1 U24.K3
XDP_TMS_CPU: R608.2 TP70.1 U24.P4
XDP_TRST#: R602.2 TP68.1 U24.N1
XTAL1: R16.2 U1.28
XTAL2: R15.1 U1.29
XTAL_38P4M_IN: R727.2 U24.DW8
XTAL_38P4M_IN_R: C658.2 R727.1 R740.1 Y4.1
XTAL_38P4M_OUT: R726.2 U24.DU8
XTAL_38P4M_OUT_R: C657.2 R726.1 R740.2 Y4.3
XTAL_SSIN: R570.1 U22.A10
N06325: Q43.3 R798.1 R807.2 R820.2
N10350616: PC200.2 PR200.2 PR203.2 PR204.1 PR205.1 PR206.1
N10356361: PR47.2 PR52.2 PR160.2
N16824426: R509.2 R510.2 U20.2
N17002655: C629.2 U30.39
N17002661: C615.2 U30.37
N17002676: C622.1 U30.34
N17002678: C635.1 U30.19
N17002722: R338.2 R366.2 U30.48
N17002952: C659.1 U30.7
N17002968: R754.1 R772.1 R782.1 U30.11
N17002995: C660.1 R746.1 R756.1 U30.12
N17003129: C615.1 U30.35
N17003186: R695.1 U30.20
N17004316: D37.1(CATHODE) Q45.3
N17047007: PQ4.5 PR12.1 PR18.1
N17047009: PR261.1 PU12.20
N17047028: PR267.1 PU12.19
N17047087: PC91.1 PL11.2 PQ11.1 PQ11.2 PQ11.3(S3) PR108.1 PR266.1 PR270.2
N17047112: PC6.2 PC8.2 PQ3.4 PQ4.4 PR247.1
N17047335: PC249.1 PR268.2
N17047399: PC243.2 PR254.2
N17047601: PC91.2 PQ11.4 PR99.1
N17398787: PR80.2 PU12.5
N17424918: PR253.2 PU12.11
N17424920: PR255.2 PU12.12
N17424921: PR249.2 PU12.7
N17424925: PR251.2 PU12.9
N17424950: PR86.2 PR88.2 PU12.15
N17661815: PR250.2 PU12.8
N17755724: PC62.2 PR231.2 PR233.1 PR235.1 PR241.1 PR243.1
N18377216: R302.1 U24.DL27
N18377220: R311.1 U24.DJ29
N18867651: PC109.1 PC112.1 PR107.1 PU7.8 PU7.9
N18867812: PC78.1 PC81.1 PR87.1 PU6.8 PU6.9
N18922914: C41.2 C54.2 C57.2 R17.1 U22.AA8 U22.AA9
N19138106: R59.2 U22.F22
N19138109: R46.2 U22.J22
N19521323: PQ12.3 PR83.1
N19521733: PQ12.2 PR82.1 PR92.1 PR96.1
N19549602: PQ13.2 PR118.1 PR121.1 PR122.1
N20858957: C211.2 R154.2
N20946170: R114.1 U2.E9
N20946459: R229.1 U6.E9
N20946794: R190.1 U4.E9
N20947128: R295.1 U8.E9
N21263014: TP9.1 U22.E10
N21263017: TP10.1 U22.F10
N24507642: PC102.1 PR105.1 PR106.2 PU14.6
N24507664: PC102.2 PR106.1 PR272.1
N24507676: PC104.2 PR116.1 PU14.1
N24507691: PR109.2 PU14.5
N24742093: PC155.1 PC156.1 PC157.1 PJ7.1 PQ19.1 PQ19.2 PQ19.3(S3) PR141.1
N24742096: PD7.2 PQ15.3 PR151.2
N24742104: PQ15.2 PQ17.2 PQ18.3 PR145.2 PR146.1
N24742107: PC31.1 PC32.1 PR34.2 PU3.13 PU3.14(VOUT1#2)
N24742118: PR147.1 PU8.3
N24742123: PQ17.3 PR141.2
N24742126: PC158.1 PQ18.2 PR153.1 PU8.4
N24742146: PC161.1 PR152.2
N24742173: PC40.1 PR37.2 PU3.4
N24742207: PC34.1 PU3.10
N24742208: PC33.1 PU3.12
N24742222: PC41.1 PR38.1 PU3.5
N24742230: PC39.1 PR36.2 PU3.3
N24995566: PC255.1 PR262.2 PU13.5(VCC)
N24995570: PR263.1 PU13.1
N24995581: PR269.1 PU13.3
N25365001: PQ2.3 PR5.2
N25369936: Q21.1(S) R433.2 R437.1
N25369945: Q21.4 R449.2 R450.1
N25430988: PQ23.3 PR232.2
N25430994: PQ28.3 PR256.2
N25431520: PQ25.3 PR238.2
N25804343: PR136.2 PR138.2
N25817818: PQ5.3 PR39.2
N25817820: PQ5.2 PQ6.3 PR40.2 PR42.1
N25821251: PC172.1 PR156.2
N27752748: R694.1 R695.2 R697.1
N28087213: C525.2 R8.1 R9.1 R10.1 R11.1
N28100067: CN12.8 R796.1
N28379472: PC146.1 PR137.1 PR139.1 PR140.2
N28379477: PC30.1 PR27.1
N28380796: PR20.1 TP1.1
N28380828: PC19.1 PR16.2 PR21.2
N28414264: PR133.1 PR142.1 PU2.13
N28607521: PR25.1 PU2.22
N29093947: Q8.2 Q9.3 R83.1
N30319022: PC42.1 PC43.1 PC44.1 PC45.1 PC46.1 PC167.1 PC168.1 PC169.1 PJ8.2 PL6.2 PR41.1
N30319317: PC183.2 PR41.2 PR167.1
N30319351: PC171.2 PR154.1
N30442035: PC103.1 PC105.1 PR111.2 PU6.13 PU6.14(VOUT1#2)
N30442060: PC93.1 PR93.1 PU6.4
N30442062: PC98.1 PU6.12
N30442063: PC92.1 PU6.10
N30442080: PC87.1 PR89.2 PU6.5
N30442084: PC99.1 PR100.2 PU6.3
N30568314: PC70.2 PR78.1 PR84.2 PU11.12
N30568326: PC70.1 PR72.1
N30568424: PC272.2 PR274.1 PR275.2 PU15.9
N30568429: PC272.1 PR278.1
N30568472: PC266.1 PR117.1 PU15.12
N30568498: PQ13.3 PR279.1
N30568535: PR230.1 PR234.2 PR237.1 PR244.2
N31069510: PC106.1 PC108.1 PR110.2 PU7.13 PU7.14(VOUT1#2)
N31161958: PC251.1 PR260.2 PU7.4
N31161974: PC111.1 PU7.12
N31161976: PC110.1 PU7.10
N31162017: PC250.1 PR259.2 PU7.5
N31162025: PC252.1 PR257.1 PU7.3
N31353058: PC83.1 PC84.1 PC95.1 PC97.1 PJ3.1 PL3.2 PR95.2
N31353100: PC75.2 PR79.2
N33618596: Q27.3 R495.2
N33761123: CN18.38 R498.1 R501.1
N33761125: CN18.50 R497.1
N33761127: CN18.68(SUSCLK) TP49.1
N35663361: R265.2 R288.2 R297.1 U9.1
N35697678: R625.2 R627.1 U25.4(Y)
N35697684: C578.1 Q37.2 Q38.2 R625.1
N35745518: PR211.2 PR217.1 PR218.1
N35745545: PQ24.4 PR228.2
N35745570: PC220.2 PR235.2
N35745574: PC213.2 PR229.1
N35745601: PC206.2 PR210.1
N35849315: R623.2 U24.BY2 U24.CB2 U24.CC1
N36191354: R297.2 U9.4 U29.2
N36203385: Q24.6 R454.1 R456.2
N36203387: Q24.2 Q24.3 R474.1
N36208700: Q39.2 Q39.3 R628.1
N36208702: Q39.6 R621.1 R627.2
N36209325: R675.1 U10.4 U29.1
N36446693: C32.1 R15.2 Y1.3
N36953746: C393.2 Q19.2 R418.2
N36954805: R464.2 U16.7
N36977514: Q44.3 Q47.2 R827.2
N37139396: D16.2 R423.1
N37139525: R458.2 U15.24
N37139527: R417.2 U15.21
N37139529: R403.2 U15.19
N37139539: R400.2 U15.18
N37139543: R412.2 U15.20
N37162665: L13.1 R313.2 R690.2
N37162929: R366.1 TP41.1
N37164012: C638.1 U30.16
N37164724: R699.2 R707.2
N37190310: C508.1 D22.2 HE1.2(VCC) R507.2
N37352433: PC17.1 PR10.1
N37598035: R104.1 U3.4
N37994586: C170.2 R94.2 R95.2
N38144837: Q40.2 Q40.3 R688.1
N38144855: Q40.6 R667.1 U9.2
N38144913: R680.1 U29.4
N38517581: D20.1 R490.2 R494.1
N38517589: Q26.2 R490.1
N38517597: Q23.4 Q26.3(E) R472.2 R482.2
N38517605: Q22.3 R482.1
N38517627: Q30.3 R493.2
N38517632: C444.2 Q22.5 Q22.6 R447.1
N38517638: C492.2 Q30.2 R499.2
N38521997: CN10.1 D18.1 R430.1
N38680042: D34.1(CATHODE) D35.1(CATHODE) R699.1
N38680880: Q16.2 R365.1
N38756738: C387.2 R402.1 U13.82
N38756749: TP43.1 U13.87
N38756787: C367.2 R318.1 U13.98
N38756834: Q7.3 R622.2 SW3.3 SW3.4
N38757336: C371.1 R310.1 U13.128
N38757362: C480.2 R487.1 U13.66
N38757406: C112.1 Q7.2 R37.2 SW2.3 SW2.4
N38758998: C389.2 R419.1
N38759178: C388.1 U13.12
N39168858: Q34.3 R111.2 R117.2 R121.2 R124.2 R138.2 R144.2 R153.2 R157.2
N39692582: Q32.2 R572.2 R574.1 R578.2
N39707880: R696.2 Y3.2
N39785725: HD1.1 R834.1 R835.1
N40437801: TP57.1 U22.V7
N40437812: TP55.1 U22.W7
N40437815: TP56.1 U22.W6
N40437818: TP54.1 U22.Y6
N40911013: R530.2 VRAM2.J13(ZQ)
N40911015: R523.2 VRAM1.J13(ZQ)
N43700942: CN2.24 R517.2
N43737419: CN2.29 R516.2
N44885066: PD4.3(COMMON ANODE) PR81.2
N45198823: PC128.1 PC129.1 PL1.2 PR123.1 PR127.1
N45477665: C37.2 Q2.2 R14.2
N45672179: R764.1 U24.DU14
N45773643: Q12.1(S) R187.2 R188.2
N45773665: Q11.2 R188.1
N45774339: R320.2 U13.103
N45774342: R321.2 U13.102
N45774345: R322.2 U13.101
N45774348: R319.2 U13.105
N47271970: R558.2 R559.2 R560.2 R561.2 R569.2
N47273600: PJ11.5 PR113.1
N47273609: PJ11.4 PR120.1
N47273625: PJ11.3 PR119.1
N48434117: C127.2 C133.2 C135.2 L5.2 U22.F11
N48587681: R42.1 U22.N6
N48650493: Q1.2 R1.1 R2.1
N49263752: R565.2 R566.2 R567.2 R568.1
N59038271: C649.1 R716.1 R717.2
N60242660: C125.2 R48.1
N453702120: TP46.1 U13.48
N3707465495: R264.2 U8.T7
N3707518295: R209.2 U6.T7
N3707546095: R165.2 U4.T7
N3707585895: R99.2 U2.T7
N4537377412: TP40.1 U13.4

Pads without a net: CN2 38; CN4 13 14; CN6 25 26 28 33 34 35; CN9 8 12 16 20 38 40 42 44 46 48; CN13 1 2 3 4; CN16 3; CN17 5; CN18 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CN19 3 4; HOLE2 1; HOLE13 1; JDIM1 162 165; NOREF#2 1; NOREF#3 1; NOREF#4 1; NOREF#9 1; NOREF#11 1; NOREF#12 1; PQ14 2; PQ16 2; PQ20 2; PQ21 2; PU5 5; PU9 7; U3 3 23 24; U7 9; U13 93; U15 2 3 5 6 7 9 10 11 12 13 14 15 25 26 27 28 29 30 31 32; U16 2 3; U22 A3 A16 A22 AA1 AA2 AA3 AA4 AA5 AA6 AA14 AA15 AB1 AB2 AB3 AB4 AB5 AB6 AB8 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B4 B6 B19 C2 C3 C7 C14 D4 D10 D11 D23 E6 E7 E9 F4 F5 F6 F7 F19 G1 G2 G3 G4 G5 G6 G7 H3 H4 H6 J1 J2 J3 J4 J5 J6 J7 K1 K2 K3 K4 K5 K6 K7 L3 L4 M1 M2 M3 M4 M5 M7 N1 N2 N3 N4 N5 N7 P3 P4 P6 P25 R1 R2 R3 R4 R5 R6 R7 T1 T2 T3 T4 T5 T6 T7 T27 U3 U4 U6 V1 V2 V3 V4 V5 V6 W1 W2 W3 W4 W5 W22 Y3 Y4; U24 A4 A5 A7 A9 A12 A14 A33 AA35 AD3 AD4 AE11 AF10 AH10 AJ11 AK10 AL3 AL5 AL11 AM10 AN3 AN5 AN7 AN9 AN11 AP10 AR5 AR6 AR10 AV5 AV6 AY5 AY6 B7 B9 B12 B14 B33 BB1 BB2 BB5 BB6 BC10 BD1 BD2 BF1 BF2 BF5 BF6 BF38 BG5 BG6 BG11 BH1 BH2 BH10 BJ5 BJ6 BJ11 BJ47 BL1 BL2 BL10 BM1 BM2 BM36 BM42 BP5 BP6 BP36 BP41 BP42 BR1 BR2 BT1 BT2 BT5 BT6 BT36 BV5 BV6 C2 C7 C8 C9 C12 C33 CG32 CH33 CH49 CJ32 CJ39 CK3 CK4 CK33 CK47 CL3 CL5 CL32 CL41 CL43 CL45 CN32 CN41 CN42 CN43 CP3 CP5 CT38 CV37 CV41 CV43 CV47 CY35 CY37 CY38 CY39 D1 D7 D8 D9 D12 D14 D33 DA11 DA45 DA48 DA49 DB37 DB39 DC45 DD38 DD39 DE47 DE49 DF37 DF38 DF41 DF48 DG38 DG40 DH47 DJ17 DJ22 DJ34 DJ40 DK15 DK22 DK29 DK31 DK36 DK40 DL1 DL2 DL17 DL36 DL38 DN17 DN27 DN38 DN48 DP3 DP5 DP15 DP17 DP27 DP29 DP38 DR5 DT2 DT11 DT16 DT18 DT19 DT28 DT29 DT30 DT33 DT34 DT36 DT38 DT40 DT41 DU18 DU22 DU23 DU24 DU29 DU30 DU33 DU34 DU36 DU38 DU41 DU42 DV11 DV14 DV19 DV22 DV24 DV28 DV30 DV33 DV36 DV38 DV41 DW18 DW19 DW23 DW24 DW28 DW29 DW30 DW33 DW34 DW36 DW38 DW40 DW41 DW42 E16 F6 F10 F13 G6 G8 G10 G11 G13 G34 H5 H34 J8 J11 J34 K6 K10 K13 L6 L8 L10 L11 L13 M8 M11 M13 M38 M41 M42 M43 N34 P10 P43 T39 V38 V39 V46 W35 Y11 Y34 Y39; U26 1; U30 14 15 23 24; VRAM1 A5 A10 U5 U10; VRAM2 A5 A10 U5 U10

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 3945 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 2430 vias
v3: diameter 0.305, hole 0.152, TOP to BOTTOM, 2 vias
v4: diameter 0.61, hole 0.356, TOP to BOTTOM, 322 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V8_AON_S:
  vias: v1(24.8,98.41)
1V8_MAIN_EN: length 191.1
  TOP w0.102: v2(88.31,99.74) 87.15,99.74 86.9,99.5 86.9,98.27 86.5,97.86 86.5,97.47 86.17,97.14 86,97.14 R60.1 85.95,96.79 86.7,96.79 86.93,97.01 R61.1 ; PR36.1 21.94,87.48 21.7,87.72 21.7,87.94 21.14,88.51 20.66,88.51 v1(20.61,88.56) ; PQ1.2 124.54,122.15 124.87,121.81 PR4.1 v1(126.77,121.81)
  TOP w0.203: v1(77.02,115.81) 77.18,115.66 PD1.1 77.79,116.69 v1(77.71,116.78) 77.33,116.39 75.86,116.39 75.64,116.61 PR11.2
  IN1 w0.089: v2(88.31,99.74) 87.67,100.39 87.67,102.27 88.28,102.88 88.28,107.96 87.97,108.27 87.97,108.9 88.87,109.8 89.12,109.8 90.26,110.94 90.26,115.59 92.8,118.12 92.8,119.04 95.54,121.78 95.79,121.78 v2(95.92,121.91) 96.39,121.91 96.77,122.29 96.77,122.79 97.45,123.47 101.38,123.47 101.64,123.72 104.54,123.72 107.25,121.02 121.22,121.02 121.73,121.53 126.48,121.53 v1(126.77,121.81)
  IN2 w0.089: v1(77.02,115.81) 77.02,117.72 74.34,120.39 74.34,125.5 74.74,125.89 76.21,125.89 78.14,123.96 85.02,123.96 87.08,121.91 87.08,121.07 88.33,119.82 92.7,119.82 94.65,121.78 95.79,121.78 v2(95.92,121.91)
  IN3 w0.089: v1(77.02,115.81) 76.01,115.81 75.75,115.56 74.74,115.56 73.47,114.29 70.55,114.29 69.91,113.65 60.77,113.65 60.34,114.08 52.02,114.08 51.88,113.94 51.88,111.37 49.64,109.13 46.09,109.13 45.4,108.44 44.26,108.44 42,106.18 42,104.74 40.54,103.28 38.12,103.28 37.45,102.6 25.61,102.6 25.13,102.12 22.39,102.12 21.02,100.75 21.02,93.08 22.16,91.93 22.16,90.92 20.61,89.37 v1(20.61,88.56)
1V8_MAIN_EN_N17: length 17.3
  TOP w0.102: v2(99.71,96.66) 99.71,96.84 98.61,97.93 97.95,97.93 97.75,97.73 97.75,97.2 97.44,96.89 96.85,96.89 96.05,97.69 96.05,98.28 93.94,100.39 93.54,100.39 90.37,97.22 88.9,97.22 88.7,97.01 R61.2
  BOTTOM w0.102: v2(99.71,96.66) 100.5,96.66 U22.F9
5V_HSMBCK: length 7.6
  TOP w0.102: D5.1 24.59,70.11 24.45,69.96 23.05,69.96 22.79,70.22 22.79,71.11 21.26,72.64 v1(21.26,72.88) ; R163.1 20.78,73.93 v1(20.94,73.76)
  BOTTOM w0.102: v1(21.26,72.88) 21.26,73.44 v1(20.94,73.76)
5V_HSMBDT: length 3.2
  TOP w0.102: R164.1 22.24,72.38 v1(22.36,72.25) 23.29,71.32 D5.2
8813VID: length 3.5
  TOP w0.102: PR22.2 71.29,113.63 71.44,113.78 71.64,113.78 71.74,113.88 PR20.2
  TOP w0.254: PR20.2 v1(72.53,114.16) 73.23,113.46 PU2.5
8813VOUT1: length 4.3
  TOP w0.254: PC26.1 70.85,110.06 70.88,110.03 PU2.11 ; PC26.1 70.65,109.34 v1(70.55,109.24) ; PC26.1 69.71,110.06 PC27.1 69.43,109.78 PR26.1
8813VREF: length 6.2
  TOP w0.254: PC21.1 69.56,113.52 70.05,113.03 70.05,112.6 70.45,112.2 v1(70.65,112.2) 70.88,112.2 71.55,111.53 PU2.8
  BOTTOM w0.254: v1(70.65,112.2) 71.27,112.2 PR140.1 71.3,110.98 71.21,110.89 PR142.2
+1.2V_VCCPLL_OC: length 30.3
  TOP w0.508: L8.2 50.82,31.43 R332.1 51.53,32.14 53.77,32.14 v1(54.27,32.64) 54.27,33.35 53.78,33.83 53.78,34.91 53.61,35.09 53.61,40.81 54.29,41.5 54.29,46.47 55.18,47.36 55.81,47.36 59.12,50.66 60.79,50.66 60.92,50.53 R221.1
+1.2V_VCCPLL_OC_S2: length 1.1
  TOP w0.508: Q14.1 v1(50.04,32.79)
+1.2VSUS: length 259.4
  TOP w0.178: v1(39.14,42.25) 39.48,42.59 39.48,43.49 U8.J2 U8.J1
  TOP w0.203: PR7.1 59.65,118.35 59.4,118.1 55.94,118.1 55.26,118.78 52.22,118.78 50.22,120.78 ; v1(64.07,30.69) 63.64,31.13 63.64,37.83 63.89,38.09 R278.1
  TOP w0.254: v1(33.11,84.57) 33.46,84.57 33.53,84.63 U2.T9 ; C303.1 31.06,51.01 31.68,51.01 32.1,51.42 34.09,51.42 34.1,51.43 U6.T9 ; C214.1 30.92,71.62 30.92,71.36 31.3,70.98 32.31,70.98 32.67,71.33 U4.T9 ; U6.G9 v1(41.87,51.03) ; v1(38.67,37.07) 38.65,37.07 38.16,37.56 38.16,38.17 U8.L9 ; U2.A1 46.61,91.03 v1(46.82,91.25) ; U6.F8 v1(41.87,51.83)
  TOP w0.305: v1(34.67,90.64) 34.68,90.64 U2.R1 ; v1(39.99,82.94) 39.33,82.94 38.52,83.76 38.52,84.42 38.3,84.63 U2.L9 ; U8.J9 v1(40.27,37.88) ; U2.J9 39.85,84.63 39.46,85.02 v1(39.46,85.03) 39.46,85.03 39.86,85.43 U2.J8
  TOP w0.356: v1(44.27,57.43) U6.D1 ; v1(41.87,37.88) U8.G9 ; v1(41.36,60.83) 40.84,60.31 40.02,60.31 38.27,58.56 U6.L1 ; U8.T9 34.22,38.23 32.59,38.23 v1(32.07,37.71) 31.84,37.93 30.96,37.93 C346.1 ; U4.J9 40.07,71.13 40.07,70.85 40.7,70.22 v1(41.08,70.22) ; v1(41.87,38.68) U8.F8 ; v1(44.27,77.33) U4.D1 ; U8.B3 v1(45.47,41.26) ; U6.R1 34.39,58.51 31.91,58.51 30.82,59.6 30.8,59.6 C268.1 30.58,60.78 v1(30.41,60.95) ; v1(46.67,84.23) U2.A9 ; v1(45.87,50.95) 45.58,51.25 45.58,51.27 45.47,51.38 U6.B9 ; v1(41.87,71.73) U4.F8 ; v1(46.04,88.3) 45.7,88.64 45.7,89.21 U2.B3 ; U2.C1 44.67,91.32 44.56,91.43 v1(44.56,91.73) ; v1(45.87,57.44) 46.26,57.83 U6.A1 ; v1(45.87,84.23) U2.B9 ; U8.B9 45.07,37.88 v1(45.07,37.88) ; v1(42.67,73.33) U4.E7 ; U6.B3 45.87,55.83 v1(45.87,55.78) ; v1(42.68,56.62) 42.67,56.63 42.67,56.63 U6.F2 ; U2.F2 41.87,89.83 v1(41.87,89.83) ; v1(41.87,53.43) U6.G7 ; v1(41.87,70.93) U4.G9 ; v1(44.27,70.93) U4.D9 ; U4.R1 34.39,78.41 33.11,78.41 33.08,78.39 31.39,78.39 31.09,78.68 C199.1 ; v1(30.54,46.01) 30.8,46.01 32.12,44.69 33.16,44.69 33.67,45.2 34.55,45.2 U8.R1 ; v1(45.87,37.88) U8.A9 ; v1(40.27,38.68) U8.J8 ; v1(41.87,85.03) U2.F8 ; U2.J1 v1(39.47,90.63) U2.J2 ; v1(42.67,90.63) U2.E2 ; v1(45.07,45.08) U8.C1 ; C320.1 39.44,48.36 39.08,48.73 39.08,50.62 U6.L9 ; v1(42.18,59.22) 42.18,59.02 41.67,58.51 40.55,58.51 U6.J1 39.88,57.83 40.13,57.58 40.13,57.29 U6.J2 ; v1(43.42,37.83) U8.D9 ; U4.L1 38.27,78.58 39.18,79.49 v1(39.18,79.59) ; U4.J2 40.07,77.13 40.07,77.53 U4.J1 40.99,78.85 v1(41.36,78.85) ; v1(46.67,44.28) U8.A1 ; v1(41.87,78.13) U4.G1 ; v1(43.47,44.28) U8.E2 ; v1(41.87,43.47) 41.87,43.48 U8.F2 ; U2.D1 v1(44.27,90.63) ; v1(43.47,77.33) U4.E2 ; v1(41.87,72.53) U4.G7 ; U6.E7 43.07,53.54 v1(44.26,54.72) ; v1(42.67,86.63) U2.E7 ; v1(41.87,85.83) U2.G7 ; U6.A9 46.67,51.03 v1(46.67,51) ; v1(41.87,44.28) U8.G1 ; v1(46.67,77.33) U4.A1 ; v1(45.07,70.93) 45.07,70.93 U4.B9 ; v1(40.32,45.88) 39.36,45.88 38.27,44.8 U8.L1 ; v1(44.27,51.03) U6.D9 ; v1(45.07,77.33) U4.C1 ; U6.J9 v1(40.27,51.03) ; v1(41.87,57.43) U6.G1 ; U4.L9 v1(39.41,70.19) ; v1(44.27,45.08) U8.D1 ; v1(40.27,51.83) U6.J8 ; v1(44.27,84.23) U2.D9 ; v1(41.87,84.23) U2.G9 ; v1(43.47,57.43) U6.E2 ; v1(39.47,71.73) U4.J8 ; v1(45.87,75.73) U4.B3 ; U2.L1 v1(37.88,90.64) ; v1(45.07,57.43) U6.C1 ; U4.F2 42.27,76.93 v1(41.87,76.53) ; v1(41.87,91.43) U2.G1 ; v1(41.87,39.48) U8.G7 ; v1(42.67,40.28) U8.E7
  TOP w0.381: R112.2 32.26,81.92 v1(32.35,82)
  TOP w0.508: C214.1 30.55,72.14 30.54,72.15 30.54,72.63 30.29,72.88 v1(29.81,72.88) ; C303.1 30.55,51.87 30.26,52.16 v1(29.63,52.16) ; C355.1 38.3,35.3 38.55,35.55 v1(38.55,35.92) ; v1(41.72,82.66) 41.4,82.66 40.82,82.08 C191.1 ; C320.1 39.81,48.49 39.81,49.14 v1(40.32,49.64) ; C257.1 v1(34.74,62.7) 34.23,63.21 v1(34.12,63.21) ; v1(43.76,35.92) C356.1 ; v1(29.91,78.35) 30.25,78.68 C199.1 ; C357.2 44.76,35.54 44.77,35.55 v1(44.77,35.92) ; v1(44.89,48.88) 44.89,48.24 C321.1 ; v1(45.77,48.88) C322.2 ; C350.1 v1(31.43,37.2)
  IN2 w0.203: v1(64.07,30.69) 62.05,30.69 61.58,30.22 50.36,30.22 45.86,34.72 44.19,34.72 43.76,35.16 v1(43.76,35.92)
  BOTTOM w0.152: U24.AL49 73.39,66.24 73.34,66.19 v2(73.11,66.19) ; v2(72.43,53.38) 72.63,53.59 73.9,53.59 74.02,53.71 74.66,53.71 U24.BU49 ; U24.BA49 74.67,61.22 73.95,61.22 73.82,61.09 73.11,61.09 72.93,60.92 v2(72.87,60.92) ; U24.T49 74.67,73.74 73.81,73.74 73.65,73.9 73.49,73.9 v2(73.47,73.87) ; v2(72.3,55.71) 72.7,55.71 73.2,56.22 74.66,56.22 U24.BM49 ; v2(72.96,63.74) U24.AT49 ; U24.BF49 74.66,58.72 73.94,58.72 73.74,58.52 73.13,58.52 v2(72.99,58.38) ; v2(73.75,71.21) 73.77,71.21 73.8,71.23 74.67,71.23 U24.AA49
  BOTTOM w0.178: U24.CB49 74.02,51.23 73.89,51.1 72.98,51.1 v2(72.83,50.95) ; U24.L49 v2(73.8,76.34) ; U24.AF49 74.02,68.74 73.9,68.86 71.77,68.86 71.26,69.38 68.9,69.38 68.85,69.33
  BOTTOM w0.203: v2(78.99,52.11) 78.99,52.09 79.03,52.05 79.03,51.91 U24.CA39 ; v2(79.7,76.77) 79.68,76.75 79.68,76.62 U24.L38
  BOTTOM w0.254: v1(53.66,43.95) 54.27,43.95 55.51,42.71 JDIM1.54 ; 59.88,70.85 59.88,70.98 59.65,71.2 JDIM1.160 ; v1(48.96,91.81) 49.31,91.45 JDIM1.241 ; v1(47.31,62.44) 47.31,62.19 48.04,61.46 JDIM1.129 ; v1(48.19,71.44) 48.68,70.95 JDIM1.159 ; 59.88,55.08 59.73,54.93 59.73,53.43 59.5,53.2 JDIM1.96 ; JDIM1.148 59.64,68.2 60.39,68.95 ; JDIM1.135 47.03,62.95 46.62,62.55 v1(46.62,62.44) ; 60.01,64.63 59.93,64.7 JDIM1.142 ; JDIM1.112 59.97,57.2 ; 59.93,69.68 59.91,69.7 JDIM1.154 ; JDIM1.147 49.13,67.95 48.78,67.6 48.78,67.17 48.28,66.67 v1(48.23,66.67) ; JDIM1.75 49.15,47.95 48.7,47.51 v1(48.7,47.31) ; JDIM1.111 48.73,56.95 v1(48.7,56.93) ; v1(48.78,72.4) 49.23,71.95 JDIM1.163 ; v2(80.43,74.79) 80.73,75.09 U24.N36 ; v1(48.78,37.5) 48.83,37.45 JDIM1.33 ; v1(48.78,69.71) 49.03,69.46 JDIM1.153 ; JDIM1.12 56.2,32.2 54.23,34.17 54.23,34.59 53.33,35.49 52.95,35.49 v1(52.64,35.8) ; v1(48.77,80.5) 49.22,80.95 JDIM1.199 ; v1(48.58,59.19) 48.58,59.55 48.98,59.95 JDIM1.123 ; 59.85,63.2 JDIM1.136 ; JDIM1.141 49.26,64.46 47.79,65.92 v1(47.79,66.22) ; 60.1,61.7 JDIM1.130 ; 59.76,60.2 JDIM1.124 ; v1(55.69,87.16) 55.69,86.83 56.31,86.21 JDIM1.220 ; 59.97,58.7 JDIM1.118 ; JDIM1.117 48.43,58.46 47.94,58.94 v1(47.94,59.19) ; JDIM1.178 57.43,75.7 57.24,75.89 56.29,75.89 56.16,76.02 55.63,76.02 55.57,75.96 v1(53.92,75.96)
  vias: v1(22.39,99.53) v1(22.59,98.92) v1(22.85,99.99) v1(23.05,99.38) v1(23.23,98.77) v1(23.33,100.47) v1(23.51,99.86) v1(23.68,99.22) v1(23.79,100.93) v1(23.96,100.32) v1(24.14,99.68) v1(24.42,100.77) v1(39.43,69.2) v1(40.19,69.2) v1(41.31,65.47) v1(41.82,65.09) v1(42.33,65.47) v1(42.84,65.09) v1(43.32,69.53) v1(43.34,65.47) v1(43.93,69.3) v1(43.85,65.09) v1(44.38,69.76) v1(44.36,65.47) v1(44.87,65.09) v1(44.99,69.99) v1(45.38,65.47) v1(45.53,95.36) v1(45.63,70.09) v1(45.87,70.93) v1(45.88,65.09) v1(45.99,67.12) v1(46.16,95.36) v1(46.26,70.09) v1(46.42,68.97) v1(46.39,65.47) v1(46.61,120.76) v1(46.8,95.36) v1(46.92,121.32) v1(46.87,70.73) v1(46.9,70.09) v1(46.9,65.09) v1(47.24,120.76) v1(47.43,95.36) v1(47.41,65.47) v1(47.51,70.78) v1(47.56,121.32) v1(47.56,71.41) v1(47.71,75.14) v1(47.88,120.76) v1(47.97,80.5) v1(48.04,79.87) v1(48.19,121.32) v1(48.17,75.6) v1(48.22,72.07) v1(48.32,82.49) v1(48.32,76.24) v1(48.32,69.25) v1(48.51,120.76) v1(48.58,87.87) v1(48.58,48.91) v1(48.58,44.33) v1(48.7,91.22) v1(48.68,51.85) v1(48.83,121.32) v1(48.78,85.91) v1(48.78,73.04) v1(48.78,45.35) v1(48.86,82.92) v1(48.96,88.38) v1(49.15,120.76) v1(49.46,121.32) v1(63.23,92.05) v1(63.51,92.69) v1(63.87,92.05) v1(64.15,92.69) v1(64.5,92.04) v1(64.78,92.67) v1(65.14,92.05) v1(66.86,94.88) v2(81.47,69.01) v2(81.47,68.38) v2(81.47,67.74) v2(81.47,67.11) v2(81.47,66.47) v2(81.47,65.84) v2(81.47,65.2) v2(81.47,64.57) v2(81.47,63.93) v2(81.47,63.3) v2(81.47,62.66) v2(81.47,62.03) v2(81.47,61.39) v2(81.47,60.76) v2(81.47,60.12) v2(81.47,59.49) v2(81.47,58.85) v2(81.47,58.22) v2(81.47,57.58) v2(81.47,57) v2(81.47,56.4) v2(81.47,55.82) v4(54.23,121.22) v4(54.23,120.41) v4(55.08,121.22) v4(55.08,120.41) v4(55.92,121.21) v4(55.92,120.41) v4(56.68,121.17) v4(56.7,120.38)
+1.5V: length 84.8
  TOP w0.381: v2(203.03,20.64) 205.83,20.64 206.68,21.49 207.36,21.49 ; R373.2 202.63,25.64 202.93,25.34 203.79,25.34 204.58,24.55 206.88,24.55 207.32,24.12 v1(207.32,23.51) 207.32,23.24 207.58,22.97 207.58,21.7 207.36,21.49 ; 207.36,21.49 207.85,21.49 208.34,20.99 208.34,19.39 208.8,18.93 v2(209.13,18.93)
  IN1 w0.508: v2(200.04,19.04) 199.55,19.04 199.09,18.57 197.46,18.57 196.81,19.23 v2(196.81,19.24)
  IN2 w0.381: v1(211.57,37.45) 211.16,37.04 211.16,34.48 211.85,33.79 212.69,33.79 213.96,32.52 214.41,32.52 215.23,31.71 215.23,31.08 215.96,30.34 215.96,25.89 213.43,23.36 213.43,20.42 212.79,19.77 210.15,19.77 209.31,18.93 v2(209.13,18.93)
  IN2 w0.508: v2(200.04,19.04) 200.95,19.95 202.35,19.95 v2(203.03,20.64)
  IN3 w0.508: v2(169.18,23.7) 169.46,23.42 171.25,23.42 171.29,23.46 172.11,23.46 173.46,24.8 179.18,24.8 179.41,24.58 185.25,24.58 185.6,24.93 189.34,24.93 189.57,24.7 190.18,24.7 191.39,23.49 192.98,23.49 193.99,22.49 195.13,22.49 196.28,21.34 196.28,19.93 196.81,19.39 v2(196.81,19.24)
  BOTTOM w0.381: v1(211.57,37.45) 211.54,37.43 R690.1
  BOTTOM w0.508: Q45.2 199.51,19.48 199.96,19.04 v2(200.04,19.04)
  vias: v1(168.84,23.13) v2(168.59,23.7)
+1.05V_EXT: length 3.3
  TOP w0.203: R277.1 92.21,38.29 v1(92.16,38.34) 91.81,38.34 91.58,38.11 90.9,38.11 90.5,37.7 v2(90.49,37.7)
  BOTTOM w0.203: v2(90.49,37.7) 90.81,38.02 U24.DJ15
+1.05V_LAN: length 3.5
  TOP w0.203: U1.30 44.04,108.44
  TOP w0.508: v1(43.5,110.73) 43.76,110.47 C39.1 C45.1 44.04,108.8 44.04,108.44
  vias: v1(38.78,102.57) v1(39.74,115.53) v1(40.17,114.29) v1(40.45,113.65) v1(40.96,114.03) v1(48.96,108.01)
+1.05V_LAN_REGOUT:
  vias: v1(43.5,114.49) v1(43.7,115.1) v1(44.18,114.49) v1(47.56,108.72)
+1.8V: length 290.6
  TOP w0.381: v2(201.38,28.66) 201.32,28.6 R360.2
  TOP w0.508: v2(207.25,19.44) 207.48,19.44 207.76,19.72 207.76,20.71 207.58,20.89 206.92,20.89 206.03,20 204.99,20 204.74,19.75 v1(204.16,19.75) 204.16,19.65 203.23,18.72 202.18,18.72 201.86,18.4 v2(201.86,18.27) ; PQ10.1 25.57,33.03 26.73,31.86 v1(26.81,31.86) ; R313.1 213.51,31.85 213.02,31.36 v2(212.08,31.36) ; v1(14.06,20.28) 15,21.22 18.83,21.22 19.75,20.31 21.2,20.31 22.16,19.34 23.3,19.34 23.94,19.98 23.94,20.2 v2(24.93,21.2)
  IN1 w0.508: v2(212.08,31.36) 211.67,31.36 211.03,30.72 211.03,28.89 211.75,28.18 211.75,26.22 211.42,25.89 210.12,25.89 209.21,26.81 209.21,28.13 208.39,28.94 208.39,29.2 207.86,29.73 203.31,29.73 202.06,28.48 201.57,28.48 v2(201.38,28.66)
  IN2 w0.508: v2(155.89,17) 156.27,17 156.78,16.5 172.45,16.5 173.32,17.36 173.95,17.36 174.18,17.13 177.59,17.13 178.18,17.73 183.03,17.73 184.44,16.32 184.95,16.32 185.88,15.39 190.46,15.39 191.21,14.64 196.3,14.64 198.87,17.21 200.29,17.21 200.65,17.56 200.65,17.82 201.1,18.27 v2(201.86,18.27) ; v2(207.25,19.44) 207.53,19.44 207.96,19.87 209.13,19.87 209.64,20.38 212.48,20.38 212.86,20.76 212.86,24.62 213.75,25.51 213.75,30.21 212.61,31.36 v2(212.08,31.36) ; v1(113.17,17.94) 113.17,17.46 112.51,16.81 111.29,16.81 111.08,17.02 110.01,17.02 108.68,15.7 98.93,15.7 98.44,16.19 95.29,16.19 94.89,16.58 93.11,16.58 91.27,14.74 91.27,13.56 88.27,10.56 84.12,10.56 80.94,13.74 80.94,14.44 80.3,15.07 74.8,15.07 74.64,14.91 62.19,14.91 60.74,16.37 58.21,16.37 57.18,15.34 56.46,15.34 53.78,18.02 50.26,18.02 49.65,17.41 42.99,17.41 40.83,15.25 38.54,15.25 38.03,15.76 38.03,15.86 37.15,16.75 33.62,16.75 32.27,18.1 32.27,22.39 31.3,23.35 31.25,23.35 28.64,25.97 27.87,25.97 26.87,26.97 26.87,31.72 26.81,31.79 v1(26.81,31.86)
  IN3 w0.508: v2(24.93,21.2) 24.93,21.93 25.61,22.62 25.61,28.84 26.81,30.03 v1(26.81,31.86) ; 124.27,17.36 124.67,17.77 126.26,17.77 127.68,19.19 129.7,19.19 131.25,17.64 136.84,17.64 137.6,18.4 142.39,18.4 144.81,15.98 154.49,15.98 155.36,16.85 155.61,16.85 155.76,17 v2(155.89,17) ; 122.85,16.9 122.74,16.79 122.01,16.79 120.91,17.89 113.22,17.89 v1(113.17,17.94)
  BOTTOM w0.102: v1(13.18,18.61) R818.1
  BOTTOM w0.254: R808.1 24.19,20.46 v2(24.93,21.2)
  BOTTOM w0.508: R818.1 13.37,19.59 v1(14.06,20.28) ; PR238.1 22.81,36.43 23.12,36.74 23.63,36.74 25.16,35.22 25.16,33.44 26.73,31.86 v1(26.81,31.86)
+1.8V_DEEP_SUS: length 246.7
  TOP w0.203: v1(107.28,49.64) 106.61,48.98 104.68,48.98 102.73,50.94 101.4,50.94 100.08,52.26 97.8,52.26 97.62,52.44 97.61,52.44 94.92,55.13 94.17,55.13 92.79,56.51 v1(92.56,56.51) ; R353.1 86.93,28.61 87.45,28.09 87.45,28.07 v2(87.67,27.85) ; v1(67.78,41.39) 67.68,41.29 67.68,41.09 67.3,40.71 66.48,40.71 66.26,40.93 R266.1 66.02,40.61 65.78,40.37 65.69,40.37 R269.1
  TOP w0.254: v2(146.1,24.24) 146.1,24.61 145.12,25.59 145.12,26.3 144.82,26.61 144.82,27.01 145.05,27.24 145.05,27.77 145.58,28.31 U12.5
  IN1 w0.254: v2(195.51,23.61) 195.49,23.61 195.29,23.4 195.29,21.84 v2(195.08,21.64)
  IN2 w0.508: v1(91.88,27.42) 91.73,27.57 v2(89.04,27.57) 88.76,27.85 v2(87.67,27.85) ; v1(96.07,25.39) 97.14,26.45 97.14,27.01 97.34,27.21 99.97,27.21 100.12,27.37 106.19,27.37 107.59,28.76 108.17,28.76 108.62,29.22 v1(108.65,29.22)
  IN3 w0.203: v1(92.56,56.51) 91.71,56.51 90.05,54.85 81.98,54.85 81.02,53.9 81.02,50.85 79.94,49.77 76.2,49.77 75.16,48.73 75.16,48.71 74.46,48.01 74.46,46.9 74.03,46.47 71.94,46.47 69.78,44.31 69.78,43.17 69.09,42.47 68.86,42.47 v1(67.78,41.39)
  IN3 w0.254: v2(146.1,24.24) 146.15,24.24 147.33,25.42 153.32,25.42 153.86,24.88 155.7,24.88 156.38,24.2 158.12,24.2 158.24,24.08 165.13,24.08 165.92,23.29 168.38,23.29 168.72,22.95 169.01,22.95 169.18,22.78 171.51,22.78 171.55,22.82 172.38,22.82 173.5,23.94 177.03,23.94 177.8,23.18 180.73,23.18 181.5,23.94 185.51,23.94 185.86,24.29 188.28,24.29 189.08,23.49 190.49,23.49 191.12,22.86 192.72,22.86 193.23,22.35 193.23,20.93 193.58,20.57 195.25,20.57 195.49,20.81 195.49,21.23 v2(195.08,21.64)
  IN3 w0.508: v1(108.65,29.22) 109.8,29.22 111.54,30.96 111.54,33.84 111.68,33.97 111.68,36.05 111.19,36.54 111.19,37.94 110.48,38.65 110.48,42.4 110.32,42.56 110.32,44.07 109.41,44.98 109.41,46.6 109.13,46.87 109.13,48.7 108.19,49.64 v1(107.28,49.64) ; v1(93.43,15.96) 93.43,17.74 96.45,20.76 96.45,25.01 v1(96.07,25.39) 95.82,25.64 95.82,26.02 95.31,26.53 92.52,26.53 91.88,27.16 v1(91.88,27.42)
  BOTTOM w0.203: R750.1 89.03,27.57 v2(89.04,27.57) 89.5,28.03 R747.1 ; v2(195.51,23.61) 195.44,23.54 R786.1 ; R799.1 195.16,21.72 v2(195.08,21.64)
  BOTTOM w0.254: U24.DD35 81.25,40.31 v2(81.54,40.02) 81.9,39.66 U24.DF34
  BOTTOM w0.381: v1(91.88,27.42) 91.64,27.66 R748.2
  BOTTOM w0.508: v1(93.43,15.96) 93.43,15.15 94.8,13.78 113.78,13.78 114.41,14.41 118.12,14.41 118.76,13.78 125.28,13.78 125.88,14.37 125.88,15.51 126.1,15.73 127.2,15.73 127.51,15.43 137.43,15.43 137.73,15.73 139.1,15.73 140.07,14.77 147.03,14.77 148.37,16.12 v2(148.37,18.78)
  vias: v1(99.5,41.79) v1(100.14,41.79) v1(100.77,41.79) v1(107.25,50.28) v1(146.26,23.61) v2(88.71,38.99) v2(88.79,39.62) v2(89.57,39.61)
+1.8V_S5: length 107.5
  IN2 w0.381: v1(143.95,36.77) 143.95,37.12 144.08,37.25 144.08,38.14 143.24,38.98 141.54,38.98 141.08,38.52 137.15,38.52 136.92,38.28 123.41,38.28 121.12,35.99 118.41,35.99 117.53,35.11 114.5,35.11 112.65,36.97 112.65,37.92 112.33,38.24 109.99,38.24 109.94,38.19 106.95,38.19 106.56,37.81 102.8,37.81 102.5,37.5 v1(102.5,36.33)
  IN3 w0.254: 27.62,28.94 27.11,28.43 27.11,26.02 26.86,25.77 26.86,22.59 25.72,21.45 25.72,20.31 v2(25.84,20.18)
  IN3 w0.381: v1(159.47,33.44) 158.94,33.97 154.85,33.97 154.3,34.53 148.65,34.53 148.27,34.91 147,34.91 146.43,34.34 146.43,33.96 145.6,33.13 144.71,33.13
  BOTTOM w0.254: v2(25.84,20.18) 25.45,20.57 R809.1
  BOTTOM w0.381: v1(159.47,33.44) 159.47,32.98 159.2,32.71 159.2,31.98 159.83,31.36 162.9,31.36 164.6,29.65 165.87,29.65 167.98,31.76 169.2,31.76 169.58,31.38 169.58,30.19 168.38,28.99 168.38,26.93 168.1,26.64 168.1,25.26 168.35,25.01 170.94,25.01 172.31,23.63 172.99,23.63 173.48,23.14 176.66,23.14 177,22.8 177,21.98 177.51,21.47 R803.1
  vias: v1(19.75,90.66) v1(20.25,91.43) v1(20.41,90.79) v1(20.89,91.3) v1(21.52,91.3) v1(23.23,26.58) v1(24.27,92.06) v1(24.27,91.43) v1(28.38,30.21) v1(28.38,29.58) v1(28.38,28.94) v1(28.54,31.79) v1(29.02,30.85) v1(29.02,30.21) v1(29.02,29.58) v1(29.02,28.94) v1(105.95,30.06) v1(106.31,30.59) v1(106.59,29.93)
+1.8V_SW: length 34.1
  IN2 w0.508: 12.59,20.28 v2(12.59,20.25) ; 12.59,20.28 11.93,20.28 11.01,21.2 11.01,22.69 11.96,23.65 13.41,23.65 14.64,24.88 v2(14.9,24.88) ; 12.59,20.28 12.61,20.3 12.61,20.86 13.08,21.32 16.9,21.32 17.16,21.07 18.17,21.07 18.6,20.64 v1(18.6,19.16)
  BOTTOM w0.203: 15.58,21.98 15.94,22.34 U34.12 ; R824.2 17.28,18.55 18.35,18.55 18.55,18.76 18.55,19.11 v1(18.6,19.16) 19.01,18.76 19.01,18.73 19.18,18.56 R822.2
  BOTTOM w0.508: R773.2 20.65,25.45 20.27,25.82 ; 15.66,26.3 15.66,26.63 16.19,27.16 18.22,27.16 18.86,26.53 19.34,26.53 ; 15.58,21.98 14.63,21.03 C692.1 C691.1 C690.1 11.24,21.03 EC8.1 11.24,20.34 R818.2 11.98,19.62 12.59,20.23 v2(12.59,20.25)
  vias: v1(15.23,26.15)
+1.35V_GFX: length 38.9
  TOP w0.356: C175.2 131.28,86.34 v2(131.41,86.21) ; C174.2 128.16,87.12 v2(128.2,87.16) ; v2(131.41,113.4) 131.68,113.66 C26.2 ; v2(138.61,86.21) 138.48,86.33 C172.2
  TOP w0.381: C165.1 128.2,90.24 v2(128.22,90.22) ; C134.2 108.81,97.58 v2(108.75,97.52) ; C166.2 132.04,91.63 v2(132.21,91.81) ; C126.2 107.35,98.49 v2(107.35,98.21) ; v2(131.41,92.61) 131.38,92.58 C163.2
  TOP w0.457: C157.2 121.23,93.93 ; C52.2 129.97,108.82 130.01,108.85 v2(130.01,109.49) ; C158.2 122.58,93.93 v1(122.57,93.94)
  BOTTOM w0.254: v2(112.13,96.73) 112.13,96.63 U22.E23 ; v2(116.14,99.25) 116.14,99.17 115.71,98.74 114.96,98.74 U22.H26 ; v2(113.73,98.37) U22.H24 ; VRAM1.L14 135.02,105.8 v2(135.41,105.41) 135.81,105.8 VRAM1.M14 ; v2(114.52,96.7) U22.E26
  BOTTOM w0.305: v2(114.51,93.41) 114.89,93.83 U22.B26 ; U22.L26 115.09,101.41 115.81,101.41 116.14,101.08 v2(116.14,100.87) ; v2(112.93,100.86) 112.94,100.86 U22.L24
  BOTTOM w0.33: VRAM2.P3 129.42,85 v2(129.81,85.38) ; VRAM1.B12 127.81,107.41 v2(127.41,107.81) ; VRAM1.F14 131.4,105.41 v2(131.41,105.41) ; VRAM1.D14 129.41,105.8 v2(129.01,105.41) ; VRAM2.M1 131.02,83.4 v2(131.41,83.01) ; v2(129.01,83.01) 129.41,83.4 VRAM2.P1 ; VRAM2.N5 130.21,87.01 v2(130.01,87.21) ; v2(134.61,92.61) 134.21,92.21 VRAM2.H12 ; v2(128.2,87.16) 128.2,87.01 128.61,86.61 VRAM2.R5 ; VRAM1.B14 127.81,105.8 v2(127.41,105.41) ; VRAM2.M3 131.01,85 v2(131.41,85.41) 131.42,85.41 VRAM2.L4 ; VRAM1.C10 128.99,108.62 v2(129.01,108.62) 129.01,108.61 129.41,108.21 VRAM1.D11 129.41,108.2 v2(129.01,107.81) 129.01,107.8 VRAM1.D12 ; v2(128.2,85.38) 127.82,85 VRAM2.T3 ; VRAM2.L2 131.81,84.2 v2(131.41,83.81) ; VRAM1.H12 VRAM1.G13 ; v2(127.41,83.01) 127.81,83.4 VRAM2.T1 ; VRAM2.B3 139.02,85 v2(139.41,84.61) ; VRAM1.L13 VRAM1.M12
  BOTTOM w0.356: VRAM1.K12 134.21,107.41 v2(134.61,107.81) ; VRAM1.G13 VRAM1.F12 131.01,107.4 v2(131.41,107.81) 131.81,108.2 VRAM1.G11 ; VRAM1.E10 130.21,109.26 130.01,109.46 v2(130.01,109.49)
  BOTTOM w0.381: U22.C25 114.14,94.63 v2(114.52,95.01)
  BOTTOM w0.457: 125.91,93.2 124.66,93.2 123.91,93.94 v1(122.57,93.94) v1(121.22,93.94)
  vias: v1(129.04,104.68) v1(129.98,101.33) v1(130.62,101.33) v1(131.25,101.33) v1(131.89,101.33) v1(140.55,82.46) v1(140.55,81.8) v1(141.21,84.77) v1(141.21,84.06) v1(141.21,83.43) v1(141.24,82.76) v1(141.24,82.05) v1(141.24,81.42) v1(141.51,99.86) v1(141.9,83.91) v1(141.9,83.22) v1(141.9,82.59) v1(141.92,81.9) v1(141.92,81.22) v2(104.65,97.46) v2(104.65,96.64) v2(109.49,97.47) v2(110.35,99.05) v2(111.31,107.43) v2(111.28,105.83) v2(111.28,105.03) v2(111.29,104.24) v2(111.29,100.83) v2(111.29,100.01) v2(111.29,99.19) v2(111.36,101.66) v2(127.41,114.99) v2(128.21,116.61) v2(128.21,93.41) v2(128.21,91.81) v2(129.01,116.61) v2(129.01,94.21) v2(129.81,114.21) v2(129.82,91.81) v2(130.61,114.99) v2(130.61,112.62) v2(130.61,90.22) v2(131.41,115.81) v2(131.41,114.99) v2(131.41,106.16) v2(131.41,94.21) v2(131.41,93.41) v2(131.41,91.01) v2(132.21,114.99) v2(132.21,83.01) v2(133.01,83.81) v2(133.01,83.01) v2(133.81,87.01) v2(134.61,115.81) v2(134.61,91.81) v2(134.61,86.21) v2(134.61,85.41) v2(134.61,83.81) v2(134.61,83.01) v2(135.41,115.81) v2(135.41,114.21) v2(135.41,94.21) v2(135.41,91.01) v2(135.41,83.01) v2(136.21,112.61) v2(136.21,109.41) v2(136.21,107.8) v2(136.21,92.61) v2(136.21,91.01) v2(136.21,87.01) v2(137.01,116.61) v2(137.01,106.16) v2(137.01,94.21) v2(137.01,92.61) v2(137.01,85.41) v2(137.01,83.01) v2(137.81,114.21) v2(137.81,113.41) v2(137.81,108.61) v2(137.81,107.81) v2(137.81,91.01) v2(137.81,90.21) v2(138.61,116.61) v2(138.61,108.61) v2(138.61,106.21) v2(138.61,105.41) v2(138.61,92.61) v2(138.61,91.81) v2(138.61,91.01) v2(138.61,83.81) v2(138.61,83.01) v2(139.41,114.21) v2(139.41,107.01) v2(139.41,94.21) v2(139.41,91.81) v2(139.41,90.21) v2(140.21,86.21)
+1V8_AON: length 276.2
  TOP w0.203: 173.42,31.61 173.42,31.13 172.89,30.6 R341.2 172.89,29.88 173.29,29.48 v2(173.29,29.04) ; 173.42,31.61 173.54,31.74 Q15.5 ; 173.42,31.61 173.29,31.74 Q15.2 171.63,31.74 171.38,31.49 171.38,30.85 171.58,30.65 R340.2
  TOP w0.254: PR14.1 71.31,115.02 71.26,114.97 v2(71.26,114.77)
  TOP w0.381: R2.2 101.47,124.07 101.62,123.91 102.73,123.91 103.09,123.55 104.9,123.55 v1(105.42,124.07) ; R50.2 R56.2 87.56,98 v1(87.08,97.52)
  TOP w0.508: R60.2 84.94,96.86 v1(84.21,96.86) ; R479.2 201.1,12.69 v2(201.1,12.2) 201.1,12 200.82,11.71 Q25.2
  IN1 w0.254: v1(87.08,97.52) 87.08,99.24 83.14,103.17 75.82,103.17 74.11,104.88 74.11,105.27 72.85,106.53 72.34,106.53 71.66,107.2 69.7,107.2 68.71,108.2 68.71,110.26 69.19,110.74 69.19,113.59 70.22,114.62 71.11,114.62 v2(71.26,114.77)
  IN1 w0.381: 100.01,99.07 99.86,99.07 99.12,99.81 99.12,103.87 99.78,104.53 100.25,104.53 100.73,105.02 100.73,109.04 101.29,109.6 101.29,117.47 99.76,119.01 v1(99.76,120.26)
  IN1 w0.508: v2(198.82,15.28) 201.1,12.99 v2(201.1,12.2)
  IN1 w1.016: 61.02,99.17 61.17,99.03 66.61,99.03 67.05,98.59 70.88,98.59 70.9,98.61 ; 26.6,96.76 26.6,98.51 27.58,99.48 29.9,99.48 30.97,98.41 44.89,98.41
  IN2 w0.381: v1(98,122.26) 98.03,122.24 99.33,122.24 102.02,124.93 104.99,124.93 105.42,124.5 v1(105.42,124.07)
  IN3 w0.203: 173.04,28.35 173.29,28.61 v2(173.29,29.04)
  IN3 w0.254: 173.04,28.35 173.2,28.19 179.23,28.19 179.83,27.59 183.15,27.59 183.86,28.31 186.08,28.31 186.95,27.44 190,27.44 190.18,27.27 190.18,26.4 191.29,25.29 192.91,25.29 193.19,25.01 193.19,24.67 193.98,23.88 193.98,23.39 194.25,23.13 195.39,23.13 196.35,22.17 197.01,22.17 197.39,22.55 198.14,22.55 198.36,22.34 198.36,15.73 v2(198.82,15.28)
  IN3 w0.508: 173.04,28.35 171.05,28.35 170.81,28.1 167.35,28.1 166.94,27.69 165.18,27.69 164.53,27.04 161.17,27.04 160.65,27.56 159.37,27.56 158.79,28.14 157.71,28.14 157.27,28.59 156.26,28.59 155.65,29.2 154.32,29.2 153.73,29.79 151.44,29.79 150.91,30.33 147.79,30.33 146.88,29.42 142.28,29.42 139.59,32.12 137.81,32.12 135.98,33.94 135.98,35.08 132.44,38.63 129.56,38.63 126.93,41.25 126.93,47.95 124.55,50.33 117.36,50.33 116.24,51.45 116.24,53.07 115.89,53.43 115.89,57.77 114.62,59.04 114.36,59.04 113.73,59.68 113.73,61.28 114.95,62.5 114.95,66.46 113.98,67.42 113.98,75.78 110.58,79.18 110.58,85 107.88,87.69 v2(107.88,87.74)
  BOTTOM w0.203: PR148.2 77.19,101.83 77.19,101.68 77.4,101.46 77.4,99.55 v1(76.77,98.92)
  BOTTOM w0.356: v2(102.22,97.75) 102.4,97.75 102.68,98.03 103.23,98.03 U22.G12 ; U22.G10 v2(101.32,97.48)
  BOTTOM w0.508: R568.2 109.37,88.25 108.86,87.74 v2(107.88,87.74)
  vias: v1(26.14,95.92) v1(26.4,98.41) v1(26.78,95.92) v1(83.83,96.33) v1(86.17,96.71) v1(98.44,86.73) v1(98.44,86.09) v2(102.17,98.41)
