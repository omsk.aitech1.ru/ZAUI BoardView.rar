# Allegro board dazauimb8c0-c-eva-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ADP_ID: length 196.5
  TOP w0.102: v1(127.49,34.12) v1(128.57,35.2) 129.39,36.02 PR71.2 131.46,36.02 PR69.1 132.3,36.87 133.44,36.87 134.22,36.08 PQ9.2
  IN2 w0.089: PJ6.3 17.88,114.45 18.1,114.67 25.08,114.67 25.51,115.1 34.28,115.1 34.76,115.58 41.62,115.58 42.23,116.19 42.23,117.46 43.93,119.16 51.02,119.16 51.65,119.79 59.83,119.79 60.54,119.09 60.54,117.31 62.16,115.68 62.8,115.68 68.01,110.48 68.01,107.56 70.67,104.89 74.94,104.89 75.57,104.25 76.52,104.25 77.4,103.36 82.61,103.36 84.77,101.21 87.44,101.21 88.33,100.32 89.6,100.32 91.5,98.41 91.5,93.03 91.34,92.87 91.34,91.35 91.5,91.19 ; 104.96,80.38 108.54,80.38 109.48,79.44 109.48,75.98 108.62,75.13 107.2,75.13 107.07,75 107.07,68.92 108.49,67.49 108.49,65.87 110.99,63.38 110.99,56.52 113.83,53.68 114.14,53.68 v1(114.23,53.58)
  IN2 w0.102: 104.96,80.38 104.46,80.89 99.92,80.89 94.45,86.36 94.45,88.25 91.5,91.19
  IN3 w0.089: v1(127.49,34.12) 127.49,34.86 123.23,39.13 123.23,46.19 120.98,48.44 116.41,48.44 114.99,49.86 114.99,52.57 114.23,53.33 v1(114.23,53.58)
ALERT: length 16.1
  TOP w0.102: R56.1 88.41,98.11 89.88,98.11 v1(90.13,97.85) 90.68,97.85 93.47,100.65 94.04,100.65 96.28,98.41 96.28,97.79 96.95,97.12 97.34,97.12 97.52,97.29 97.52,97.83 97.85,98.16 98.98,98.16 v2(99.62,97.52)
  BOTTOM w0.102: U22.F8 v2(99.62,97.52)
AMP_MUTE#: length 14.4
  TOP w0.102: v2(191.93,27.8) 192.09,27.8 192.85,28.56 U13.108
  IN1 w0.089: v2(191.93,27.8) 191.96,27.8 192.85,26.91 193.86,26.91 195.39,25.39 195.39,24.88 196.82,23.44 197.76,23.44 198.16,23.84 199.86,23.84 v2(200.04,24.01)
  BOTTOM w0.102: v2(200.04,24.01) 200.04,24.57 200.62,25.16 D36.1
AP_EQ: length 3
  BOTTOM w0.102: R824.1 R817.2 16.73,20.53 v1(16.7,20.56) 17.3,21.16 U34.9
AUX_PWRGD: length 0.8
  BOTTOM w0.203: TP78.1 143.64,41.71 PR227.1
BAT-V: length 27.5
  TOP w0.254: PD4.1 126.1,31 v2(126.1,30.52)
  IN2 w0.254: v2(126.1,30.52) 126.04,30.57 125.9,30.57 124.26,28.93 v2(111.54,28.93)
  BOTTOM w0.152: PR266.2 111.21,27.01 111.43,26.8 111.43,25.14 112.2,24.37 PR271.2
  vias: v1(108.88,24.45)
BATLED0#: length 52.1
  TOP w0.102: v2(192.52,21.7) 192.52,21.67 190.67,19.82 188.35,19.82 187.26,18.73 184.71,18.73 184.36,18.38 184.36,17.49 184.13,17.26 184.13,17.16 183.95,16.98 U13.29
  IN1 w0.089: v2(206.36,26.07) 206.41,26.02 206.74,26.02 207.69,25.06 208.63,25.06 209.4,24.29 213,24.29 214.84,26.13 214.84,29.87 215.42,30.44 215.42,31.85 215.86,32.29 215.86,33.23 214.18,34.91 213.33,34.91 v2(212.15,36.09)
  IN2 w0.089: v2(192.52,21.7) 192.82,21.7 193.03,21.91 193.63,21.91 194.21,22.48 195.23,22.48 195.62,22.1 196.81,22.1 197.47,22.76 197.75,22.76 198.59,23.6 201.15,23.6 202.64,25.09 203.58,25.09 204.38,25.89 205.14,25.89 205.55,25.49 205.85,25.49 206.36,26 v2(206.36,26.07)
  BOTTOM w0.102: v2(212.15,36.09) 212.47,36.4 CN6.24
BATLED1#: length 54
  TOP w0.102: U13.25 183.92,18.58 184.52,19.19 185.32,19.19 arc(185.32,19.19) 185.32,19.19 187.07,19.19 188.16,20.28 189.95,20.28 v2(191.93,22.26) ; v2(212.17,36.69) 211.56,36.69 v1(211.49,36.77)
  IN1 w0.089: v2(206.34,26.66) 206.39,26.61 206.79,26.61 207.19,26.21 207.19,25.86 207.79,25.25 208.71,25.25 209.48,24.48 212.92,24.48 214.65,26.21 214.65,29.95 215.23,30.52 215.23,31.94 215.66,32.37 215.66,33.06 214.44,34.28 213.12,34.28 211.72,35.67 211.72,36.44 211.98,36.69 v2(212.17,36.69)
  IN2 w0.089: v2(191.93,22.26) 192.34,22.67 193.85,22.67 194.05,22.87 195.74,22.87 196.02,23.15 197.6,23.15 199.06,24.61 201.04,24.61 201.18,24.47 201.48,24.47 202.75,25.74 202.75,27.16 203.13,27.55 204.15,27.55 204.66,27.04 206.03,27.04 206.34,26.73 v2(206.34,26.66)
  BOTTOM w0.102: v2(212.17,36.69) 212.38,36.9 CN6.23
BATLOW#: length 19.1
  TOP w0.102: v2(73.75,38.57) 73.75,38.45 73.44,38.14 72.13,38.14 71.54,37.55 71.54,35.83 69.43,33.72 69.43,32.72 66.84,30.12 66.84,29.47 66.56,29.2 66.56,25.31 66.84,25.03 R397.1
  BOTTOM w0.102: v2(73.75,38.57) 73.89,38.43 74.68,38.43 U24.DH48
BI: length 131
  TOP w0.102: v2(99.45,20.18) 100.01,20.18 100.21,20.38 v1(100.21,20.59) 100.21,20.74 100.01,20.94 PR112.1
  IN2 w0.089: v1(78.19,15.71) 77.99,15.91 74.76,15.91 74.17,15.31 63.93,15.31 60.66,18.59 58.24,18.59 57.12,19.71 55.38,19.71 54.12,18.45 48.59,18.45 46.06,20.98 46.06,22.14 45.69,22.5 40.75,22.5 39.9,23.35 39.9,23.98 38.4,25.48 29.79,25.48 28.87,26.4 28.03,26.4 27.28,27.14 27.28,32.78 23.79,36.27 23.79,49.8 24.4,50.4 24.4,50.84 24.98,51.42 v1(25.01,51.42)
  IN3 w0.089: v1(78.19,15.71) 79.34,15.71 80.55,14.49 80.55,13.17 82.94,10.78 88.96,10.78 93.73,15.55 95.36,15.55 99.43,19.62 99.43,20.16 v2(99.45,20.18)
  BOTTOM w0.102: SW3.2 SW3.1 21.25,58.87 19.85,57.46 R622.1 22.86,57.26 25.08,55.05 25.08,51.49 v1(25.01,51.42) ; v2(99.45,20.18) 99.45,20.2 99.45,20.21 PJ11.6
BIOS_WP#: length 6.3
  TOP w0.102: v2(162.01,27.85) 162.44,28.28 163.35,28.28 R363.2 164.54,29.47 R351.1 164.81,29.65 165.31,30.16 v1(165.31,30.33)
  BOTTOM w0.102: v2(162.01,27.85) 162.01,27.32 162.16,27.16 U33.3
BL#: length 17.2
  TOP w0.102: 56.58,101.21 56.73,101.05 57.08,101.05 57.23,101.19 Q4.3 ; 56.58,101.21 Q4.2 ; 56.58,101.21 56.55,101.21 55.38,100.04 53.78,100.04 53.66,100.16 v1(53.66,101.54) 53.5,101.69 51.89,101.69 51.42,102.15 51.42,103.35 51.76,103.69 53.67,103.69 54.14,104.17 54.14,105.4 53.68,105.86 53.68,106.26 53.46,106.48 53.06,106.48 52.63,106.91 R24.1
BL_ON: length 20.9
  TOP w0.102: R13.1 60.56,111.44 Q3.3 58.39,110.64 57.47,109.71 57.34,109.71 57.21,109.59 57.21,108.06 56.89,107.74 56.89,106.59 56.7,106.41 56.26,106.41 v2(56.05,106.21) 56.05,106.19 55.48,105.62 55.48,105.1 55.51,105.06 55.51,104.43 55.93,104.01 Q4.6 ; v1(52.26,102.86) 52.89,102.86 53.16,102.59 D1.2
  IN2 w0.089: v1(52.26,102.86) 52.26,103.17 54.54,105.45 55.3,105.45 v2(56.05,106.21)
  BOTTOM w0.102: CN2.26 56.35,106.51 v2(56.05,106.21)
BOARD_ID0: length 20
  BOTTOM w0.076: U24.CC45 76.09,50.61 76.01,50.53
  BOTTOM w0.079: 76.01,50.53 75.75,50.28 75.47,50.28 75.37,50.38 73.52,50.38 73.21,50.07 72.4,50.07 71.11,48.78 70.7,48.78 69,47.08 68.64,47.08
  BOTTOM w0.102: 68.64,47.08 65.79,47.08 65.69,47.18 64.55,47.18 63.98,47.75 63.98,49 64.27,49.29 64.27,50.33 63.96,50.64 62.96,50.64 R640.2 R639.1
BOARD_ID1: length 20.4
  BOTTOM w0.079: U24.CC48 74.7,50.61 74.47,50.84 74.18,50.84 74.05,50.71 73.38,50.71 73.07,50.41 72.22,50.41 70.95,49.14 70.55,49.14 69.51,48.1
  BOTTOM w0.102: 69.51,48.1 68.95,47.53 65.98,47.53 65.88,47.64 64.74,47.64 64.48,47.9 64.48,48.85 64.73,49.1 64.73,52.54 64.57,52.7 62.96,52.7 R632.2 R631.1
BOARD_ID2: length 19.6
  BOTTOM w0.079: U24.CC49 74.26,50.54 73.45,50.54 73.14,50.24 72.3,50.24 71.02,48.96 70.62,48.96 68.97,47.31 68.85,47.31
  BOTTOM w0.102: 68.85,47.31 65.89,47.31 65.79,47.41 64.64,47.41 64.25,47.8 64.25,48.94 64.5,49.2 64.5,52.26 64.29,52.47 62.97,52.47 R635.2 R634.1
BOARD_ID3: length 22.3
  BOTTOM w0.079: 69.28,48.25 69.4,48.25 70.47,49.31 70.88,49.31 72.15,50.58 73.01,50.58 73.31,50.88 73.98,50.88 74.11,51.01 74.54,51.01 74.66,50.89 75.35,50.89 U24.CC47
  BOTTOM w0.102: R629.1 R630.2 62.97,54.52 64.02,54.52 64.96,53.58 64.96,49.01 64.7,48.75 64.7,47.99 64.83,47.87 65.97,47.87 66.08,47.76 68.79,47.76 69.28,48.25
BOARD_ID4: length 177
  TOP w0.102: v1(61.98,48.61) v1(61.07,48.61) 60.47,48.61 57.85,45.99 57.85,30.19 57.52,29.86 57.52,29.02 57.26,28.76 57.19,28.76 56.45,28.03 56.45,27.59 55.75,26.88 53.78,26.88 v2(53.29,26.39)
  IN2 w0.089: v2(54.49,106.21) 54.49,106.21 51.48,103.2 51.48,102.3 49.94,100.76 49.94,100.41 48.04,98.51 44.79,98.51 43.89,97.61 31.84,97.61 29.88,95.65 29.88,94.45 27.34,91.91 27.34,89.58 24.71,86.96 24.71,85.08 25.08,84.71 25.71,84.71 26.2,84.23 26.2,82.41 25.22,81.43 25.22,74.13 25.7,73.66 25.7,62.36 26.04,62.02 26.04,50.35 25.44,49.74 24.89,49.74 24.6,49.45 24.6,49.11 24.76,48.95 25.13,48.95 26.2,47.88 26.2,43.3 25.44,42.53 25.44,39.46 26.12,38.77 26.12,37.3 30.71,32.71 37.12,32.71 38.62,31.21 39.55,31.21 39.99,30.77 43.78,30.77 44.89,29.65 44.89,28.14 46,27.03 48.81,27.03 49,27.23 49.8,27.23 51.16,25.87 52.49,25.87 53.01,26.39 v2(53.29,26.39)
  BOTTOM w0.079: U24.CF45 75.98,49.64 75.58,49.64 75.43,49.58 73.85,49.58 73.54,49.27 73.12,49.27 72.87,49.02 72.11,49.02 71.32,48.23 70.91,48.23 69.07,46.39 68.64,46.39
  BOTTOM w0.102: R517.1 56.42,104.44 C541.2 56.01,104.21 55.69,104.53 55.69,105.08 54.56,106.21 v2(54.49,106.21) ; v1(61.98,48.61) R650.1 61.5,47.95 R651.2 62.94,47.45 63.28,47.45 64.24,46.49 65.41,46.49 65.51,46.39 68.64,46.39
BOARD_ID5: length 19.2
  BOTTOM w0.079: U24.CE47 75.07,50.21 73.59,50.21 73.28,49.9 72.47,49.9 71.17,48.6 70.78,48.6 69.02,46.85 68.64,46.85
  BOTTOM w0.102: R644.1 61.72,50.28 62.17,50.28 62.47,49.97 R645.2 63.1,50.41 63.81,50.41 64.04,50.18 64.04,49.39 63.75,49.09 63.75,47.65 64.45,46.95 65.6,46.95 65.7,46.85 68.64,46.85
BOARD_ID6: length 185.4
  TOP w0.102: v1(62.04,49.69) 62.01,49.69 61.99,49.67 61.15,49.67 57.61,46.13 57.61,30.96 56.98,30.34 56.58,30.34 56.07,29.83 56.07,28.71 56.22,28.56 56.22,27.68 55.65,27.11 53.58,27.11 v1(53.32,27.37) v2(52.77,27.93)
  IN1 w0.089: v2(26.22,85.33) 25.7,84.8 25.7,74.19 26.83,73.06 27.27,73.06 27.77,72.56 27.77,68.64 25.92,66.8 25.92,65.49 25.6,65.17 25.6,62.62 26.21,62 26.21,58.01 25.36,57.16 25.36,52.39 24.6,51.62 24.6,50.33 25.46,49.47 25.46,44.3 v1(25.01,43.85)
  IN2 w0.089: v2(32.68,36.66) 32.75,36.59 36.43,36.59 39.13,33.9 46.12,33.9 48.42,31.6 48.42,30.01 48.86,29.58 52.13,29.58 52.77,28.94 v2(52.77,27.93) ; v2(26.22,85.33) 26.48,85.33 26.83,85.69 26.83,86.24 28.1,87.51 28.1,91.79 30.73,94.41 30.73,95.39 32.37,97.04 44.19,97.04 45.08,97.93 48.3,97.93 50.53,100.16 50.53,100.53 52.66,102.67 52.66,103.3 54.62,105.26 55.71,105.26 v2(56.07,105.63)
  BOTTOM w0.079: 68.64,46.62 69.05,46.62 70.85,48.42 71.28,48.42 72.04,49.18 72.8,49.18 73.06,49.44 73.47,49.44 73.78,49.75 75.4,49.75 75.54,49.81 75.54,49.81 75.78,49.81 U24.CE46
  BOTTOM w0.102: R516.1 57.77,104.94 57.53,105.18 C532.2 56.81,105.55 56.15,105.55 v2(56.07,105.63) ; v1(25.01,43.85) 25.54,43.85 27.3,42.09 27.3,38.45 29.63,36.13 29.63,34.17 30.95,32.85 34.81,32.85 35.22,33.26 35.22,34.12 v2(32.68,36.66) ; 68.64,46.62 65.6,46.62 65.5,46.72 64.33,46.72 63.37,47.68 63.04,47.68 62.88,47.84 62.88,48.67 R648.2 62.49,49.06 61.46,49.06 R647.1 61.41,49.27 61.81,49.67 61.99,49.67 62.01,49.69 v1(62.04,49.69)
BOARD_ID7: length 15
  BOTTOM w0.079: 68.64,46.16 69.1,46.16 71,48.06 71.39,48.06 72.18,48.85 72.94,48.85 73.19,49.11 73.61,49.11 73.85,49.35 U24.CF49
  BOTTOM w0.102: R652.1 61.8,47.08 R653.2 63.1,45.78 63.7,45.78 64.18,46.26 65.31,46.26 65.41,46.16 68.64,46.16
BRIGHT: length 3.1
  TOP w0.102: R21.2 54.8,108.2 R26.1 R25.2 53.33,107.91 53.44,108.02 53.44,108.46 v1(53.63,108.65)
BT_EN: length 17.4
  TOP w0.102: v2(202.83,23.48) 202.91,23.56 R402.2
  IN2 w0.089: v2(202.83,23.48) 201.88,22.53 201.15,22.53 198.88,20.26 198.88,18.57 198.22,17.91 195.96,17.91 195.68,18.2 v2(195.03,18.2)
  BOTTOM w0.102: v2(195.03,18.2) 194.65,18.58 194.03,18.58 193.73,18.88 193.05,18.88 192.88,18.71 R825.1 192.67,18.48 192.07,17.88 CN9.54
BXTALOUT: length 7.9
  BOTTOM w0.102: R562.1 R563.1 98.44,89.4 99.96,90.92 100.39,90.92 101.15,91.68 101.15,92.7 101.28,92.82 101.28,93.89 101.71,94.32 U22.C10
C_IN_CLK: length 12.7
  TOP w0.102: R115.2 15.33,80.79 15.26,80.71 15.14,80.71 v1(14.82,81.04) 14.52,81.04 R111.1
  IN3 w0.089: CN4.10 11.81,76.2 12.05,76.44 12.05,76.85 12.19,77 12.92,77 13.22,77.3 13.22,80.45 14.41,81.65 15.17,81.65 15.3,81.52 15.3,80.93 15.13,80.76 14.97,80.76 14.82,80.91 v1(14.82,81.04)
  BOTTOM w0.102: R115.2 15.33,81.09 15.16,80.92 14.93,80.92 v1(14.82,81.04) 14.71,81.15 R589.1
C_IN_CLK#: length 12.7
  TOP w0.102: R117.1 14.37,80.58 14.59,80.58 v1(14.79,80.38) 14.92,80.5 15.22,80.5 15.33,80.39 R118.2
  IN3 w0.089: CN4.12 12.84,77.2 13.02,77.38 13.02,80.54 14.33,81.85 15.26,81.85 15.51,81.6 15.51,80.85 15.21,80.55 14.97,80.55 v1(14.79,80.38)
  BOTTOM w0.102: R589.2 14.24,80.45 14.72,80.45 v1(14.79,80.38) 14.92,80.38 R118.2
C_IN_CLK#_R: length 3
  TOP w0.102: U3.31 24.3,79.72 24.49,79.91 24.75,79.91 25.01,80.17 25.01,80.83 25.23,81.05 25.45,81.05 25.55,80.95 C196.2
C_IN_CLK_R: length 3
  TOP w0.102: U3.32 24.35,80.22 24.44,80.13 24.66,80.13 24.8,80.26 24.8,80.92 25.14,81.27 25.39,81.27 25.55,81.42 C187.2
C_TX0_HDMI+: length 15.5
  TOP w0.102: R150.2 15.12,75.45 v1(14.82,75.14) 14.67,75.3 R153.1
  IN1 w0.089: CN4.7 10.51,74.7 10.73,74.48 10.73,71.78 11.26,71.26 11.98,71.26 12.53,71.81 12.53,72.11 13.1,72.68 14.08,72.68 15.05,73.65 15.95,73.65 16.29,73.99 16.29,74.54 15.81,75.02 14.95,75.02 v1(14.82,75.14)
  BOTTOM w0.102: R606.1 14.66,75.31 v1(14.82,75.14) 15.12,75.45 R150.2
C_TX0_HDMI+_R: length 3.5
  TOP w0.102: U3.26 24.42,77.22 24.56,77.08 24.85,77.08 25.08,76.85 25.08,75.74 25.22,75.6 25.44,75.6 25.55,75.71 C203.2
C_TX0_HDMI-: length 15.4
  TOP w0.102: R157.1 14.57,74.28 v1(14.79,74.5) 15.09,74.5 R160.2
  IN1 w0.089: v1(14.79,74.5) 15.11,74.81 15.73,74.81 16.09,74.45 16.09,74.08 15.86,73.85 14.96,73.85 14,72.88 13.02,72.88 12.33,72.2 12.33,71.89 11.9,71.46 11.34,71.46 10.93,71.87 10.93,74.56 10.6,74.89 10.6,75.15 CN4.9
  BOTTOM w0.102: R606.2 14.24,74.61 14.68,74.61 v1(14.79,74.5) 15.09,74.5 R160.2
C_TX0_HDMI-_R: length 3.5
  TOP w0.102: U3.25 24.42,76.72 24.56,76.86 24.76,76.86 24.86,76.76 24.86,75.65 25.13,75.38 25.44,75.38 25.55,75.27 C206.2
C_TX1_HDMI+: length 10.2
  TOP w0.102: R138.1 14.54,77.33 v1(14.79,77.08) 15.07,77.35 R137.2
  IN3 w0.089: v1(14.79,77.08) 15.02,76.85 15.21,76.85 15.43,76.63 15.43,74.28 15.02,73.87 13.22,73.87 12.54,73.2 CN4.4
  BOTTOM w0.102: R601.1 14.66,77.21 v1(14.79,77.08) 15.07,77.35 R137.2
C_TX1_HDMI+_R: length 2.5
  TOP w0.102: C200.2 25.55,77.56 25.49,77.5 25.35,77.5 24.77,78.08 24.46,78.08 24.31,78.22 U3.28
C_TX1_HDMI-: length 10.2
  TOP w0.102: R144.1 14.35,76.5 14.73,76.5 v1(14.79,76.43) 15.06,76.43 R145.2
  IN3 w0.089: CN4.6 11.95,74.2 12.1,74.05 12.1,73.54 12.24,73.4 12.46,73.4 13.13,74.08 14.94,74.08 15.23,74.37 15.23,76.54 15.12,76.64 14.92,76.64 14.79,76.52 v1(14.79,76.43)
  BOTTOM w0.102: R145.2 15.06,76.43 v1(14.79,76.43) 14.71,76.52 14.24,76.52 R601.2
C_TX1_HDMI-_R: length 2.4
  TOP w0.102: U3.27 24.33,77.72 24.47,77.86 24.68,77.86 25.26,77.28 25.46,77.28 25.55,77.19 C201.2
C_TX2_HDMI+: length 16.2
  TOP w0.102: R122.2 15.22,79.37 15.07,79.37 v1(14.79,79.09) 14.44,79.09 R121.1
  IN3 w0.089: CN4.1 10.56,71.7 11.1,71.16 12.08,71.16 14.19,73.27 15.31,73.27 16.04,73.99 16.04,78.49 15.44,79.09 v1(14.79,79.09)
  BOTTOM w0.102: R595.1 14.23,79.04 14.75,79.04 v1(14.79,79.09) 15.07,79.37 15.22,79.37 R122.2
C_TX2_HDMI+_R: length 2.3
  TOP w0.102: U3.30 24.42,79.22 24.56,79.08 24.86,79.08 25.18,79.41 25.44,79.41 25.55,79.52 C197.2
C_TX2_HDMI-: length 16.2
  TOP w0.102: R130.2 15.18,78.07 v1(14.79,78.46) 14.71,78.54 14.36,78.54 R124.1
  IN3 w0.089: CN4.3 10.45,72.3 10.45,72.1 11.19,71.36 12,71.36 14.11,73.47 15.23,73.47 15.84,74.08 15.84,78.41 15.36,78.89 15.16,78.89 14.79,78.52 v1(14.79,78.46)
  BOTTOM w0.102: R130.2 14.94,78.46 v1(14.79,78.46) 14.28,78.46 R595.2
C_TX2_HDMI-_R: length 2.3
  TOP w0.102: C198.2 25.55,79.03 25.39,79.19 25.27,79.19 24.95,78.86 24.56,78.86 24.42,78.72 U3.29
CFG_RCOMP: length 8
  TOP w0.254: v2(95.85,69.58) 97.09,69.58 97.98,70.47 98.87,70.47 99.25,70.85 99.25,71.11 99.53,71.39 101.65,71.39 102,71.74 R173.1
  BOTTOM w0.254: v2(95.85,69.58) 95.49,69.94 U24.AD6
CHA_SA0: length 4.5
  TOP w0.102: v1(56.45,96.13) 56.45,96.42 R58.1 R57.2
  BOTTOM w0.102: JDIM1.256 57.62,95.21 57.16,95.67 56.55,95.67 56.45,95.77 v1(56.45,96.13)
CHA_SA1: length 3.4
  TOP w0.102: R63.2 58.64,96.47 58.62,96.5 R62.1 57.68,96.21 v1(57.08,96.21)
  BOTTOM w0.102: JDIM1.260 v1(57.08,96.21)
CHA_SA2: length 3.8
  BOTTOM w0.102: JDIM1.166 59.32,72.7 59.5,72.88 59.5,73.01 60.14,73.65 R609.1 R605.2
CLK_24M_DEBUG_R: length 2.1
  BOTTOM w0.102: CN9.60 191.82,16.38 191.84,16.41 192.23,16.41 192.42,16.22 R831.2
CLK_BIASREF: length 3.1
  TOP w0.203: 95.66,32.24 R308.1
  TOP w0.381: 95.66,32.24 95.6,32.18 v2(95.6,31.95)
  BOTTOM w0.079: 95.58,31.97 95.35,32.2 95.3,32.2 95.14,32.36 95.14,33.56 U24.DU6
  BOTTOM w0.127: v2(95.6,31.95) 95.58,31.97
CLK_PCIE_LANN: length 118.4
  TOP w0.102: v1(46.29,101.9) 46.21,101.9 46,102.11 46,102.64 46.04,102.68 U1.16
  IN3 w0.089: v1(46.29,101.9) 46.06,102.13 46.06,104.35 47.27,105.56 49.3,105.56 50.15,104.71 52.72,104.71 53.47,105.46 53.47,105.97 54.09,106.59 63.27,106.59 63.61,106.94 68.17,106.94 70.39,104.72 74.62,104.72 75.29,104.05 77.15,104.05 78.73,102.48 81.72,102.48 84.62,99.58 86.62,99.58 87.73,98.46 89.84,98.46 91.29,97.01 91.29,96.3 93.35,94.25 93.86,94.25 95.13,92.97 95.13,92.18 97.72,89.59 97.72,85.68 102.86,80.55 102.86,65.2 100.84,63.18 99.27,63.18 97.85,61.76 97.85,56.7 98.28,56.27 98.94,56.27 99.83,55.38 99.83,49.03 100.29,48.57 100.29,47.94 v2(100.03,47.69)
  BOTTOM w0.079: v2(100.03,47.69) 100.11,47.69 100.38,47.95 100.38,48.05 100.31,48.12 99.6,48.12 98.93,47.45 97.91,47.45 97.66,47.7 U24.CJ2
CLK_PCIE_LANP: length 118.4
  TOP w0.102: U1.15 45.64,102.77 45.78,102.63 45.78,102.01 v1(45.64,101.87)
  IN3 w0.089: v1(45.64,101.87) 45.81,102.03 45.81,102.04 45.86,102.09 45.86,104.44 47.18,105.76 49.38,105.76 50.24,104.91 52.63,104.91 53.26,105.54 53.26,106.05 54,106.79 63.18,106.79 63.53,107.14 68.25,107.14 70.47,104.92 74.71,104.92 75.37,104.25 77.24,104.25 78.81,102.68 81.81,102.68 84.7,99.78 86.7,99.78 87.82,98.67 89.93,98.67 91.5,97.09 91.5,96.38 93.43,94.45 93.94,94.45 95.34,93.05 95.34,92.26 97.93,89.67 97.93,85.76 103.06,80.63 103.06,65.11 100.93,62.98 99.36,62.98 98.06,61.67 98.06,56.79 98.37,56.48 99.03,56.48 100.04,55.47 100.04,49.11 100.49,48.65 100.49,47.81 v2(100.62,47.69)
  BOTTOM w0.079: v2(100.62,47.69) 100.54,47.76 100.54,48.12 100.38,48.29 99.53,48.29 98.86,47.62 98.14,47.62 U24.CJ1
CLK_PCIE_REQ2#: length 11
  TOP w0.102: R391.1 83.02,25.73 83.02,26.73 83.63,27.34 83.63,28.69 TP38.1 83.5,29.12 82.1,30.52 82.1,33.42 81.98,33.55 81.98,34.4 82.08,34.51 v2(82.08,34.95)
  BOTTOM w0.102: v2(82.08,34.95) 82.03,35 81.95,35 81.71,35.24 U24.DP34
CLK_PCIE_REQ3#: length 10.6
  BOTTOM w0.079: 80.79,34.72 80.79,35.41 U24.DP36
  BOTTOM w0.102: TP94.1 81.72,26.02 81.72,27.54 81.43,27.83 81.43,28.19 81.6,28.36 81.6,29 R729.1 81.34,29.66 81.34,31.45 80.79,32.01 80.79,34.72
CLK_PCIE_SSDN: length 106.2
  IN3 w0.089: v1(27.75,12.64) 27.62,12.64 27.52,12.74 27.52,12.89 27.65,13.02 27.65,14.44 27.6,14.48 27.6,20.05 27.87,20.32 27.87,23.55 32.4,28.07 32.4,31.51 33.79,32.9 34.92,32.9 36.93,34.91 49.17,34.91 50.54,36.28 53.63,36.28 54.09,36.74 59.5,36.74 62.39,39.64 67.81,39.64 71.73,43.56 71.83,43.56 72.83,44.56 72.83,44.77 73.52,45.45 74.41,45.45 75.55,46.59 75.55,47.41 76.8,48.65 79.84,48.65 79.94,48.75 81.06,48.75 81.37,49.06 81.37,49.63 81.66,49.93 83,49.93 83.32,50.25 84.2,50.25 84.76,49.69 86.57,49.69 88.5,51.62 90.8,51.62 91.49,52.31 91.49,53.06 92.57,54.14 93.74,54.14 93.91,54.32 95.72,54.32 97.39,52.64 97.39,48.44 98.03,47.81 98.03,47.26 v2(97.84,47.08)
  BOTTOM w0.079: v2(97.84,47.08) 97.84,46.79 97.63,46.58 U24.CL2
  BOTTOM w0.102: R848.1 27.47,11.77 27.37,11.87 27.37,12.33 27.67,12.64 v1(27.75,12.64)
CLK_PCIE_SSDN_C: length 2.5
  BOTTOM w0.102: CN18.53 26.85,10.33 26.73,10.46 26.73,10.57 26.85,10.69 27.21,10.69 27.42,10.91 27.42,11.12 27.62,11.32 R848.2
CLK_PCIE_SSDP: length 106.2
  IN3 w0.089: v1(27.05,12.64) 27.32,12.9 27.32,12.97 27.44,13.1 27.44,14.35 27.4,14.4 27.4,20.13 27.67,20.41 27.67,23.63 32.19,28.16 32.19,31.59 33.71,33.11 34.83,33.11 36.84,35.11 49.08,35.11 50.46,36.49 53.55,36.49 54,36.94 59.41,36.94 62.31,39.84 67.73,39.84 71.65,43.76 71.74,43.76 72.63,44.65 72.63,44.85 73.43,45.66 74.32,45.66 75.35,46.68 75.35,47.49 76.71,48.86 79.76,48.86 79.86,48.96 80.98,48.96 81.16,49.14 81.16,49.72 81.58,50.13 82.92,50.13 83.24,50.46 84.29,50.46 84.85,49.9 86.49,49.9 88.42,51.83 90.71,51.83 91.28,52.39 91.28,53.14 92.48,54.34 93.65,54.34 93.83,54.52 95.8,54.52 97.6,52.72 97.6,48.53 98.23,47.89 98.23,47.27 v2(98.43,47.08)
  BOTTOM w0.079: U24.CL1 98.05,46.7 v2(98.43,47.08)
  BOTTOM w0.102: R847.1 27.15,11.93 27.15,12.53 v1(27.05,12.64)
CLK_PCIE_SSDP_C: length 2.4
  BOTTOM w0.102: R847.2 27.11,11.32 27.21,11.22 27.21,11 27.12,10.91 26.76,10.91 26.51,10.66 26.51,10.51 26.35,10.35 CN18.55
CLK_PCIE_WLANN: length 138.6
  IN1 w0.089: v2(191.04,33.87) 190.89,34.02 190.89,34.46 190.61,34.75 189.7,34.75 189.16,34.2 185.75,34.2 185.37,33.82 167.63,33.82 166.83,33.03 163.82,33.03 163.64,33.21 161.28,33.21 160.26,34.23 159.73,34.23 158.44,35.52 156.94,35.52 156.08,34.66 152.95,34.66 152.8,34.81 147.72,34.81 146.24,36.29 146.24,36.84 145.68,37.4 144.98,37.4 143.02,39.36 136.89,39.36 136.33,38.8 126.67,38.8 124.31,36.44 118.06,36.44 117.33,35.7 114.74,35.7 114.46,35.98 112.05,35.98 110.77,37.26 110.24,37.26 108.86,38.64 107.61,38.64 107.43,38.83 107.43,42.79 106.41,43.81 106.41,45.62 106.61,45.82 106.61,48.33 105.89,49.06 104.79,49.06 103.69,50.15 103.69,50.4 103.8,50.51 104.07,50.51 v1(104.18,50.41)
  BOTTOM w0.079: U24.CF5 96.11,49.04 96.88,48.68 97.16,48.68 97.27,48.63 97.59,48.63 97.69,48.69 97.8,48.69 97.91,48.63 98.29,48.63 98.51,48.86 99.59,48.86 100.33,49.6 101.36,49.6 101.39,49.58 101.41,49.58
  BOTTOM w0.102: 101.41,49.58 102.82,49.58 103.64,50.41 v1(104.18,50.41) ; CN9.49 185.87,19.13 186.18,18.82 187.55,18.82 188.75,20.01 188.75,23.62 188.53,23.84 188.53,25.31 188.24,25.6 188.24,29.72 187.05,30.91 187.05,31.88 188.36,33.2 190.68,33.2 190.89,33.41 190.89,33.72 v2(191.04,33.87)
CLK_PCIE_WLANP: length 138.5
  IN1 w0.089: v1(104.18,51.04) 104.18,50.99 103.9,50.71 103.72,50.71 103.49,50.48 103.49,50.07 104.7,48.86 105.8,48.86 106.41,48.25 106.41,45.91 106.21,45.71 106.21,43.72 107.22,42.71 107.22,38.75 107.53,38.44 108.77,38.44 110.16,37.06 110.68,37.06 111.97,35.77 114.38,35.77 114.66,35.5 117.41,35.5 118.15,36.23 124.39,36.23 126.76,38.59 136.42,38.59 136.98,39.15 142.94,39.15 144.89,37.2 145.6,37.2 146.04,36.76 146.04,36.2 147.63,34.61 152.72,34.61 152.87,34.45 156.16,34.45 157.03,35.32 158.36,35.32 159.65,34.02 160.18,34.02 161.2,33.01 163.55,33.01 163.74,32.82 166.92,32.82 167.71,33.62 185.46,33.62 185.84,34 189.24,34 189.79,34.54 190.52,34.54 190.69,34.38 190.69,34.1 v2(190.46,33.87)
  BOTTOM w0.079: U24.CF3 96.75,49.01 96.92,48.85 97.19,48.85 97.31,48.8 97.54,48.8 97.64,48.86 97.84,48.86 97.95,48.8 98.22,48.8 98.44,49.02 99.52,49.02 100.26,49.77 101.36,49.77 101.39,49.79 101.41,49.79
  BOTTOM w0.102: 101.41,49.79 102.73,49.79 103.55,50.62 103.76,50.62 v1(104.18,51.04) ; v2(190.46,33.87) 190.68,33.65 190.68,33.5 190.59,33.41 188.28,33.41 186.83,31.97 186.83,30.82 188.02,29.63 188.02,25.51 188.31,25.22 188.31,23.75 188.53,23.53 188.53,20.1 187.46,19.04 186.27,19.04 185.96,19.35 184.26,19.35 184.21,19.39 184.21,19.5 184.08,19.63 CN9.47
CLK_VGA_N: length 106.3
  IN1 w0.089: v2(99.58,112.45) 99.58,112.56 99.71,112.69 99.88,112.69 99.97,112.6 99.97,112.01 98.99,111.03 98.99,110.21 99.43,109.78 99.43,107.77 97.66,106 97.66,104.73 96.51,103.58 96.51,102.54 97.17,101.88 97.17,99.9 97.52,99.55 97.52,97.2 96.53,96.21 96.53,91.35 95.85,90.67 95.85,86.53 96.28,86.11 96.28,83.92 102.6,77.6 102.6,72.38 102.04,71.83 102.04,71.45 102.25,71.24 104.44,71.24 104.53,71.15 104.53,70.89 104.44,70.8 102.25,70.8 102.04,70.59 102.04,70.16 102.25,69.95 104.44,69.95 104.53,69.86 104.53,69.59 104.44,69.5 102.25,69.5 102.04,69.3 102.04,68.86 102.25,68.65 104.44,68.65 104.53,68.56 104.53,68.3 104.44,68.21 102.25,68.21 102.04,68 102.04,67.57 102.25,67.36 104.39,67.36 104.48,67.27 104.48,67 104.39,66.91 102.25,66.91 102.04,66.7 102.04,66.27 102.25,66.06 104.01,66.06 104.1,65.97 104.1,65.71 104.01,65.62 102.25,65.62 102.04,65.41 102.04,64.97 102.25,64.77 103.63,64.77 103.71,64.69 103.71,64.4 103.63,64.32 102.25,64.32 102.04,64.11 102.04,63.98 101.05,62.99 101.05,51.22 101.41,50.86 102.3,50.86 102.78,50.38 102.78,49.2 103.16,48.82 103.34,48.82 103.52,48.65 v1(103.52,48.53)
  BOTTOM w0.079: U24.CJ3 96.97,47.84 97.3,47.96 97.48,47.96 97.56,47.94 97.87,47.94 97.95,47.96 98.22,47.96 98.39,47.79 98.78,47.79 99.49,48.51 99.83,48.51 100.16,48.84 101.36,48.84 101.39,48.82 101.41,48.82
  BOTTOM w0.102: U22.AD8 100.07,112.4 99.99,112.48 99.62,112.48 v2(99.58,112.45) ; v1(103.52,48.53) 103.52,48.57 103.15,48.94 102.74,48.94 102.61,48.82 101.41,48.82
CLK_VGA_P: length 106.3
  IN1 w0.089: v1(103.52,49.19) 103.36,49.03 103.24,49.03 102.98,49.29 102.98,50.46 102.38,51.07 101.49,51.07 101.26,51.3 101.26,62.9 102.25,63.89 102.25,64.03 102.34,64.12 103.71,64.12 103.91,64.31 103.91,64.77 103.71,64.97 102.34,64.97 102.25,65.06 102.25,65.33 102.34,65.41 104.1,65.41 104.3,65.62 104.3,66.06 104.1,66.27 102.34,66.27 102.25,66.35 102.25,66.62 102.34,66.71 104.48,66.71 104.68,66.92 104.68,67.35 104.48,67.56 102.34,67.56 102.25,67.65 102.25,67.92 102.34,68 104.53,68 104.74,68.21 104.74,68.65 104.53,68.86 102.34,68.86 102.25,68.94 102.25,69.21 102.34,69.3 104.53,69.3 104.74,69.51 104.74,69.94 104.53,70.15 102.34,70.15 102.25,70.24 102.25,70.51 102.34,70.6 104.53,70.6 104.74,70.8 104.74,71.24 104.53,71.45 102.34,71.45 102.25,71.54 102.25,71.74 102.8,72.3 102.8,77.68 96.48,84.01 96.48,86.19 96.06,86.62 96.06,90.59 96.73,91.27 96.73,96.13 97.72,97.12 97.72,99.63 97.37,99.99 97.37,101.97 96.71,102.63 96.71,103.49 97.86,104.65 97.86,105.92 99.63,107.68 99.63,109.87 99.2,110.3 99.2,110.95 100.17,111.92 100.17,112.68 99.96,112.89 99.78,112.89 99.68,112.99 v2(99.68,113.22)
  BOTTOM w0.079: 101.41,49.03 101.39,49.03 101.36,49.01 100.09,49.01 99.76,48.67 99.42,48.67 98.71,47.96 98.45,47.96 98.29,48.13 97.93,48.13 97.85,48.11 97.58,48.11 97.49,48.13 97.27,48.13 96.88,47.98 96.69,47.98 96.11,47.72 U24.CJ5
  BOTTOM w0.102: v1(103.52,49.19) 103.49,49.16 102.65,49.16 102.52,49.03 101.41,49.03 ; U22.AE8 v2(99.68,113.22)
CLR_CMOS: length 193.1
  TOP w0.102: v2(179.59,18.91) 179.59,18.94 179.82,19.17 179.82,19.57 v1(179.84,19.59) 180.52,20.27 181.82,20.27 182.26,20.71 182.26,20.84 182.4,20.98 U13.19 ; Q28.2 15.23,6.15 R496.2 14.9,5.96 v1(14.36,5.42) 16.14,5.42 17.21,6.49 17.21,6.83 Q29.2
  IN2 w0.089: v1(14.36,5.42) 14.46,5.52 16.14,5.52 17.66,7.05 19.47,7.05 19.98,7.56 21.42,7.56 23.33,5.65 24.9,5.65 25.18,5.37 27.8,5.37 29.2,6.77 33.23,6.77 33.44,6.97 34.96,6.97 35.57,7.58 35.57,9.42 36.28,10.13 37.6,10.13 42.82,15.35 44.41,15.35 45.32,14.44 53.61,14.44 53.73,14.56 55.1,14.56 55.83,13.82 57.81,13.82 58.84,14.85 60.11,14.85 61.87,13.09 70.8,13.09 71.23,12.66 74.16,12.66 74.85,11.97 80.74,11.97 83.29,9.42 83.45,9.42 83.76,9.1 88.71,9.1 89.17,9.57 89.17,9.76 92.2,12.79 92.39,12.79 93.71,14.11 111.88,14.11 114.44,16.67 122.43,16.67 123.19,17.42 127.71,17.42 128.21,16.93 138.49,16.93 139.28,17.72 142.25,17.72 142.92,17.05 150.64,17.05 151.2,17.61 153.3,17.61 154.06,16.86 154.57,16.86 154.88,17.17 154.88,17.76 155.13,18.01 156.77,18.01 157.28,17.49 160.86,17.49 161.18,17.82 171.82,17.82 172.44,18.43 173.96,18.43 174.23,18.7 179.23,18.7 179.44,18.91 v2(179.59,18.91)
CNV_BRI_DT: length 134.5
  TOP w0.102: v2(87.13,32.47) 87.13,32.24 87.49,31.89 87.49,30.77 87.18,30.47 87.18,29.78 87.08,29.68 R353.2 86.93,30.06 86.9,30.09 R337.1 86.9,30.77 87.11,30.98 R329.2
  IN2 w0.089: v2(87.13,32.47) 87.58,32.92 95.88,32.92 97.2,31.6 101.97,31.6 103.72,33.35 106.4,33.35 106.59,33.54 110.39,33.54 110.92,34.08 112.99,34.08 114.29,32.78 117.65,32.78 119.13,34.26 121.84,34.26 124.13,36.55 135.53,36.55 136.55,35.53 144.17,35.53 146.33,33.37 152.34,33.37 152.73,32.98 156.33,32.98 156.68,32.63 159.66,32.63 159.91,32.88 161.56,32.88 161.76,32.68 161.76,32.22 162.06,31.91 163.08,31.91 163.71,31.29 167.78,31.29 168.01,31.51 174.74,31.51 176.27,29.98 178.62,29.98 180.47,28.13 183.12,28.13 183.91,28.92 187.81,28.92 188.57,28.15 190.15,28.15 190.98,28.98 192.67,28.98 193.36,28.29 193.36,27.37 194.07,26.66 194.8,26.66 195.54,25.92 196.05,25.92 196.76,25.21 v2(197.17,25.21)
  BOTTOM w0.102: v2(197.17,25.21) 197.17,25.01 196.56,24.4 196.56,23.35 195.77,22.56 R799.2 194.37,22.56 194.19,22.39 193,22.39 192.64,22.74 191.84,22.74 191.48,22.38 CN9.36
CNV_BRI_DT_R: length 7
  TOP w0.102: R329.1 87.11,31.89 86.68,32.32 86.68,33.13 86.22,33.59 85.86,33.59 85.05,34.4 85.05,35.01 84.38,35.69 84.38,36.13 84.01,36.5 v2(83.96,36.5)
  BOTTOM w0.102: v2(83.96,36.5) 83.96,36.52 83.77,36.72 U24.DL31
CNV_BRI_RSP: length 126.8
  IN2 w0.089: v2(83.96,37.07) 84.39,36.64 84.39,36.31 84.64,36.05 85.15,36.05 85.41,35.8 85.41,34.02 85.86,33.56 96.15,33.56 97.47,32.24 101.7,32.24 102.84,33.38 102.84,34.45 103.52,35.14 106.84,35.14 107.63,34.35 109.33,34.35 109.41,34.28 110.21,34.28 110.65,34.72 113.28,34.72 114.58,33.43 117.38,33.43 118.86,34.9 121.57,34.9 123.86,37.2 135.8,37.2 136.82,36.18 145.36,36.18 146.84,34.7 147.34,34.7 147.93,34.1 152.52,34.1 152.89,33.74 156.64,33.74 157.01,34.11 161.39,34.11 162.23,33.28 163.12,33.28 163.79,32.61 163.79,32.19 164.05,31.93 167.51,31.93 167.74,32.16 175.01,32.16 176.54,30.63 178.89,30.63 179.99,29.53 183.27,29.53 183.49,29.74 194.74,29.74 195.26,29.22 195.26,27.9 v2(195.5,27.66)
  BOTTOM w0.102: R761.2 196.45,27.06 195.86,27.66 v2(195.5,27.66) ; U24.DL29 84.11,37.07 v2(83.96,37.07)
CNV_BRI_RSP_L: length 9.7
  BOTTOM w0.102: CN9.22 190.78,25.81 190.87,25.72 190.87,25.18 190.61,24.93 190.61,24.37 191.02,23.96 191.15,23.84 193.38,23.84 193.77,24.22 v1(194.19,24.22) 194.62,24.22 194.67,24.27 195.24,24.27 195.83,24.85 196.03,24.85 196.25,25.07 196.25,25.67 196.15,25.78 196.15,26.23 R761.1
CNV_RF_RESET#: length 138.1
  TOP w0.102: R349.1 145.47,29.93 v1(145.2,29.65) 145.2,29.4 145.48,29.12 146.14,29.12 146.32,28.95 146.32,27.55 146.19,27.42 145.86,27.42 145.35,26.91 v2(145.35,26.79) 145.35,26.68 145.55,26.48 145.55,26.3 145.64,26.22 U12.1 145.92,25.7 R396.1 146.74,25.39 146.57,25.56 U12.2
  IN1 w0.089: v2(59.9,27.77) 59.9,27.34 60.15,27.09 60.15,26.42 61.1,25.47 v1(61.1,24.57)
  IN2 w0.089: v2(145.35,26.79) 145.25,26.89 142.97,26.89 142.49,27.37 138.03,27.37 136.84,28.56 135.84,28.56 134.8,27.52 127.42,27.52 126.42,26.52 120.95,26.52 120.55,26.12 111.92,26.12 110.45,24.65 102.73,24.65 102.08,24 v2(102.08,23.86) ; v2(100.8,20.18) 100.29,19.67 93.15,19.67 92.21,20.61 90.89,20.61 89.01,22.49 83.91,22.49 79.7,18.27 74.92,18.27 73.56,19.63 63.68,19.63 62.16,21.14 62.16,22.11 61.1,23.18 v1(61.1,24.57)
  IN3 w0.089: v2(102.08,23.86) 102.08,23.49 100.8,22.21 v2(100.8,20.18)
  BOTTOM w0.079: U24.CT48 74.7,44.34 74.51,44.15 74.42,44.11 73.36,44.11 72.35,43.11 71.09,43.11 70.13,42.15 68.64,42.15
  BOTTOM w0.102: 68.64,42.15 66.38,42.15 R672.1 65.95,41.99 65.46,41.51 64.25,41.51 63.62,40.88 62.79,40.88 60.83,38.92 60.83,28.91 59.9,27.98 v2(59.9,27.77)
CNV_RF_RESET#_L: length 53.2
  TOP w0.102: U12.4 147.22,29.4 146.99,29.63 R350.1 146.7,29.7 146.47,29.48 R349.2 146.11,29.47 146.59,29 146.59,27.71 147,27.29 147.66,27.29 v2(148.32,26.62)
  IN3 w0.089: v2(189.39,26.99) 188.71,26.3 185.76,26.3 185.23,25.77 185.23,25.44 184.96,25.17 182.37,25.17 181.78,25.76 179.28,25.76 178.91,25.39 173.21,25.39 172.41,24.59 169.46,24.59 169.36,24.49 165.72,24.49 165.52,24.69 160.2,24.69 159.68,25.21 156.24,25.21 155.88,25.57 154.04,25.57 153.57,26.04 149.55,26.04 148.96,26.62 v2(148.32,26.62)
  BOTTOM w0.102: CN9.10 189.97,28.88 189.82,28.74 189.82,28.36 189.39,27.93 v2(189.39,26.99)
CNV_RGI_DT: length 136.2
  TOP w0.102: R307.2 86.24,31.69 86.11,31.55 R328.2 85.9,31.62 85.9,32.71 84.64,33.97 84.64,34.4 v2(84.31,34.73)
  IN2 w0.089: v2(196.56,25.94) 196.35,26.15 195.96,26.15 194.83,27.28 194.83,28.61 194.24,29.2 190.88,29.2 190.81,29.13 183.82,29.13 183.62,28.93 182.83,28.93 182.24,28.35 180.56,28.35 178.71,30.2 176.36,30.2 174.83,31.73 167.92,31.73 167.69,31.5 163.87,31.5 163.36,32.01 163.36,32.43 162.95,32.85 162.05,32.85 161.79,33.11 159.83,33.11 159.57,32.85 156.77,32.85 156.42,33.2 152.82,33.2 152.35,33.67 147.8,33.67 147.72,33.6 146.79,33.6 146.37,34.02 146.37,34.53 145.15,35.75 136.64,35.75 135.62,36.77 124.04,36.77 121.75,34.47 119.04,34.47 117.56,32.99 114.4,32.99 113.1,34.29 110.83,34.29 110.39,33.84 106.59,33.84 106.31,33.56 103.63,33.56 101.88,31.81 97.29,31.81 95.97,33.13 85.68,33.13 84.31,34.5 v2(84.31,34.73)
  BOTTOM w0.102: v2(196.56,25.94) 196.48,25.87 196.48,24.98 196.12,24.62 195.92,24.62 195.28,23.99 R786.2 194.77,23.99 194.19,23.4 v1(192.58,23.4) 192.56,23.38 CN9.32
CNV_RGI_DT_R: length 4.4
  TOP w0.102: R307.1 86.21,32.98 85.98,33.2 85.72,33.2 84.85,34.07 84.85,34.92 84.62,35.15 83.95,35.15 v2(83.84,35.05)
  BOTTOM w0.102: v2(83.84,35.05) 83.83,35.06 83.83,35.23 83.64,35.42 U24.DP31
CNV_RGI_RSP: length 132.8
  IN2 w0.089: v2(84.94,35.66) 84.94,34.18 85.77,33.35 96.06,33.35 97.38,32.03 101.79,32.03 103.05,33.29 103.05,34.36 103.57,34.89 106.79,34.89 107.62,34.06 110.3,34.06 110.74,34.51 113.19,34.51 114.49,33.21 117.47,33.21 118.95,34.69 121.66,34.69 123.95,36.98 135.71,36.98 136.73,35.97 145.27,35.97 146.75,34.49 146.75,34.19 147.12,33.81 147.63,33.81 147.71,33.89 152.43,33.89 152.81,33.51 156.71,33.51 157.1,33.9 161.3,33.9 162.14,33.06 163.04,33.06 163.57,32.52 163.57,32.1 163.96,31.72 167.6,31.72 167.83,31.95 174.92,31.95 176.45,30.42 178.8,30.42 180.65,28.56 182.15,28.56 182.74,29.15 183.53,29.15 183.91,29.53 194.65,29.53 195.05,29.13 195.05,27.37 196.01,26.4 196.81,26.4 197.14,26.07 v2(197.14,25.79)
  BOTTOM w0.102: U24.DN29 84.82,35.71 84.89,35.71 v2(84.94,35.66) ; R793.2 193.92,22.95 194.03,22.85 195.73,22.85 196.11,23.23 v1(196.11,23.91) 196.11,24.28 196.73,24.9 196.73,25.39 v2(197.14,25.79)
CNV_RGI_RSP_L: length 2.6
  BOTTOM w0.102: R793.1 193,22.95 192.97,22.97 191.74,22.97 191.65,22.88 CN9.34
CNV_WR_CLK_DN: length 131.1
  IN1 w0.089: v2(178.27,24.18) 178.34,24.18 178.51,24.34 178.51,24.48 178.39,24.6 177.94,24.6 177.84,24.5 177.84,23.81 177.61,23.58 177.11,23.58 176.91,23.79 176.91,24.6 176.79,24.71 176.52,24.71 176.46,24.65 176.46,23.79 176.25,23.58 175.82,23.58 175.61,23.79 175.61,24.33 175.52,24.42 175.25,24.42 175.16,24.33 175.16,23.79 174.95,23.58 170.69,23.58 169.87,24.4 169.54,24.4 169.49,24.35 166.16,24.35 165.46,25.06 160.79,25.06 160.51,25.34 143.63,25.34 143.43,25.13 134.86,25.13 134.71,24.98 127.56,24.98 126.73,25.81 125.09,25.81 125,25.72 125,25.16 124.82,24.98 124.33,24.98 124.15,25.16 124.15,25.72 124.06,25.81 121.19,25.81 120.79,25.41 108.1,25.41 107.76,25.75 107.76,26.11 107.67,26.2 107.46,26.2 107.37,26.11 107.37,25.75 107.16,25.54 106.77,25.54 106.57,25.75 106.57,27.63 106.5,27.7 106.27,27.7 106.17,27.6 106.17,25.75 105.96,25.54 105.58,25.54 105.37,25.75 105.37,26.77 105.28,26.86 105.06,26.86 104.97,26.77 104.97,26.48 104.75,26.26 104.34,26.26 104.12,26.48 104.12,26.77 104.03,26.86 103.11,26.86 102.82,27.15 102.82,28.2 102.14,28.89 101.15,28.89 100.64,29.4 96.25,29.4 95.85,29.8 94.04,29.8 93.76,30.09 93.03,30.09 91.89,31.23 90.13,31.23 89.62,30.72 88.56,30.72 88.45,30.62 85.07,30.62 84.71,30.97 81.48,30.97 79.02,33.44 79.02,35.91 78.74,36.18 78.42,36.18 78.07,35.83 77.34,35.83 77.01,36.16 77.01,36.6 76.95,36.67 76.95,37.16 76.82,37.29 v2(76.58,37.29)
  BOTTOM w0.102: U24.DK44 76.76,37.37 76.68,37.29 v2(76.58,37.29) ; v2(178.27,24.18) 178.44,24.35 178.44,24.69 178.62,24.88 179.36,24.88 179.55,24.69 181.62,24.69 181.94,25.01 181.94,25.69 182.17,25.92 182.31,25.92 182.52,26.13 CN9.21
CNV_WR_CLK_DP: length 131.1
  IN1 w0.089: v2(178.88,24.18) 178.83,24.18 178.71,24.29 178.71,24.56 178.47,24.8 177.85,24.8 177.63,24.58 177.63,23.9 177.52,23.79 177.2,23.79 177.11,23.87 177.11,24.68 176.88,24.91 176.44,24.91 176.26,24.73 176.26,23.87 176.17,23.79 175.9,23.79 175.81,23.87 175.81,24.42 175.6,24.62 175.17,24.62 174.96,24.42 174.96,23.87 174.87,23.79 170.78,23.79 169.96,24.61 169.45,24.61 169.4,24.56 166.25,24.56 165.54,25.26 160.88,25.26 160.6,25.54 143.54,25.54 143.34,25.34 134.77,25.34 134.62,25.18 127.65,25.18 126.81,26.02 125.01,26.02 124.8,25.81 124.8,25.25 124.73,25.18 124.42,25.18 124.35,25.25 124.35,25.81 124.14,26.02 121.1,26.02 120.7,25.62 108.18,25.62 107.97,25.83 107.97,26.19 107.76,26.4 107.37,26.4 107.16,26.19 107.16,25.83 107.07,25.74 106.86,25.74 106.77,25.83 106.77,27.72 106.59,27.9 106.18,27.9 105.97,27.69 105.97,25.83 105.88,25.74 105.66,25.74 105.57,25.83 105.57,26.86 105.37,27.06 104.98,27.06 104.77,26.86 104.77,26.57 104.67,26.47 104.43,26.47 104.33,26.57 104.33,26.86 104.12,27.06 103.19,27.06 103.03,27.23 103.03,28.29 102.22,29.09 101.23,29.09 100.72,29.6 96.34,29.6 95.93,30.01 94.13,30.01 93.85,30.29 93.11,30.29 91.97,31.43 90.04,31.43 89.54,30.92 88.47,30.92 88.37,30.82 85.15,30.82 84.8,31.18 81.57,31.18 79.22,33.53 79.22,35.99 78.83,36.39 78.34,36.39 77.98,36.03 77.43,36.03 77.22,36.24 77.22,36.69 77.15,36.75 77.15,37.25 76.67,37.73 v2(76.67,37.86)
  BOTTOM w0.102: v2(178.88,24.18) 178.66,24.4 178.66,24.6 178.71,24.66 179.27,24.66 179.46,24.47 181.71,24.47 182.15,24.92 182.15,25.6 182.26,25.7 182.35,25.7 182.42,25.63 CN9.23 ; U24.DJ44 77,38.02 76.84,37.86 v2(76.67,37.86)
CNV_WR_LANE0_DN: length 131.1
  IN1 w0.089: v2(180.25,25.18) 180.35,25.18 180.46,25.07 180.46,24.45 180.98,23.94 181.99,23.94 182.21,23.72 182.21,23.32 182.12,23.23 179.4,23.23 179.17,23 177.11,23 176.96,23.15 175.44,23.15 175.3,23.01 173.78,23.01 173.57,22.8 173.57,22.53 173.48,22.44 173.22,22.44 173.13,22.53 173.13,22.8 172.92,23.01 172.48,23.01 172.27,22.8 172.27,22.53 172.19,22.44 171.92,22.44 171.83,22.53 171.83,22.8 171.62,23.01 171.19,23.01 170.98,22.8 170.98,22.53 170.89,22.44 170.62,22.44 170.53,22.53 170.53,22.8 170.32,23.01 169.44,23.01 169.25,23.21 168.48,23.21 168.17,23.53 165.88,23.53 164.92,24.48 159.92,24.48 159.68,24.25 158.12,24.25 157.52,24.85 144.63,24.85 144.48,24.7 137.49,24.7 137.28,24.49 137.28,23.7 137.19,23.61 136.92,23.61 136.84,23.7 136.84,24.49 136.63,24.7 135.49,24.7 135.36,24.57 134.01,24.57 133.63,24.19 133.34,24.19 132.96,24.57 123.94,24.57 123.14,25.37 121.47,25.37 120.96,24.85 119.49,24.85 119.29,24.65 119.29,24.59 119.2,24.5 118.98,24.5 118.89,24.59 118.89,24.8 118.68,25.01 106.62,25.01 106.41,24.8 106.41,24.64 106.33,24.56 106.04,24.56 105.97,24.64 105.97,24.8 105.76,25.01 105.32,25.01 105.11,24.8 105.11,24.64 105.04,24.56 104.75,24.56 104.67,24.64 104.67,25.63 104.44,25.86 102.16,25.86 102.02,25.99 102.02,27.46 100.47,29.01 94.19,29.01 93.76,29.44 93.11,29.44 91.96,30.59 90.36,30.59 89.6,29.83 87.95,29.83 87.81,29.7 85.29,29.7 84.49,30.49 81.39,30.49 78.5,33.38 78.5,34.68 78.22,34.96 78.22,35.24 77.86,35.6 77.27,35.6 76.94,35.27 76.6,35.27 76.15,35.72 76.15,35.86 76.27,35.98 76.42,35.98 76.44,35.98 v2(76.62,35.79)
  BOTTOM w0.102: CN9.15 182.52,27.63 182.24,27.35 182.06,27.35 180.52,25.81 180.52,25.46 v2(180.25,25.18) ; v2(76.62,35.79) 77.17,35.79 77.27,35.68 77.27,35.55 U24.DP44
CNV_WR_LANE0_DP: length 131.1
  IN1 w0.089: v2(76.63,36.39) 76.42,36.18 76.29,36.18 76.19,36.18 75.95,35.94 75.95,35.63 76.52,35.06 77.02,35.06 77.35,35.39 77.78,35.39 78.01,35.16 78.01,34.87 78.29,34.6 78.29,33.3 81.3,30.29 84.41,30.29 85.2,29.49 87.9,29.49 88.03,29.63 89.68,29.63 90.44,30.39 91.88,30.39 93.03,29.24 93.67,29.24 94.1,28.8 100.39,28.8 101.81,27.38 101.81,25.91 102.07,25.65 104.36,25.65 104.46,25.55 104.46,24.55 104.66,24.36 105.12,24.36 105.32,24.55 105.32,24.71 105.41,24.8 105.67,24.8 105.76,24.71 105.76,24.55 105.96,24.36 106.42,24.36 106.62,24.55 106.62,24.71 106.7,24.8 118.6,24.8 118.69,24.71 118.69,24.5 118.9,24.29 119.28,24.29 119.49,24.5 119.49,24.56 119.58,24.65 121.04,24.65 121.56,25.16 123.06,25.16 123.85,24.37 132.88,24.37 133.26,23.99 133.72,23.99 134.1,24.37 135.44,24.37 135.57,24.5 136.54,24.5 136.63,24.41 136.63,23.61 136.84,23.4 137.28,23.4 137.48,23.61 137.48,24.41 137.57,24.5 144.56,24.5 144.71,24.65 157.43,24.65 158.03,24.05 159.77,24.05 160,24.28 164.84,24.28 165.79,23.32 168.08,23.32 168.4,23 169.16,23 169.36,22.81 170.24,22.81 170.33,22.72 170.33,22.44 170.54,22.24 170.97,22.24 171.18,22.44 171.18,22.72 171.27,22.81 171.54,22.81 171.63,22.72 171.63,22.44 171.83,22.24 172.27,22.24 172.48,22.44 172.48,22.72 172.57,22.81 172.83,22.81 172.92,22.72 172.92,22.44 173.13,22.24 173.57,22.24 173.78,22.44 173.78,22.72 173.86,22.81 175.39,22.81 175.53,22.95 176.87,22.95 177.02,22.8 179.26,22.8 179.49,23.02 182.2,23.02 182.41,23.23 182.41,23.81 182.08,24.14 181.06,24.14 180.67,24.53 180.67,25.02 v2(180.83,25.18)
  BOTTOM w0.102: U24.DN44 77.06,36.07 76.74,36.39 v2(76.63,36.39) ; v2(180.83,25.18) 180.74,25.28 180.74,25.72 182.15,27.13 CN9.17
CNV_WR_LANE1_DN: length 131.8
  IN1 w0.089: v2(78.44,38.35) 78.44,38.63 78.5,38.69 78.64,38.69 78.91,38.43 78.91,36.71 79.51,36.11 79.51,33.91 81.8,31.63 88.26,31.63 88.36,31.73 89.72,31.73 89.81,31.82 92.13,31.82 93.19,30.76 94.62,30.76 94.77,30.62 96.18,30.62 96.8,30 100.88,30 101.38,29.5 103.01,29.5 103.44,29.07 105.03,29.07 105.51,28.59 106.46,28.59 108.24,26.81 109.51,26.81 110.3,26.02 120.48,26.02 120.87,26.41 127.08,26.41 127.9,25.59 134.46,25.59 134.64,25.77 142.72,25.77 143.53,26.58 144.73,26.58 145.33,25.98 160.09,25.98 160.41,26.3 165.43,26.3 165.84,25.89 167.11,25.89 168.03,24.98 169.3,24.98 169.35,25.03 170.24,25.03 170.93,24.34 174.24,24.34 174.97,25.08 175.99,25.08 176.22,25.31 177.71,25.31 177.71,25.31 179.23,25.31 179.61,25.69 181.47,25.69 183.13,24.03 183.13,21.39 183.95,20.57 184.48,20.57 184.78,20.87 184.78,21.06 v2(185,21.27)
  BOTTOM w0.102: U24.DG42 78.12,38.67 v2(78.44,38.35) ; CN9.9 184.18,29.13 184.32,28.99 184.6,28.99 185.46,28.13 185.46,27.44 185.66,27.24 185.66,23.23 184.86,22.43 184.86,21.41 v2(185,21.27)
CNV_WR_LANE1_DP: length 131.8
  IN1 w0.089: v2(184.42,21.27) 184.58,21.11 184.58,20.96 184.4,20.77 184.04,20.77 183.34,21.47 183.34,24.11 181.55,25.9 179.53,25.9 179.15,25.51 177.62,25.51 177.62,25.51 176.13,25.51 175.9,25.28 174.89,25.28 174.15,24.55 171.01,24.55 170.33,25.23 169.27,25.23 169.22,25.18 168.11,25.18 167.2,26.1 165.92,26.1 165.52,26.5 160.33,26.5 160.01,26.19 145.41,26.19 144.82,26.78 143.44,26.78 142.63,25.97 134.56,25.97 134.38,25.79 127.99,25.79 127.16,26.61 120.79,26.61 120.4,26.23 110.38,26.23 109.6,27.01 108.32,27.01 106.54,28.79 105.59,28.79 105.12,29.27 103.52,29.27 103.09,29.7 101.47,29.7 100.97,30.2 96.89,30.2 96.27,30.82 94.85,30.82 94.71,30.97 93.28,30.97 92.22,32.03 89.73,32.03 89.63,31.93 88.28,31.93 88.17,31.83 81.88,31.83 79.72,34 79.72,36.19 79.11,36.8 79.11,38.51 78.73,38.9 78.42,38.9 78.06,38.54 77.6,38.54 v2(77.6,38.54)
  BOTTOM w0.102: CN9.11 184.18,28.63 184.32,28.77 184.51,28.77 185.24,28.04 185.24,27.35 185.44,27.15 185.44,23.32 184.64,22.52 184.64,21.5 v2(184.42,21.27) ; v2(77.6,38.54) 77.59,38.54 77.26,38.54 U24.DG44
CNV_WT_CLK_DN: length 131
  IN1 w0.089: v2(77.54,37.01) 77.73,37.2 77.91,37.2 78.14,37.43 78.14,37.88 77.86,38.17 77.26,38.17 76.98,38.44 76.38,38.44 75.82,37.88 75.82,37.8 75.18,37.17 75.18,34.33 75.82,33.69 75.82,31.55 76.47,30.9 77.78,30.9 80.22,28.46 83.19,28.46 83.42,28.22 83.42,27.69 83.87,27.24 85.77,27.24 86.02,27.49 86.44,27.49 86.97,26.96 91.49,26.96 92.3,26.15 94.8,26.15 95.36,25.59 95.36,25.23 98.41,22.18 103.77,22.18 104.05,22.47 114.36,22.47 114.49,22.34 119.06,22.34 119.21,22.49 126.1,22.49 127.43,21.17 133.79,21.17 134.15,21.53 140.79,21.53 141.4,22.13 156.45,22.13 156.55,22.03 164.24,22.03 164.68,21.59 164.68,18.85 165.03,18.5 166.79,18.5 167.1,18.81 167.1,19.04 v2(167.24,19.19)
  BOTTOM w0.079: U24.DL42 77.83,36.72 v2(77.54,37.01)
  BOTTOM w0.102: CN9.71 180.88,13.63 180.52,14 171.73,14 167.24,18.48 v2(167.24,19.19)
CNV_WT_CLK_DP: length 130.8
  IN1 w0.089: v2(77.56,37.59) 77.56,37.59 77.56,37.45 77.63,37.37 77.8,37.37 77.94,37.51 77.94,37.8 77.77,37.96 77.17,37.96 76.9,38.24 76.47,38.24 76.02,37.79 76.02,37.72 75.39,37.08 75.39,34.41 76.02,33.78 76.02,31.63 76.55,31.1 77.87,31.1 80.31,28.66 83.27,28.66 83.63,28.31 83.63,27.77 83.96,27.44 85.69,27.44 85.94,27.7 86.52,27.7 87.06,27.16 91.57,27.16 92.38,26.35 94.89,26.35 95.57,25.67 95.57,25.32 98.5,22.39 103.68,22.39 103.96,22.67 114.45,22.67 114.57,22.54 118.98,22.54 119.13,22.69 126.19,22.69 127.51,21.37 133.71,21.37 134.06,21.73 140.7,21.73 141.31,22.34 156.53,22.34 156.64,22.24 164.32,22.24 164.88,21.68 164.88,18.93 165.11,18.71 166.7,18.71 166.9,18.9 166.9,19.03 166.74,19.19 v2(166.66,19.19)
  BOTTOM w0.079: v2(77.56,37.59) 77.56,37.59 77.43,37.73 77.43,37.88 77.53,37.98 77.68,37.98 78.05,37.62 U24.DK42
  BOTTOM w0.102: v2(166.66,19.19) 167.03,18.82 167.03,18.39 171.64,13.78 180.43,13.78 180.79,13.41 182.22,13.41 182.5,13.13 CN9.73
CNV_WT_LANE0_DN: length 130.7
  IN1 w0.089: v2(76.5,32.12) 76.9,32.52 77.51,32.52 80.76,29.27 83.93,29.27 84.71,28.49 87.96,28.49 88.29,28.16 92.03,28.16 93.19,27 95.47,27 96.79,25.69 96.79,25.34 99.11,23.02 103.46,23.02 103.7,23.27 115.08,23.27 115.17,23.18 118.63,23.18 118.75,23.29 126.44,23.29 127.75,21.98 133.45,21.98 133.81,22.34 140.24,22.34 140.91,23.01 156.75,23.01 156.92,22.84 161.42,22.84 161.63,23.05 164.63,23.05 165.41,22.26 166.84,22.26 167.45,21.65 167.45,21.25 168.45,20.26 170.27,20.26 170.79,20.77 173,20.77 173.11,20.89 177.3,20.89 177.71,21.3 178.48,21.3 179.95,19.82 180.51,19.82 184.35,15.99 185.48,15.99 185.74,15.73 186.29,15.73 186.6,16.04 188.12,16.04 188.38,16.29 188.38,16.52 188.28,16.62 v2(188.17,16.62)
  BOTTOM w0.079: U24.DV45 76.32,33.42 76.43,33.46 76.5,33.43 76.61,33.32 76.61,33.15 76.58,33.12
  BOTTOM w0.102: v2(188.17,16.62) 188.4,16.39 188.4,15.86 187.39,14.85 184.36,14.85 184.08,15.13 CN9.65 ; v2(76.5,32.12) 76.58,32.21 76.58,33.12
CNV_WT_LANE0_DP: length 130.7
  IN1 w0.089: v2(188.76,16.6) 188.58,16.42 188.58,16.21 188.21,15.83 186.68,15.83 186.38,15.53 185.65,15.53 185.4,15.78 184.26,15.78 180.43,19.62 179.87,19.62 178.4,21.09 177.79,21.09 177.39,20.68 173.2,20.68 173.08,20.57 170.88,20.57 170.36,20.05 168.36,20.05 167.25,21.17 167.25,21.56 166.75,22.06 165.33,22.06 164.54,22.85 161.72,22.85 161.51,22.64 156.84,22.64 156.67,22.81 140.99,22.81 140.32,22.13 133.9,22.13 133.54,21.78 127.66,21.78 126.35,23.09 118.83,23.09 118.72,22.97 115.09,22.97 115,23.06 103.78,23.06 103.54,22.82 99.02,22.82 96.58,25.26 96.58,25.6 95.39,26.8 93.1,26.8 91.95,27.95 88.21,27.95 87.87,28.29 84.63,28.29 83.85,29.07 80.67,29.07 77.42,32.32 77.3,32.32 v2(77.11,32.12)
  BOTTOM w0.079: U24.DU45 76.45,33.71 76.49,33.61 76.59,33.57 76.77,33.38 76.77,33.15 76.8,33.12 76.8,33.1
  BOTTOM w0.102: v2(77.11,32.12) 76.8,32.43 76.8,33.1 ; v2(188.76,16.6) 188.62,16.46 188.62,15.77 187.48,14.63 CN9.67
CNV_WT_LANE1_DN: length 131.3
  IN1 w0.089: v2(184.85,17.23) 185.05,17.03 185.05,16.96 184.94,16.85 184.63,16.85 181.71,19.77 181.66,19.77 180.64,20.79 180.16,20.79 178.91,22.03 177.55,22.03 177,21.49 172.85,21.49 172.73,21.37 170.29,21.37 169.94,21.02 169.69,21.02 169.18,21.53 169.18,21.78 168.51,22.44 167.52,22.44 167.09,22.87 165.67,22.87 164.66,23.88 161.5,23.88 161.1,23.48 157.64,23.48 157.34,23.78 138.41,23.78 137.58,22.95 133.43,22.95 133.07,22.59 127.99,22.59 126.64,23.94 123.3,23.94 123.12,24.12 123.12,24.5 122.85,24.77 121.75,24.77 121.17,24.19 121.17,23.98 121.08,23.89 120.84,23.89 120.64,24.09 120.08,24.09 119.88,23.89 118.47,23.89 117.96,24.4 115.11,24.4 114.9,24.19 114.9,23.95 114.81,23.87 114.59,23.87 114.5,23.95 114.5,24.19 114.3,24.4 112.05,24.4 111.85,24.19 111.85,23.95 111.76,23.87 111.54,23.87 111.45,23.95 111.45,24.19 111.24,24.4 110.86,24.4 110.65,24.19 110.65,23.95 110.56,23.87 110.34,23.87 110.26,23.95 110.26,24.19 110.05,24.4 109.66,24.4 109.45,24.19 109.45,23.95 109.36,23.87 109.15,23.87 109.06,23.95 109.06,24.19 108.85,24.4 108.47,24.4 108.26,24.19 108.26,23.95 108.17,23.87 107.95,23.87 107.86,23.95 107.86,24.19 107.66,24.4 107.27,24.4 107.06,24.19 107.06,23.95 106.97,23.87 104.23,23.87 103.54,24.56 101.32,24.56 101.2,24.67 101.2,26.35 100.06,27.5 97.47,27.5 96.89,26.91 96.66,26.91 96.41,27.16 96.41,28.09 96.1,28.41 93.84,28.41 93.41,28.84 92.87,28.84 92.38,29.32 90.23,29.32 89.72,28.82 88.71,28.82 88.42,29.1 84.99,29.1 84.21,29.88 81.14,29.88 77.13,33.9 77.13,34.34 77.38,34.59 77.82,34.59 77.96,34.45 77.96,34.28 77.84,34.15 v2(77.61,34.15)
  BOTTOM w0.102: v2(184.85,17.23) 184.92,17.23 185.04,17.12 185.04,16.74 184.65,16.35 184.36,16.35 184.08,16.63 CN9.59 ; v2(77.61,34.15) 77.49,34.28 77.15,34.28 77.05,34.18 77.05,34.05 U24.DU44
CNV_WT_LANE1_DP: length 131.3
  IN1 w0.089: v2(77.61,34.99) 77.41,34.8 77.3,34.8 76.92,34.42 76.92,33.81 81.05,29.68 84.13,29.68 84.91,28.9 88.34,28.9 88.62,28.61 89.81,28.61 90.32,29.12 92.3,29.12 92.78,28.64 93.32,28.64 93.75,28.2 96.01,28.2 96.21,28.01 96.21,27.07 96.57,26.71 96.97,26.71 97.56,27.29 99.98,27.29 101,26.27 101,24.59 101.23,24.36 103.45,24.36 104.15,23.66 107.06,23.66 107.27,23.87 107.27,24.11 107.35,24.2 107.57,24.2 107.66,24.11 107.66,23.87 107.87,23.66 108.25,23.66 108.46,23.87 108.46,24.11 108.55,24.2 108.77,24.2 108.86,24.11 108.86,23.87 109.06,23.66 109.45,23.66 109.66,23.87 109.66,24.11 109.75,24.2 109.96,24.2 110.05,24.11 110.05,23.87 110.26,23.66 110.65,23.66 110.85,23.87 110.85,24.11 110.94,24.2 111.16,24.2 111.25,24.11 111.25,23.87 111.46,23.66 111.84,23.66 112.05,23.87 112.05,24.11 112.14,24.2 114.21,24.2 114.3,24.11 114.3,23.87 114.51,23.66 114.89,23.66 115.1,23.87 115.1,24.11 115.19,24.2 117.87,24.2 118.39,23.69 119.97,23.69 120.17,23.89 120.55,23.89 120.75,23.69 121.16,23.69 121.37,23.89 121.37,24.11 121.83,24.57 122.77,24.57 122.92,24.41 122.92,24.03 123.22,23.74 126.55,23.74 127.9,22.39 133.16,22.39 133.51,22.74 137.66,22.74 138.5,23.58 157.26,23.58 157.56,23.28 161.18,23.28 161.58,23.68 164.58,23.68 165.58,22.67 167.01,22.67 167.43,22.24 168.42,22.24 168.97,21.69 168.97,21.44 169.6,20.81 170.02,20.81 170.38,21.17 172.82,21.17 172.93,21.28 177.09,21.28 177.63,21.83 178.83,21.83 180.07,20.59 180.55,20.59 181.57,19.57 181.62,19.57 184.54,16.65 185.02,16.65 185.25,16.87 185.25,17.08 v2(185.43,17.26)
  BOTTOM w0.102: U24.DT44 77.2,34.58 v2(77.61,34.99) ; v2(185.43,17.26) 185.25,17.08 185.25,16.65 184.73,16.13 CN9.61
CNV_WT_RCOMP: length 6.2
  TOP w0.254: v2(74.61,31.96) 74.64,31.99 74.64,32.96 v2(76.01,34.33)
  BOTTOM w0.254: v2(74.61,31.96) 74.64,31.94 74.64,30.36 75.22,29.78 R724.1 ; U24.DT45 76.39,34.52 76.19,34.33 v2(76.01,34.33)
CODEC_VREF: length 5.2
  BOTTOM w0.102: U30.28 203.66,36.28 203.52,36.43 203.52,37.45 203.64,37.58 203.64,38.89 C616.2 204.52,39.37 205.01,39.86 v1(205.01,40.04)
CON_DE: length 3.9
  BOTTOM w0.102: U34.15 17.5,24.26 17.26,24.5 16.95,24.5 v1(16.57,24.88) 16.57,25.47 16.47,25.57 R774.2 16.34,25.41 15.97,25.03 R781.1
